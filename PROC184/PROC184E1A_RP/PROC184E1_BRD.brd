# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDA_DLL_0V8: length 106.6
  L14-SIGNAL6 w0.381: 164.45,71.3 165.56,72.41 166.35,72.41 166.91,72.96 v4(166.91,73.8)
  L14-SIGNAL6 w0.508: 165.77,77.76 166.68,78.67 166.68,79.64 166.1,80.22 166.1,84.2 166.75,84.85 167.14,84.85 167.42,85.12 167.42,86.98 166.99,87.41 v11(166.99,90.13) 166.99,97.96 163.55,101.39 161.93,101.39 v2(159.41,103.91) ; 165.77,77.76 165.77,77.72 166.91,76.58 v4(166.91,73.8) ; 165.77,77.76 v11(156.4,77.76) ; 164.45,71.3 164.45,54.99 160,50.55 137.35,50.55 136.46,51.44 v11(136.46,56.8)
  BOTTOM w0.254: U217.1 171.6,89.66 171.13,90.13 v11(166.99,90.13)
VDA_DLL_0V8_N: length 49.7
  TOP w0.127: v2(185.22,42.7) 185.85,42.7 185.99,42.56 R558.2
  L7-SIGNAL3 w0.109: v2(165.81,73.82) 166.33,73.3 167.05,73.3 167.9,72.44 167.9,63.07 166.83,62 164.93,62 164.7,61.78 164.7,56.1 168.85,51.95 170.87,51.95 176.36,46.46 180.05,46.46 184.42,42.09 185.11,42.09 185.22,42.2 v2(185.22,42.7)
VDA_DLL_0V8_P: length 49.5
  TOP w0.127: R562.2 185.99,41.42 185.85,41.28 v2(185.22,41.28)
  L7-SIGNAL3 w0.109: v2(165.81,73.06) 166.9,73.06 167.66,72.3 167.66,63.21 166.69,62.24 164.83,62.24 164.41,61.82 164.41,56.05 168.75,51.72 170.74,51.72 176.25,46.21 179.83,46.21 184.19,41.85 185.11,41.85 185.22,41.75 v2(185.22,41.28)
VDA_DLL_0V8_REG: length 5.7
  TOP w0.305: U68.9 171.32,73.32 171.08,73.57 v4(170.36,73.57)
  BOTTOM w0.381: v4(170.36,73.57) 169.6,72.81 168.31,72.81 168.04,73.08 R1052.3
VDA_DLL_MMC0_0V8: length 42.8
  TOP w0.305: v2(129.12,87.43) 128.72,87.03 U59.AD7
  L14-SIGNAL6 w0.254: v11(136.03,86.24) 138.37,86.24 141.31,89.18 141.31,96.32 143.18,98.18 143.18,98.18 143.71,98.71 143.71,98.72 145.04,100.05 146.18,100.05 148.06,101.93 156.34,101.93 v11(157.4,102.99)
  L14-SIGNAL6 w0.305: v2(129.12,87.43) 130.31,86.24 v11(136.03,86.24) ; v11(157.4,102.99) v11(158.03,102.99)
  BOTTOM w0.254: C762.1 v11(158.03,102.99) 159.41,102.99
VDA_DSITX_0V8: length 24.2
  TOP w0.305: v2(116.32,89.83) 116.72,89.44 U59.AG22 ; v2(115.52,89.83) 115.92,89.44 U59.AG23
  L10-SIGNAL4 w0.152: 114.93,95.29 114.93,93.8 114.66,93.53 114.66,92.1 114.93,91.83 114.93,91.4 114.74,91.21 114.74,90.79 115.17,90.37 115.33,90.37 115.52,90.18 v2(115.52,89.83)
  L10-SIGNAL4 w0.254: v2(117.79,106.4) 117.18,105.79 117.18,104.55 116.32,103.7 116.32,99.21
  L10-SIGNAL4 w0.305: v2(116.32,89.83) v2(115.52,89.83) ; 116.32,99.21 114.93,97.82 114.93,95.29
  BOTTOM w0.381: FL87.2 116.73,107.51 116.23,107 116.21,107 116.82,106.4 v2(117.79,106.4)
  BOTTOM w0.508: C747.1 116.23,107
VDA_DSITX_1V8: length 27.4
  TOP w0.305: v2(115.52,89.03) 115.92,88.64 U59.AF23 ; v2(116.32,89.03) 116.72,88.64 U59.AF22
  L10-SIGNAL4 w0.152: 114.05,94.36 114.13,94.28 114.13,91.39 114.44,91.08 114.44,90.7 115.12,90.02 115.12,89.43 v2(115.52,89.03)
  L10-SIGNAL4 w0.254: v2(115.38,99.62) 114.78,100.22 114.78,110.8 v2(114.13,111.45)
  L10-SIGNAL4 w0.305: v2(115.38,99.62) 114.05,98.3 114.05,94.36 ; v2(116.32,89.03) v2(115.52,89.03)
  BOTTOM w0.381: FL70.2 v2(114.13,111.45)
VDA_MCU_1V8: length 230
  TOP w0.254: U124.5 v2(168.03,31.45)
  TOP w0.305: v2(113.12,76.23) 113.51,76.63 U59.L26 ; U59.K24 115.11,75.83 v2(114.72,75.43) ; v2(112.32,74.63) 112.71,75.03 U59.J27 ; v2(113.12,75.43) 113.51,75.83 U59.K26
  TOP w0.381: TP134.1 167.05,77.3 v4(167.17,77.3)
  L3-SIGNAL1 w0.381: v2(173.36,77.27) 173.34,77.3 167.17,77.3 v4(167.17,77.3)
  L5-SIGNAL2 w0.381: v2(172.28,16.78) 171.39,16.78 164.4,9.79 117.66,9.79 108.99,18.46 67.79,18.46 63.11,23.13 55.85,23.13 53.63,25.36 50.61,25.36 43.85,32.11 37.9,32.11 34.4,35.62 34.4,39.53 32.21,41.71 20.06,41.71 v2(17.98,43.79)
  L7-SIGNAL3 w0.381: v2(168.03,31.45) 168.03,37.45 165.74,39.73 v2(165.74,41.05)
  L8-PWR1 w0.508: v4(167.17,77.3) 170.42,77.3
  L14-SIGNAL6 w0.381: v2(172.28,16.78) 169.83,19.24 169.83,26.62 172.58,29.36 172.58,30.84 171.96,31.45 v2(168.03,31.45)
  BOTTOM w0.254: v2(179.28,71) 179.13,70.85 R1062.2 ; R1033.2 173.38,77.3 173.36,77.29 v2(173.36,77.27) ; C1175.2 v2(168.03,31.45) 168.36,31.12 168.36,29.45 168.08,29.17 C1183.1 C1184.1 U258.5 ; v2(17.98,43.79) U252.5
  BOTTOM w0.305: v2(99.45,70.29) 99.45,69.68 C1045.1
  BOTTOM w0.457: v4(167.17,77.3) 166.91,77.04 R1044.2
  vias: v2(100.95,74.96) v2(110.63,61.8) v2(113.44,67.42) v2(113.44,65.87) v2(114.28,67.42) v2(114.28,65.87) v2(114.33,62.91)
VDA_MCU_1V8_N: length 50.3
  TOP w0.127: R573.2 174.72,40.29 174.85,40.43 v2(174.85,41.03)
  L7-SIGNAL3 w0.109: v2(174.85,41.03) 174.54,41.03 174.36,40.86 174.36,40.1 173.43,39.16 173.23,39.16 173.23,39.16 168.34,39.16 167.21,40.29 167.21,45.27 161.97,50.52 161.97,72.19 v2(165.81,76.03)
VDA_MCU_1V8_P: length 48.8
  TOP w0.127: R572.2 173.58,40.28 173.44,40.41 v2(173.44,41.03)
  L7-SIGNAL3 w0.109: v2(165.81,75.27) 162.23,71.68 162.23,50.59 167.45,45.37 167.45,40.45 168.5,39.4 173.33,39.4 174.13,40.19 174.13,40.93 174.02,41.03 v2(173.44,41.03)
VDA_MCU_1V8_REG: length 166.5
  TOP w0.254: v2(84.11,38.36) 83.66,38.36 83.45,38.57 U104.1 ; v2(84.11,35.69) 83.66,35.69 83.45,35.91 U110.1
  TOP w0.305: v4(170.36,75.09) 170.36,75 171.03,74.32 U68.7
  L9-PWR2 w0.381: v4(170.36,75.09) 170.36,74.47 171.73,73.1 171.73,71.91 172.92,70.71 176.07,70.71 176.52,70.26 179.54,70.26 183.65,66.15 183.65,42.21 172.73,31.29 172.73,30.18 170.6,28.04 165.7,28.04 165.48,27.82 162.06,27.82 161.58,28.3 139.16,28.3 138.45,27.59 129.42,27.59 128.66,28.35 125.15,28.35 124.09,27.29 109.71,27.29 108.64,28.35 94.06,28.35 93.13,29.28 93.13,30.14 84.92,38.36 v2(84.11,38.36) 83.37,37.62 83.37,36.43 v2(84.11,35.69)
  BOTTOM w0.381: R1044.3 167.76,75.29 168.64,74.4 169.67,74.4 v4(170.36,75.09)
VDA_PHY_1V8: length 160
  TOP w0.254: v2(176.41,50.34) 176.45,50.38 U87.3
  L5-SIGNAL2 w0.381: v2(170.58,103.02) 183.49,103.02 184.92,101.58 184.92,95.44 186.53,93.84 186.53,82.41 185.4,81.29 182.2,81.29 180.07,79.15 180.07,73.87 180.63,73.31 181.9,73.31 184.29,70.92 184.29,56.92 179.85,52.48 178.9,52.48 176.76,50.34 v2(176.41,50.34)
  L9-PWR2 w0.381: v2(155.95,103.91) 157.87,105.83 157.87,110.79 156.93,111.73 155.15,111.73 154.26,112.62 154.26,115.65 150.65,119.26 114.33,119.26 113.62,119.97 111.82,119.97 110.18,118.33 109.49,118.33 108.44,117.28 104.28,117.28 103.67,116.67 103.67,112.76 105.6,110.83 v2(107.15,110.83)
  BOTTOM w0.254: FL81.1 106.51,110.04
  BOTTOM w0.381: FL82.1 v2(132.01,111.18)
  vias: v2(114.13,113.75) v2(122.49,113.75) v2(129.6,113.75) v4(107.78,110.83) v4(107.78,110.04)
VDA_PHY_1V8_N: length 20
  L7-SIGNAL3 w0.109: v2(95.88,122.63) 95.49,122.24 95.49,121.44 95.79,121.14 96.25,121.14 v2(105.85,111.54)
  BOTTOM w0.127: v2(95.88,122.63) 95.28,122.03 94.6,122.03 TP265.1 93.37,122 93.08,122 R909.2
VDA_PHY_1V8_P: length 17.7
  L7-SIGNAL3 w0.109: v2(105.85,112.27) 105.65,112.27 96.24,121.68 v2(95.93,121.68)
  BOTTOM w0.127: v2(95.93,121.68) 94.47,121.68 TP270.1 93.46,121.76 93.14,121.76 R910.2
VDA_PHY_1V8_PG: length 4.6
  TOP w0.127: R1298.2 111.51,118.73 TP52.1 110.46,118.36 R209.1 109.41,118.23 109.41,118.02 109.2,117.81 U41.5
VDA_PHY_1V8_REG: length 6.8
  TOP w0.254: 107.03,112.27 107.03,113.83 v2(107.15,113.95)
  L14-SIGNAL6 w0.254: v2(107.15,113.95) 107.91,114.71 107.91,117.57 v2(108.7,118.36)
VDA_PLL_1V8: length 87.1
  TOP w0.203: v2(177.1,52.9) 176.88,52.68 176.59,52.68 176.41,52.5 C330.1
  TOP w0.254: U87.1 177.09,51.38 C330.1 ; v4(88.57,83.62) 88.19,83.25 R377.2 ; v4(90.5,83.62) 90.5,83.11 TP120.1
  TOP w0.305: U59.AD20 118.32,87.04 v2(117.92,87.43) ; v2(113.92,82.63) 114.32,82.24 U59.V25 ; v2(114.72,82.63) 115.12,82.24 U59.V24 ; v2(114.72,84.23) 115.12,83.84 U59.Y24 ; U59.M10 126.32,77.43 v2(126.72,77.03) ; v2(126.72,75.43) 126.32,75.83 U59.K10 ; v2(118.72,77.83) 119.11,78.23 U59.N19 ; v2(117.12,83.43) 117.52,83.04 U59.W21 ; U59.AC11 125.52,86.23 v2(125.92,86.63) ; U59.T12 124.72,80.63 v2(125.12,80.23) ; v2(117.12,81.03) 117.51,81.43 U59.U21 ; U59.AB16 v2(121.92,85.83) ; v2(124.32,75.43) 123.92,75.83 U59.K13 ; v2(113.92,83.43) 114.32,83.04 U59.W25 ; v2(113.12,82.63) 113.52,82.24 U59.V26 ; v2(112.32,76.23) 112.71,76.63 U59.L27 ; U59.AE11 125.52,87.83 v2(125.92,88.23)
  L10-SIGNAL4 w0.127: v2(126.72,75.43) 126.3,75.02 126.3,72.54 126.5,72.34 126.5,71.45 126.83,71.12 127.08,71.12
  L10-SIGNAL4 w0.203: 127.08,71.12 133.4,71.12 147.61,56.92 147.61,51.84 150.68,48.77 155.09,48.77 155.34,48.51 161.81,48.51 162.7,49.41 168.15,49.41 168.84,48.72 176.53,48.72 177.1,49.29 v2(177.1,52.9)
  BOTTOM w0.254: C969.1 126.88,75.27 v2(126.72,75.43) ; v2(125.12,80.23) 125.27,80.39 C878.1
  vias: v2(102.37,85.3) v4(89.53,83.62)
VDA_PLL_1V8_N: length 26.5
  L7-SIGNAL3 w0.109: v2(71.36,79.14) 71.36,78.61 71.73,78.24 73.87,78.24 74.39,78.77 76.6,78.77 78.09,77.27 84.36,77.27 85.25,76.38 85.47,76.17 86.89,76.17 87.51,76.78 88.27,76.78 88.65,77.17 88.65,81.39 88.4,81.64 88.25,81.64 v2(88.18,81.58)
  BOTTOM w0.127: R1031.2 70.42,78.59 71.24,78.59 71.36,78.72 v2(71.36,79.14)
VDA_PLL_1V8_P: length 28.1
  L7-SIGNAL3 w0.109: v2(71.36,77.73) 71.64,78.01 73.97,78.01 74.44,78.48 76.45,78.48 77.89,77.04 84.26,77.04 85.08,76.22 85.37,75.93 86.99,75.93 87.61,76.55 88.37,76.55 88.98,77.16 88.98,81.72 88.6,82.1 87.84,82.1 87.45,81.71 87.45,81.61 v2(87.42,81.58)
  BOTTOM w0.127: R1036.2 70.42,78.28 71.24,78.28 71.36,78.16 v2(71.36,77.73)
VDA_PLL_1V8_PG: length 3.4
  TOP w0.127: U63.5 85.31,77.93 v2(85.18,77.8)
  BOTTOM w0.127: R1296.1 86,78.68 85.79,78.47 85.79,78.06 85.53,77.8 v2(85.18,77.8)
VDA_PLL_1V8_REG: length 6.5
  TOP w0.254: R1295.2 84,83.38 84.21,83.59 85.39,83.59 86.18,82.8 C256.1
  BOTTOM w0.254: R1296.2 86.52,82.33 v2(86.89,82.69)
VDA_PLL_DDR0_0V8: length 32.9
  TOP w0.305: U59.P8 127.92,79.03 v2(128.32,78.63)
  L14-SIGNAL6 w0.152: 129.55,78.31 129.47,78.23 128.72,78.23 v2(128.32,78.63)
  L14-SIGNAL6 w0.254: v2(153.02,79.28) 153.5,79.76 154.46,79.76 154.48,79.74
  L14-SIGNAL6 w0.305: 129.55,78.31 130.92,78.31 131.47,77.76 v2(155.4,77.76) 155.4,79.44 v2(155.48,79.53) 154.69,79.53 154.48,79.74
  BOTTOM w0.254: v2(128.32,78.63) 128.16,78.47 C947.1
VDA_PLL_DDR1_0V8: length 3.6
  TOP w0.305: U59.J11 125.52,75.03 v2(125.92,74.63)
  L14-SIGNAL6 w0.305: v11(136.46,57.82) v11(137.98,57.82)
  BOTTOM w0.254: C1077.1 138.04,57.79 C1093.1
VDA_SERDES0_1_0V8: length 2.3
  TOP w0.305: U59.AG10 126.32,89.43 v2(126.72,89.83) ; v2(125.12,89.03) 124.72,88.63 U59.AF12 ; U59.AG13 123.92,89.43 v2(124.32,89.83)
  BOTTOM w0.254: FL83.2 v2(135.57,106.96)
  vias: v2(135.57,106.4) v2(135.59,103.93) v2(135.59,101.95)
VDA_SERDES0_1_1V8: length 4.9
  TOP w0.305: U59.AG11 125.52,89.43 v2(125.92,89.83) ; U59.AG12 124.72,89.43 v2(125.12,89.83)
  BOTTOM w0.381: 130.44,107 130.45,107 130.96,107.51 FL82.2 ; 130.44,107 131.04,106.4 v2(132.01,106.4) ; 130.44,107 C742.1
VDA_SERDES4_0V8: length 4.9
  TOP w0.305: v2(122.72,89.83) 122.32,89.43 U59.AG15 ; U59.AG16 121.52,89.43 v2(121.92,89.83)
  BOTTOM w0.381: 126.88,107 126.89,107 127.4,107.51 FL84.2 ; 126.88,107 127.49,106.4 v2(128.46,106.4) ; 126.88,107 C744.1
VDA_SERDES4_1V8: length 37.9
  TOP w0.305: U59.AG21 117.52,89.44 v2(117.12,89.83) ; v2(122.72,89.03) 122.32,88.63 U59.AF15
  L10-SIGNAL4 w0.152: v2(117.12,89.83) U59.AG21 117.52,88.87 117.75,88.63 120.87,88.63 121.42,89.18 121.42,89.69 121.68,89.43 122.32,89.43 v2(122.72,89.03)
  L10-SIGNAL4 w0.254: v2(126.74,99.62) 125.9,98.78 125.19,98.78 120.79,94.38 120.79,92.99 121.09,92.69 121.09,91.64 120.71,91.26 120.71,90.72 121.42,90.01 121.42,89.69
  L10-SIGNAL4 w0.305: v4(128.46,111.45) 129.01,110.89 129.01,109.07 127.9,107.95 127.9,102.97 126.22,101.3 126.22,100.14 v2(126.74,99.62)
  BOTTOM w0.381: v4(128.46,111.45) C724.1 FL65.2
VDA_SERDES_C0_1_0V8: length 1.1
  TOP w0.305: U59.AF13 123.92,88.63 v2(124.32,89.03) ; U59.AF10 126.32,88.63 v2(126.72,89.03)
  vias: v10(132.55,87.25) v10(134.3,87.25) v10(136.03,87.26) v10(146.16,101.75) v10(146.9,101.78) v11(132.55,87.25) v11(134.3,87.25) v11(136.03,87.26) v11(146.16,101.75) v11(146.9,101.78)
VDA_SERDES_C4_0V8: length 31.6
  TOP w0.305: U59.AE15 122.32,87.83 v2(122.72,88.23) ; U59.AF16 v2(121.91,89.03)
  L10-SIGNAL4 w0.254: v4(126.04,111.45) 125.54,110.94 125.54,102.79 124.98,102.24 123.43,102.24 122,100.81 122,100.11 v2(122.49,99.62)
  L14-SIGNAL6 w0.254: v2(122.72,88.23) 122.71,88.23 v2(121.91,89.03) 119.2,91.74 119.2,96.74 122.08,99.62 v2(122.49,99.62)
  BOTTOM w0.381: v4(126.04,111.45) FL66.2
VDA_UFS_0V8: length 36.9
  TOP w0.305: v2(127.52,89.03) 127.12,88.63 U59.AF9
  L14-SIGNAL6 w0.457: 130.6,89.97 130.12,90.45
  L14-SIGNAL6 w0.508: 130.6,89.97 131.81,89.97 132.44,89.34 v11(136.03,89.34) 136.69,89.34 138.69,91.34 138.69,98.26 143.42,102.99 v11(150.49,102.99) v11(151.13,102.99) ; 130.12,90.45 128.06,90.45 127.52,89.9 v2(127.52,89.03)
  BOTTOM w0.127: C855.1 127.91,90.17 127.91,89.43 v2(127.52,89.03)
VDA_UFS_1V8: length 39.6
  TOP w0.305: U59.AG8 127.92,89.43 v2(128.32,89.83)
  L14-SIGNAL6 w0.152: 129.65,89.28 129.5,89.43 128.72,89.43 v2(128.32,89.83)
  L14-SIGNAL6 w0.305: v11(154.58,102.99) v11(153.95,102.99) 153.42,102.47 143.64,102.47 139.28,98.11 139.28,90.75 136.82,88.3 v11(136.03,88.3) 131.47,88.3 130.49,89.28 129.65,89.28
  BOTTOM w0.254: FL96.1 v11(154.58,102.99) C763.1
VDA_USB_0V8: length 24.2
  TOP w0.305: U59.AG17 120.72,89.44 v2(120.32,89.83)
  L14-SIGNAL6 w0.152: v2(120.32,89.83) 119.92,90.23 118.47,90.23 118.17,90.54
  L14-SIGNAL6 w0.305: v2(121.34,106.4) 120.79,105.84 120.79,99.95 117.89,97.05 117.89,90.82 118.17,90.54
  BOTTOM w0.381: v2(121.34,106.4) 120.37,106.4 119.77,107 119.78,107 120.29,107.51 FL86.1
  BOTTOM w0.508: C746.1 119.78,107
VDA_USB_1V8: length 24.3
  TOP w0.305: U59.AH19 119.12,90.24 v2(118.72,90.63)
  L14-SIGNAL6 w0.203: v2(121.34,99.62) 121.9,100.18 121.9,110.87 v4(122.49,111.45)
  L14-SIGNAL6 w0.254: v2(118.72,90.63) 118.72,96.99 v2(121.34,99.62)
  BOTTOM w0.381: v4(122.49,111.45) FL67.1
VDA_USB_3V3: length 31.7
  TOP w0.305: U59.AF17 120.72,88.64 v2(120.32,89.03)
  L10-SIGNAL4 w0.254: v2(123.73,99.62) 123.73,97.86 120.33,94.46 120.33,92.81 120.58,92.55 120.58,92 120.25,91.67 120.25,90.58 120.88,89.95 120.88,89.59 v2(120.32,89.03)
  L14-SIGNAL6 w0.254: v2(123.73,99.62) 123.11,100.24 123.11,114.65 v2(122.53,115.23)
  BOTTOM w0.381: R923.2 v2(122.53,115.23)
VDA_USB_3V3_N: length 36.3
  L7-SIGNAL3 w0.109: v2(151.53,124.67) 150.48,123.62 124.11,123.62 122.09,121.59 122.09,121.05 v2(122.57,120.57)
  BOTTOM w0.127: R887.2 151.98,126.1 151.62,125.73 151.62,125.26 TP261.1 v2(151.53,124.67) ; R923.1 122.53,120.01 122.6,120.08 122.6,120.31 122.57,120.35 v2(122.57,120.57)
VDA_USB_3V3_P: length 35.3
  L7-SIGNAL3 w0.109: v2(150.27,124.6) 149.52,123.85 124.01,123.85 121.85,121.69 121.85,121.08 v2(121.34,120.57)
  BOTTOM w0.127: v2(121.34,120.57) 121.34,120.39 121.81,119.93 R923.4 ; R888.2 150.87,126.09 151.24,125.72 151.24,125.24 TP262.1 150.32,124.67 v2(150.27,124.6)
VEXP_3V3: length 15.9
  L3-SIGNAL1 w0.254: v3(216.03,111.6) 217.04,111.6 219.26,113.82 219.26,122.27 217.89,123.64 217.89,124.34 217.64,124.59 v3(217.34,124.59)
VEXT_1V8_RAIL_MON3: length 1.9
  BOTTOM w0.127: R1097.1 TP318.1
VEXT_1V8_RAIL_MON4: length 1.5
  BOTTOM w0.127: TP312.1 97.18,73.69 R1050.1
VEXT_3V3_RAIL_MON5: length 3.7
  BOTTOM w0.127: R1046.1 98.17,75.06 97.77,75.45 96.58,75.45 96.08,74.96 96.08,74.58 TP313.1
VLDO_CSI_1V8: length 1.4
  BOTTOM w0.305: U265.5 R1241.1
VLDO_CSI_3V3: length 1.6
  BOTTOM w0.305: R1240.1 179.98,24.37 U265.6
VMAIN: length 67.6
  L3-SIGNAL1 w0.305: v2(206.78,138.72) 208.45,138.72 v2(210.79,136.38) 212.66,138.25 v2(212.66,138.93) ; v2(194.17,189.04) 196.21,187 198,187 199.75,185.25 199.75,184.08 205.33,178.51 205.33,162.68 209.89,158.12 TP20.1
  L7-SIGNAL3 w0.381: 230.46,159.93 233.33,159.93 234.48,161.07 234.48,166.87 v2(237.39,169.78)
  BOTTOM w0.254: U182.2 210.62,137.33 210.8,137.15 210.79,137.14 v2(210.79,136.38) 210.79,135.68 210.48,135.38 R850.1
  vias: v12(213.8,152.59) v12(213.8,148.53) v12(216.34,152.59) v12(216.34,148.53) v12(218.88,152.59) v12(218.88,148.53) v12(224.13,156.27) v12(224.13,152.71) v12(224.13,149.16) v12(226.16,154.49) v12(226.16,150.93) v12(226.16,147.38) v12(228.19,156.27) v12(228.19,152.71) v12(228.19,149.16) v12(230.23,154.49) v12(230.23,150.93) v12(230.23,147.38)
VMAIN_CONN:
  vias: v12(207.72,181.34) v12(207.72,179.56) v12(209.49,181.34) v12(209.49,179.56) v12(211.27,183.12) v12(211.27,181.34) v12(211.27,179.56) v12(214.74,173.95) v12(214.74,172.17) v12(214.74,170.39) v12(216.52,173.95) v12(216.52,172.17) v12(216.52,170.39) v12(218.25,173.5) v12(218.25,171.47) v12(218.3,175.72) v12(220.07,175.72) v12(220.28,173.5) v12(220.28,171.47) v12(222,175.72) v12(222,173.95) v12(222,172.17) v12(222,170.39) v12(225.91,175.72) v12(225.91,173.95) v12(225.91,172.17) v12(225.91,170.39) v12(227.69,175.72) v12(227.69,173.95) v12(227.69,172.17) v12(227.69,170.39)
VMAIN_FUSE: length 7.3
  TOP w0.254: 208.82,167.6 206.52,167.6 206.03,167.1 206.03,163.6 206.28,163.35 U16.1
  vias: v12(212.96,168.08) v12(214.74,168.08) v12(214.74,166.3) v12(216.52,168.08) v12(216.52,166.3) v12(216.52,164.52) v12(218.25,167.12) v12(218.25,165.09) v12(220.23,162.75) v12(220.28,167.12) v12(220.28,165.09) v12(222,168.08) v12(222,166.3) v12(222,164.52) v12(222,162.75) v12(223.78,168.08) v12(223.78,166.3) v12(223.78,164.52) v12(223.78,162.75) v12(225.91,168.08) v12(225.91,166.3) v12(225.91,164.52) v12(225.91,162.75) v12(227.69,168.08) v12(227.69,166.3) v12(227.69,164.52) v12(227.69,162.75)
VPLL_1V8_EDP: length 3.6
  TOP w0.305: C139.2 v2(108.02,134.94)
  TOP w0.381: v2(108.02,134.94) 108.02,135.62 107.73,135.91 FL7.2
  BOTTOM w0.254: U187.42 v2(108.02,134.94)
VPP_CORE_1V8: length 16.1
  TOP w0.305: v2(99.63,82.84) 99.12,82.33 TP122.1 ; v2(110.72,82.63) 111.12,82.24 U59.V29
  L10-SIGNAL4 w0.305: v2(99.63,82.84) 100.14,83.34 108.28,83.34 108.93,82.7 110.65,82.7 v2(110.72,82.63)
VPP_EFUSE_1V8: length 29.4
  L8-PWR1 w0.381: v2(98.13,82.84) 98.93,82.03 98.93,78.78 97.95,77.79 97.95,73.71 97.67,73.44 97.67,71.31 98.42,70.56 v2(98.42,68.36)
  L9-PWR2 w0.381: v4(90.48,74.39) 89.78,74.39 88.97,73.58 88.97,73.08 92.55,69.5 97.28,69.5 v2(98.42,68.36)
VPP_MCU_1V8: length 5.2
  TOP w0.305: TP155.1 96.89,65.39 99.82,68.32 v2(99.82,68.36) ; U59.F26 113.51,72.63 v2(113.12,72.23)
VREF2_CSI: length 4.8
  TOP w0.254: C339.1 R522.2 ; C339.1 204.43,49.41 204.59,49.25 U88.8 ; C339.1 U88.7
VREF2_EDP_I2C: length 4.5
  TOP w0.305: C55.2 127.17,163.47 U20.8 ; C55.2 U20.7 ; C55.2 R71.2
VRTC_PMIC_1V8: length 6.2
  TOP w0.254: TP310.1 167.63,76.73 168.24,77.33 170.11,77.33 170.36,77.09 C271.1 170.52,76.32 U68.3
VSENSE: length 24.3
  TOP w0.127: TP163.1 v2(98.25,59.98)
  L3-SIGNAL1 w0.089: v3(111.12,76.63) v5(110.89,76.35)
  L4-GND2 w0.102: v5(110.89,76.35) v7(110.58,76.05)
  L7-SIGNAL3 w0.109: v2(98.25,59.98) 97.8,60.43 97.8,61.04 103.03,66.27 103.03,69.63 108.03,74.63 108.03,74.98 109.56,76.51 110.13,76.51 v7(110.58,76.05)
  vias: v1(111.12,76.63)
VSYS3V3_MON_CT: length 1.5
  TOP w0.127: C435.1 U131.4
VSYS3V3_MON_MR#: length 1.5
  TOP w0.127: U131.3 R631.2
VSYS3V3_MON_RESET#: length 1.6
  TOP w0.127: U131.1 161.41,28.08 161.16,28.33 R618.1
VSYS_3V3: length 307.2
  TOP w0.203: v2(186.49,47.68) 186.49,47.68 185.87,48.3 R1317.2 ; U64.B3 v2(196.26,74.37) ; v2(184.26,45.95) 184.26,45.06 185.1,44.22 R1318.2 ; U116.C3 169.54,33.98 v2(169.43,33.86) ; U105.C3 192.28,37.51 191.73,36.96 v2(191.42,36.96) ; R1315.2 v2(183.55,40.13) ; U93.C3 192.28,46.03 192.74,45.57 v2(192.85,45.57) ; v2(177.55,34.54) 178.12,33.98 U121.C3
  TOP w0.254: R102.1 146.25,156.78 149.24,156.78 149.68,156.34 ; U131.5 166.12,27.13 v2(166.35,27.36) C426.2 U131.6 ; R142.2 v2(12.27,148.5) 12.27,147.86 12.6,147.53 14.32,147.53 14.63,147.84 ; R612.2 227.21,30.66 227.03,30.84 227.03,31.82 227.2,31.99 v2(227.76,31.99) U113.8 ; U130.5 v2(230.69,27.97) ; U125.4 v2(118.99,31.01) ; v2(45.89,45.74) R548.1 v2(45.89,48.28) R529.1 v2(45.89,50.82) R502.1 v2(45.89,53.36) R483.1 ; v2(11.96,166.93) C43.1 11.96,167.79 12.54,168.37 U10.1 ; U113.6 v2(226.76,34.17) ; U98.20 v2(221.12,42.37) ; R116.1 13.77,155.4 13.95,155.58 13.95,155.98 14.1,156.14 v2(14.65,156.14) 14.65,156.63 14.65,156.64 14.65,157.37 14.4,157.63 U19.16 ; v2(238.92,22.21) R653.2 R661.2 R664.2 ; v2(224.66,28.73) 224.01,28.73 223.71,29.04 U123.5 ; v2(224.66,28.73) 224.66,28.17 224.94,27.88 R623.2 ; v2(224.66,28.73) U123.6 ; R60.1 R61.1 R62.1 v2(14.28,166.14) ; R137.2 R143.2 14.63,147.84 ; 14.63,147.84 15.13,147.35 16.6,147.35 v2(17.14,147.89) ; R631.1 v2(159.79,26.91) ; v2(45.89,68.18) R435.1 R441.1 R450.1 R454.1 v2(45.89,61.83) R467.1 R474.1 ; U122.5 v2(163.51,31.96) ; R614.2 v2(160.72,29.49) ; R590.1 v2(228.99,34.75) ; R585.1 v2(224.85,35.25)
  TOP w0.305: R1303.2 v2(12.05,136.94)
  L3-SIGNAL1 w0.305: v2(201.78,156.1) 201.78,152.54 201.36,152.12 201.36,146.35 v2(202.96,144.75) ; v2(64.05,126.99) 59.87,122.81 v2(59.34,122.81)
  L3-SIGNAL1 w0.381: v2(46.45,41.75) 45.9,41.19 43.83,41.19 43.45,41.58 40.4,41.58 37.7,44.28 27.72,44.28 26.95,45.06 24.11,45.06 23.06,44.01 23.06,42.98 22.54,42.46 20.73,42.46 v2(19.4,43.79) ; v2(218.58,110.4) 223.38,110.4 238.04,125.05 v2(241.29,125.05)
  L5-SIGNAL2 w0.381: v2(19.4,43.79) 18.7,44.49 18.7,46.06 16.5,48.26 v2(13.35,48.26) ; v2(98.45,65.18) 95.79,65.18 95.28,64.67 93.32,64.67 v2(93.01,64.97)
  L7-SIGNAL3 w0.203: v2(93.01,64.97) 93.01,65.43 93.05,65.47 93.05,68.68 91.22,70.51 91.22,70.97 90.66,71.53 87.61,71.53 85.89,69.8 79.38,69.8 77.55,67.97 74.91,67.97 72.55,65.61 70.72,65.61 70.25,65.14 v2(69.06,65.14)
  L7-SIGNAL3 w0.305: v2(159.44,161.77) 161.95,161.77 163.85,159.87 163.85,157.02 v12(162.7,155.87)
  L10-SIGNAL4 w0.381: v2(11.96,166.93) 12.46,166.43 13.98,166.43 v2(14.28,166.14) 13.7,165.57 13.7,157.08 v2(14.65,156.14) 12.27,153.76 v2(12.27,148.5) 12.41,148.35 12.41,140.57 12.05,140.21 v2(12.05,136.94) 12.05,134.76 v2(13.38,133.43)
  L13-GND5 w0.203: v9(63.04,73.58) v7(63.04,73.16)
  L14-SIGNAL6 w0.203: v11(63.04,73.93) v9(63.04,73.58)
  BOTTOM w0.203: U192.B3 86.56,121.78 v2(86.23,121.45) ; v2(62.44,66.87) 63.3,66.87 64.3,67.88 U231.C3 ; v2(196.62,84.5) 196.53,84.5 196.53,84.48 196.26,84.21 U211.B3 ; v2(195.77,100.3) 196.2,99.87 U207.C3 ; U222.B3 63.9,83.6 63.7,83.39 63.32,83.39 62.98,83.73 U221.2 ; U230.B3 63.9,73.85 63.72,73.67 63.3,73.67 v11(63.04,73.93)
  BOTTOM w0.254: v2(60.75,83.73) U221.2 ; U243.31 v2(56.52,56.2) 56.52,55.79 56.77,55.53 57.08,55.53 57.27,55.34 R1135.2 ; v2(160.72,29.49) 160.59,29.62 U255.5 ; U269.14 v2(232.3,14.72) ; U186.4 v2(85.07,129.69) ; U244.1 C1117.1 v2(54.8,49.38) ; C1206.2 60.31,24.21 C1203.2 U266.4 ; U251.5 v2(19.4,43.79) ; v2(54.66,44.71) C1131.2 55.14,45.37 55.14,45.37 U248.1 ; R939.2 218.37,110.19 v2(218.58,110.4) ; R1316.2 v2(69.06,65.14) ; U233.1 55.49,65.84 56.14,65.18 C1064.1 57.56,65.18 v2(57.75,64.99) 57.75,64.35 56.66,63.25 R1109.2 ; v2(130.71,25.35) C1268.1 U278.5 ; R1301.2 130.04,23.83 v2(130.04,24.35) ; R827.2 v2(17.14,147.89) ; v2(203.79,58.83) 203.97,58.66 R1131.2 ; R817.2 202.28,155.59 v2(201.78,156.1) ; R834.1 203.15,144.09 202.96,144.28 v2(202.96,144.75) 202.46,145.25 R828.2 ; U188.B3 58.94,123.21 v2(59.34,122.81) U188.C3 ; U247.5 v2(13.35,48.26) ; U243.27 v2(55.99,58.2) ; U268.16 230.2,23.57 230.38,23.75 v2(230.38,24.26) ; U253.5 v2(46.45,41.75)
  vias: v2(14.29,133.43) v2(15.2,133.43) v2(30.44,127.07) v2(30.44,126.31) v2(31.45,127.07) v2(31.45,126.31) v2(53.36,42.07) v2(53.89,51.3) v2(58.81,27.77) v2(59.44,27.77) v2(63.28,107.63) v2(64.62,106.09) v2(64.97,126.99) v2(65.54,106.09) v2(67.03,106.72) v2(78.64,128.07) v2(78.64,127.05) v2(78.64,126.04) v2(78.64,123.9) v2(78.64,122.89) v2(78.64,121.87) v2(79.66,128.07) v2(79.66,127.05) v2(79.66,126.04) v2(79.66,123.9) v2(79.66,122.89) v2(79.66,121.87) v2(80.68,128.07) v2(80.68,127.05) v2(80.68,126.04) v2(80.68,123.9) v2(80.68,122.89) v2(80.68,121.87) v2(82.41,128.24) v2(83.32,128.24) v2(83.41,120.23) v2(84.11,33.69) v2(84.74,33.69) v2(84.81,120.69) v2(86.89,120.67) v2(120.2,29.32) v2(121.12,29.32) v2(122.03,30.24) v2(122.03,29.32) v2(140.22,23.68) v2(141.13,23.68) v2(159.99,34.45) v2(185.56,189.14) v2(188.73,189.04) v2(201.77,55.35) v2(217.72,98.77) v12(154.58,155.87) v12(154.58,153.84) v12(154.58,151.81) v12(154.58,148.89) v12(154.58,146.86) v12(154.58,144.83) v12(154.58,142.79) v12(156.61,155.87) v12(156.61,153.84) v12(156.61,151.81) v12(156.61,148.89) v12(156.61,146.86) v12(156.61,144.83) v12(156.61,142.79) v12(156.61,140.76) v12(158.64,155.87) v12(158.64,153.84) v12(158.64,151.81) v12(158.64,148.89) v12(158.64,146.86) v12(158.64,144.83) v12(158.64,142.79) v12(158.64,140.76) v12(160.67,153.84) v12(160.67,151.81) v12(160.67,148.89) v12(160.67,146.86) v12(160.67,144.83) v12(160.67,142.79) v12(160.67,140.76) v12(162.7,153.84) v12(162.7,151.81) v12(162.7,148.89) v12(162.7,146.86) v12(162.7,144.83) v12(162.7,142.79) v12(162.7,140.76) v12(186.1,100.51) v12(186.1,98.86) v12(186.1,97.21) v12(187.87,100.51) v12(187.87,98.86) v12(187.87,97.21) v12(189.65,100.51) v12(189.65,98.86) v12(189.65,97.21)
VSYS_3V3_1: length 378.1
  TOP w0.203: U105.B1 192.68,39.52 192.34,39.86 191.45,39.86 191.13,39.55 U106.6 ; U114.B1 192.68,35.33 192.34,35.67 191.43,35.67 191.11,35.36 U115.6
  TOP w0.254: v2(187.35,40.13) 187.54,40.32 C380.1 188.92,40.32 189.7,39.55 U106.6 ; v2(67.93,70.86) 68.54,70.25 68.54,69.39 66.89,67.74 v2(60.79,67.74) ; v2(188.65,36.13) 188.95,36.13 189.72,35.36 U115.6 ; U106.1 v2(196.71,37.55) ; v2(60.71,88.78) 63.35,88.78 v2(63.74,88.39)
  L3-SIGNAL1 w0.254: v2(196.71,37.55) 195.29,36.13 v2(188.65,36.13) 187.35,37.44 v2(187.35,40.13)
  L5-SIGNAL2 w0.305: v2(64.42,97.41) 61.86,99.97 61.86,105.18 63.51,106.83 65.69,106.83 v2(66.4,107.54)
  L7-SIGNAL3 w0.254: v2(185.35,47.78) 187.99,45.14 187.99,40.78 v2(187.35,40.13)
  L10-SIGNAL4 w0.254: v2(185.35,47.78) 185.35,60.17 186.14,60.96 186.14,75.13 187.41,76.4 187.41,83.62 189.57,85.78 195.41,85.78 198.33,88.7 198.33,89.92 v2(199.73,91.31)
  L10-SIGNAL4 w0.305: v2(67.93,91.05) 67.39,91.59 67.39,94.44 v2(64.42,97.41) ; v2(185.35,47.78) 181.09,43.51 170.82,43.51 166.95,39.63 158.05,39.63 157.62,40.06 141.08,40.06 138.97,42.16 138.21,42.16 135.61,44.77 135.61,45.58 124.06,57.13 89.31,57.13 83.09,63.35 74.89,63.35 68.77,69.47 68.77,70.02 v2(67.93,70.86)
  L12-SIGNAL5 w0.305: v2(196.02,103.33) 201.07,98.27 v2(201.07,95.99) ; v2(67.93,91.05) 67.87,91.05 67.24,90.42 67.24,71.55 v2(67.93,70.86)
  L14-SIGNAL6 w0.254: v2(201.07,95.99) 199.54,94.45 199.54,91.5 v2(199.73,91.31)
  L14-SIGNAL6 w0.305: v2(55.76,123.37) 62.24,123.37 v2(64.3,125.43) 64.3,119.51 64.96,118.85 64.96,115.82 63.95,114.81 v2(63.84,114.81) 66.58,112.08 v2(66.58,111) 66.58,107.72 v2(66.4,107.54) ; v2(63.74,88.39) 66.41,91.05 v2(67.93,91.05)
  BOTTOM w0.203: U188.B1 58.94,124.93 59.33,125.32 60.3,125.32 60.51,125.11 U189.6 ; U232.6 65.47,70.09 65.26,70.3 64.3,70.3 63.9,69.91 U231.B1 ; U204.C3 66.39,111.19 v2(66.58,111) 66.37,110.79 U204.B3 ; U219.B1 63.9,90.1 64.3,90.49 65.26,90.49 65.47,90.28 U218.6 ; U208.6 198.88,98.7 199.09,98.92 199.09,99.88 198.7,100.27 U207.B1 ; U203.6 64.62,112.36 64.41,112.15 64.41,111.18 64.8,110.79 U204.B1 ; U215.6 65.47,95.33 65.26,95.54 64.3,95.54 63.9,95.15 U214.B1 ; v2(63.74,88.39) 63.74,88.39 63.9,88.55 U219.B3
  BOTTOM w0.254: U218.2 v2(60.71,88.78) ; U203.1 66.62,107.76 v2(66.4,107.54) 66.12,107.83 U203.2 ; U232.1 61.14,68.09 v2(60.79,67.74) ; v2(196.02,103.33) 196.6,103.33 196.88,103.05 U208.1 ; U189.6 61.91,125.11 62.16,125.36 62.16,125.61 62.4,125.86 62.93,125.86 C704.1 63.83,125.89 v2(64.3,125.43) ; U232.6 67.09,70.09 67.86,70.86 v2(67.93,70.86) ; U218.6 66.87,90.28 67.12,90.53 67.12,90.78 67.37,91.02 67.9,91.02 v2(67.93,91.05) ; v2(63.84,114.81) 63.84,114.57 64.62,113.8 U203.6 ; v2(64.42,97.41) 65.73,96.1 C805.1 67.9,96.07 67.37,96.07 67.12,95.83 67.12,95.58 66.87,95.33 U215.6 ; v2(201.07,95.99) 200.82,96.25 C796.1 199.66,96.39 198.88,97.16 U208.6 ; U189.2 56.01,123.61 v2(55.76,123.37) 56.02,123.11 U189.1
VSYS_3V3_2: length 210.4
  L3-SIGNAL1 w0.305: v2(90.83,119.11) 85.55,119.11 83.35,121.31 v2(83.35,122.1) 87.46,122.1 89.73,124.37 v2(90.59,124.37) 91.15,123.8 102.3,123.8 103.84,125.35 111.57,125.35 112.35,126.14 121.75,126.14 133.28,137.67 143.26,137.67 151.8,129.13 v2(154.64,129.13)
  L7-SIGNAL3 w0.254: v2(154.64,129.13) 156.7,127.08 v2(156.7,123.19)
  L10-SIGNAL4 w0.305: v2(90.83,119.11) 89.21,117.5 89.21,116.74 85.91,113.44 85.91,109.13 81.94,105.16 79.66,105.16 73.58,99.09 72.73,99.09 68.54,94.9 68.54,86.61 v2(67.93,86)
  L12-SIGNAL5 w0.305: v2(68.59,66.75) 69.58,67.74 69.58,71.17 67.93,72.82 v2(67.93,76.38) 68.46,76.91 68.46,80.42 v2(67.93,80.96) 68.64,81.67 68.64,85.29 v2(67.93,86)
  BOTTOM w0.203: U225.B1 63.9,80 64.3,80.39 65.26,80.39 65.47,80.18 U226.6 ; U222.B1 63.9,85.05 64.3,85.44 65.26,85.44 65.47,85.23 U221.6 ; U195.6 153.55,122.14 153.3,122.39 152.29,122.39 151.98,122.08 U194.B1 ; U230.B1 63.9,75.42 64.29,75.81 65.26,75.81 65.47,75.6 U229.6 ; U198.B1 86.82,118.39 87.21,118.78 88.17,118.78 88.38,118.57 U199.6 ; U185.B1 153.2,132.19 153.48,131.91 153.48,130.72 153.19,130.43 U184.6 ; U192.B1 86.56,123.42 86.95,123.81 87.92,123.81 88.13,123.6 U193.6 ; U236.6 65.47,65.27 65.26,65.48 64.3,65.48 63.9,65.08 U235.B1
  BOTTOM w0.254: v2(90.59,124.37) 90.56,124.34 90.02,124.34 89.78,124.1 89.78,123.85 89.53,123.6 U193.6 ; U193.2 v2(83.35,122.1) ; v2(67.93,80.96) 67.9,80.93 67.37,80.93 67.12,80.68 67.12,80.43 66.87,80.18 U226.6 ; v2(156.7,123.19) 156.42,122.91 C709.1 155.74,122.91 154.96,122.14 U195.6 ; v2(67.93,86) 67.4,86 67.12,85.73 67.12,85.48 66.87,85.23 U221.6 ; U236.6 67,65.27 67.77,66.04 C1065.1 68.75,66.04 R1316.1 68.8,66.54 v2(68.59,66.75) ; U184.6 153.19,129.22 153.44,128.97 153.68,128.97 153.93,128.72 153.93,128.2 C698.1 154.46,128.17 154.64,128.35 v2(154.64,129.13) ; v2(90.83,119.11) 90.49,119.11 89.95,118.57 U199.6 ; C988.1 67.89,76.34 67.36,76.34 67.12,76.1 67.12,75.85 66.87,75.6 U229.6
VSYS_3V3_3: length 192.2
  TOP w0.203: U119.B1 175.87,33.58 176.21,33.92 176.21,34.82 175.9,35.13 U118.6 ; U128.6 155.84,29.41 156.15,29.1 156.15,28.26 155.81,27.92 U129.B1 ; U116.B1 171.55,33.58 171.89,33.92 171.89,34.75 171.58,35.07 U117.6 ; U93.B1 192.68,47.9 192.34,48.24 191.5,48.24 191.19,47.93 U94.6 ; C348.1 187.31,48.7 v2(187.27,48.67) ; U121.B1 180.19,33.58 180.53,33.92 180.53,34.75 180.21,35.07 U120.6 ; U57.B1 196.26,84.21 196.16,84.31 196.16,84.55 195.89,84.82 195.11,84.82 194.72,84.43 U56.6 ; U60.6 194.72,80.4 195.03,80.71 195.92,80.71 196.26,80.37 U61.B1 ; U64.B1 196.26,76.34 195.92,76.68 195.08,76.68 194.77,76.37 U65.6
  TOP w0.254: v2(192.23,77.14) 192.56,77.14 193.33,76.37 U65.6 ; U118.6 175.9,36.62 176.67,37.39 C390.1 v2(176.67,37.61) ; C392.1 180.99,37.44 180.21,36.67 U120.6 ; U94.6 189.62,47.93 188.85,48.7 C348.1 ; U56.6 193.17,84.43 192.4,85.21 v2(192.23,85.21) ; v2(191.52,80.26) 191.52,80.47 192.23,81.18 C257.1 192.54,81.18 193.32,80.4 U60.6 ; U94.1 195.58,45.93 v2(195.87,45.64) ; U117.1 169.58,30.76 v2(169.25,30.43) ; U65.2 v2(199.47,74.87) ; U128.6 155.84,31.01 156.61,31.79 v2(156.61,31.94) ; U117.6 171.58,36.65 172.35,37.42 v2(172.35,37.6) ; U120.1 178.21,30.73 v2(177.88,30.4)
  L3-SIGNAL1 w0.254: v2(192.23,85.21) 192.23,80.97 v2(191.52,80.26) ; v2(199.47,74.87) 196.51,74.87 194.24,77.14 v2(192.23,77.14)
  L12-SIGNAL5 w0.305: v2(177.88,30.4) 177.88,32.23 178.65,32.99 178.65,35.31 v2(181.01,37.67) 188.3,37.67 189.26,38.63 189.26,45.97 187.58,47.66 187.58,48.36 v2(187.27,48.67) 189.74,51.13 191.88,51.13 195.21,54.46 195.21,58.01 197.62,60.43 197.62,64.69 199.12,66.19 199.12,72.03 197.37,73.79 197.37,80.07 v2(192.23,85.21) ; v2(192.23,77.14) 191.52,77.85 v2(191.52,80.26)
  L14-SIGNAL6 w0.254: v2(181.01,37.67) 180.57,38.11 177.17,38.11 v2(176.67,37.61) 176.15,37.09 172.86,37.09 v2(172.35,37.6) 171.71,36.96 166.61,36.96 165.11,35.46 165.11,31.48 165.85,30.73 168.94,30.73 v2(169.25,30.43) 166.76,27.94 161.45,27.94 161.07,28.32 160.23,28.32 v2(156.61,31.94)
  BOTTOM w0.254: v2(195.87,45.64) 195.46,45.64 194.45,44.63 190.81,44.63 187.27,48.17 v2(187.27,48.67)
VSYS_3V3_4: length 290.6
  TOP w0.203: C366.1 187.69,44.51 R1318.1 ; U84.B1 192.68,52.66 192.34,53 191.45,53 191.13,52.69 190.28,52.69 U83.6 ; U100.6 191.19,43.74 191.5,44.05 192.34,44.05 192.68,43.71 U99.B1 ; U32.6 202.17,134.77 201.81,135.14 201.81,136.05 202.1,136.34 U31.B1
  TOP w0.254: U83.6 190.28,52.69 189.61,52.69 188.84,53.46 v2(188.65,53.46) ; C366.1 188.9,44.51 189.67,43.74 U100.6 ; U32.6 202.17,133.38 201.92,133.13 201.65,133.13 201.4,132.87 v2(201.4,132.31)
  L14-SIGNAL6 w0.254: 229.93,78.66 v4(229.93,78.67)
  L14-SIGNAL6 w0.305: v2(191.27,164.06) 191.27,159.77 196.12,154.91 196.12,137.59 v2(201.4,132.31) ; v2(201.4,132.31) 202.93,130.78 204.07,130.78 206.89,127.97 212.63,127.97 232.62,107.98 232.62,88.16 238.11,82.68 238.11,79.32 237.45,78.66 229.93,78.66 229.93,77.83 237.03,70.73 v2(237.03,67.48) ; v2(201.4,132.31) 199.58,130.49 199.58,108.92 196.58,105.92 196.58,97.75 v2(194.82,95.99) 195.79,95.02 195.79,86.82 199.47,83.14 v2(199.47,83.01) 191.98,83.01 v2(190.41,81.43) 188.1,79.12 188.1,72.93 188.09,72.92 188.09,72.48 188.1,72.48 188.1,71.96 188.09,71.96 188.09,71.72 184.67,68.3 184.67,57.45 v2(188.65,53.46) 189.99,52.12 191.37,52.12 192.97,50.52 192.97,47.22 192.26,46.51 189.7,46.51 v2(187.41,44.22)
  BOTTOM w0.203: U172.6 190.5,168.68 190.71,168.89 190.71,169.86 190.32,170.25 U171.B1 ; U211.B1 196.26,82.13 195.87,81.74 194.9,81.74 194.69,81.95 U212.6 ; U223.B1 233.95,79.7 233.56,79.31 232.7,79.31 232.5,79.5 U224.6 ; U209.6 194.05,98.45 194.26,98.66 194.26,99.63 193.87,100.02 U210.B1 ; U239.6 237.8,65.01 237.59,64.8 237.59,63.84 237.98,63.45 U238.B1
  BOTTOM w0.254: v2(190.41,81.43) 190.93,80.91 191.55,80.91 191.82,81.18 C800.1 192.46,81.18 193.23,81.95 U212.6 ; U239.6 237.8,66.58 237.03,67.35 C1058.1 v2(237.03,67.48) ; U209.6 194.05,97.05 194.3,96.8 194.57,96.8 194.82,96.55 v2(194.82,95.99) ; U172.6 190.5,167.28 190.75,167.03 191,167.03 191.24,166.79 191.24,166.25 C586.1 v2(191.27,164.06) ; U224.6 230.92,79.5 230.67,79.25 230.67,78.9 230.43,78.67 C949.1 v4(229.93,78.67) ; U212.2 199.03,83.45 v2(199.47,83.01)
VSYS_3V3_IN+: length 4.8
  BOTTOM w0.127: U171.D3 188.5,168.85 U172.10 188.5,166.89 188.29,166.68 C587.2 188.29,165.64 188.18,165.53 R801.1
VSYS_3V3_IN-: length 6.3
  BOTTOM w0.127: 189.7,169.25 U171.D1 ; 189.7,169.25 U171.D2 ; 189.7,169.25 189.7,169.03 189.5,168.83 U172.8 189.5,166.97 189.21,166.68 ; R800.1 189.32,165.49 189.21,165.6 C587.1 189.21,166.68 ; U172.9 189,166.89 189.21,166.68
VSYS_3V3_N: length 39.2
  TOP w0.127: R136.5 v2(163.68,150.35)
  L12-SIGNAL5 w0.102: v2(189.45,162.79) 188.87,162.2 188.87,157.37 186.73,155.23 171.8,155.23 167.54,150.97 167.54,149.67 166.72,148.85 165.27,148.85 164.66,149.46 164.66,150.21 164.52,150.35 v2(163.68,150.35)
  BOTTOM w0.127: v2(189.45,162.79) 189.03,162.79 188.9,162.92 188.9,163.74 R800.2
VSYS_3V3_P: length 38.2
  TOP w0.127: R136.2 v2(165.93,150.35)
  L12-SIGNAL5 w0.102: v2(165.93,150.35) 165.12,150.35 164.98,150.21 164.98,149.6 165.41,149.17 166.58,149.17 167.22,149.81 167.22,151.04 171.63,155.45 186.64,155.45 188.64,157.46 188.64,162.19 v2(188.04,162.79)
  BOTTOM w0.127: v2(188.04,162.79) 188.47,162.79 188.6,162.92 188.6,163.73 R801.2
VSYS_5V0: length 73.4
  TOP w0.254: v2(50.81,84.98) 51.06,85.23 U58.17 ; U151.3 149.59,15.8 149.76,15.98 v2(149.76,16.54) ; v2(53.22,102.83) 52.97,102.58 U50.17 ; v2(120.29,18.16) 120.29,17.57 120.53,17.33 C493.2 120.53,16.29 120.33,16.1 U148.3 ; v2(159.57,16.54) 159.57,15.98 159.39,15.8 U152.3 ; C246.1 v4(70.3,91.54)
  TOP w0.381: v2(45.42,169.6) 45.42,168.16 45.17,167.9 C42.2 44.32,169.24 C33.2 43.88,170.41 43.94,170.47 U9.3
  L5-SIGNAL2 w0.381: v2(58.14,178.44) 56.94,178.44 54.36,175.87 51.69,175.87 v2(45.42,169.6)
  L8-PWR1 w0.508: v2(50.81,84.98) 51.75,85.93 51.75,90.49 53.04,91.78 69.37,91.78 v4(69.6,91.54) v4(70.3,91.54)
  L10-SIGNAL4 w0.381: 105.8,122.7 110.46,122.7 114.7,118.46 v2(114.7,117.74)
  BOTTOM w0.254: v2(86.04,30) 85.8,29.77 U260.4 ; U169.4 v2(106.37,168.22) ; U174.4 v2(134.26,167.05)
  vias: v2(24.96,4.96) v2(24.96,3.94) v2(41.84,61.24) v2(41.84,60.33) v2(41.84,59.41) v2(42.76,61.24) v2(42.76,60.33) v2(42.76,59.41) v2(44.79,30.02) v2(55.66,21.24) v2(55.66,20.33) v2(58.14,179.46) v2(60.51,9.64) v2(61.43,9.64) v2(108.06,168.43) v2(108.06,167.16) v2(134.04,168.74) v2(135.31,168.74) v2(143.95,177.34) v2(144.97,177.34) v2(176.11,22.19) v12(223.4,89.85) v12(223.4,88.07) v12(223.4,86.29) v12(223.4,84.51) v12(223.4,82.74) v12(225.18,89.85) v12(225.18,86.29) v12(225.18,84.51) v12(225.18,82.74) v12(226.96,89.85) v12(226.96,88.07)
VSYS_5V0_IN+: length 4.8
  BOTTOM w0.127: R1021.1 229.29,81.8 229.34,81.75 C919.2 230.45,81.75 230.69,81.5 U224.10 232.57,81.5 U223.D3
VSYS_5V0_IN-: length 7
  BOTTOM w0.127: U223.D1 232.9,80.12 232.76,80.26 232.76,80.41 ; 229.98,80.83 230.31,80.5 U224.8 232.67,80.5 232.76,80.41 ; 229.98,80.83 C919.1 229.49,80.83 229.32,80.65 R1024.1 ; 229.98,80.83 230.46,80.83 230.64,81 U224.9 ; U223.D2 232.86,80.52 232.76,80.41
VSYS_5V0_N: length 5.4
  TOP w0.127: R357.4 v2(227,83.99)
  BOTTOM w0.127: v2(227,83.99) 227.31,83.99 227.44,83.87 227.44,83.34 226.68,82.58 226.68,81.37 226.96,81.08 227.42,81.08 R1024.2
VSYS_5V0_P: length 4.8
  TOP w0.127: R357.1 v2(228.18,83.99)
  BOTTOM w0.127: v2(228.18,83.99) 227.9,83.99 227.77,83.87 227.77,83.26 227.01,82.5 227.01,81.54 227.13,81.41 227.48,81.41 R1021.2
VSYS_GPIORET_5V0: length 10.5
  TOP w0.254: C454.1 169.06,21.69 U139.3
  TOP w0.381: C453.1 166.66,20.51 TP238.1 168.49,19.67 169.37,18.78 C498.2 169.37,15.98 169.2,15.8 U153.3
VSYS_GPIORET_IO_3V3: length 75.3
  TOP w0.254: TP156.1 v4(81.33,65.01)
  L3-SIGNAL1 w0.381: v2(35.23,52.3) 37.23,54.3 43.11,54.3 47.91,59.11 50.4,59.11 51.16,59.87 64.8,59.87 65.44,60.5 v2(66.96,60.5)
  L7-SIGNAL3 w0.203: v2(66.96,60.5) 66.96,61.19 70.67,64.9 74.61,64.9 75.45,65.74 80.6,65.74 v4(81.33,65.01)
  L14-SIGNAL6 w0.305: v2(35.23,52.3) 33.58,50.66 24.88,50.66 24.21,51.32 24.21,59.47 v2(23.43,60.26)
  BOTTOM w0.305: v2(23.43,60.26) 23.58,60.1 R1128.1
VSYS_GPIORET_IO_3V3_IN+: length 4.8
  BOTTOM w0.127: R1053.1 68.62,73.28 68.51,73.39 C1016.2 67.47,73.39 67.26,73.6 U229.10 65.3,73.6 U230.D3
VSYS_GPIORET_IO_3V3_IN-: length 6.3
  BOTTOM w0.127: R1048.1 68.66,74.42 68.55,74.31 C1016.1 67.47,74.31 ; 67.47,74.31 67.26,74.1 U229.9 ; 67.47,74.31 67.18,74.6 U229.8 65.31,74.6 65.11,74.8 64.9,74.8 ; 64.9,74.8 U230.D1 ; 64.9,74.8 U230.D2
VSYS_GPIORET_IO_3V3_N: length 21.5
  L12-SIGNAL5 w0.102: v2(78.99,67.16) 79.31,67.49 80.66,67.49 80.67,67.5 80.68,67.5 81.12,67.93 81.12,73 80.22,73.9 71.46,73.9 71.36,74 v2(71.36,74.56)
  BOTTOM w0.127: v2(78.99,67.16) 79.06,67.23 79.45,67.23 79.52,67.31 R1092.4 ; v2(71.36,74.56) 71.36,74.13 71.23,74.01 70.41,74.01 R1048.2
VSYS_GPIORET_IO_3V3_P: length 19.7
  L12-SIGNAL5 w0.102: v2(71.36,73.14) 71.36,73.48 71.54,73.67 80.12,73.67 80.89,72.9 80.89,68.03 80.57,67.71 79.69,67.71 v2(79.4,67.99)
  BOTTOM w0.127: R1053.2 70.42,73.7 71.23,73.7 71.36,73.57 v2(71.36,73.14) ; v2(79.4,67.99) 79.45,68.04 R1092.1
VSYS_IO_1V8: length 125.7
  TOP w0.254: R112.1 128.94,156.8 R113.1 C91.2 127.77,157.59 127.82,157.64 U20.2 ; v2(50.25,115.8) 50.25,115.12 R229.1
  TOP w0.305: v2(114.19,124.64) 114.04,124.49 C153.2 C159.1 ; C147.2 v2(114.16,129.81)
  TOP w0.381: C91.2 127.77,156.27 128.24,155.81 134.64,155.81 135.39,156.56 139.7,156.56 v2(139.99,156.27) ; FL3.1 v2(101.79,162.87) ; FL7.1 107.15,138.52 107.63,139.01 v2(108.02,139.01) ; FL2.1 v2(88.07,163.44)
  L3-SIGNAL1 w0.305: v2(26.04,87.55) 28.24,89.75 v2(30.46,89.75)
  L3-SIGNAL1 w0.381: v2(115.52,134.78) 113.99,134.78 112.28,136.48 110.55,136.48 v2(108.02,139.01) 101.79,145.25 v2(101.79,151.75)
  L7-SIGNAL3 w0.254: 54.9,116.66 53.5,116.66 52.64,115.8 v2(50.25,115.8)
  L7-SIGNAL3 w0.305: v2(26.38,82.84) 26.04,83.18 v2(26.04,87.55)
  L7-SIGNAL3 w0.381: v2(114.19,124.64) 115.07,125.52 115.07,128.9 v2(114.16,129.81) 114.86,130.52 114.86,134.12 v2(115.52,134.78)
  L10-SIGNAL4 w0.381: v2(118.98,124.49) 114.33,124.49 v2(114.19,124.64)
  L14-SIGNAL6 w0.381: v2(42.1,70.24) 36.66,70.24 TP10.1 34.6,85.61 v2(30.46,89.75)
  BOTTOM w0.254: v2(115.52,134.78) 115.83,134.48 C676.2 ; R864.1 114.78,130.46 114.78,130.31 114.28,129.81 v2(114.16,129.81) U187.53 ; R999.1 v2(26.04,87.55) ; C676.2 116.77,134.48 117.02,134.22 U183.4 U183.1 116.98,135.22 C676.2 ; U213.5 C770.1 ; U187.63 114.01,124.81 v2(114.19,124.64) ; R880.2 R883.1 R889.1 R893.1 119.12,124.63 v2(118.98,124.49) ; U220.5 v2(26.38,82.84)
  vias: v2(42.1,69.33) v2(42.1,68.41) v2(43.01,70.24) v2(43.01,69.33) v2(43.01,68.41) v2(54.47,109.13) v2(55.38,109.13) v2(60.91,109.63) v2(60.91,108.62) v2(83.51,151.71) v2(102.8,162.87) v2(103.82,162.87) v2(139.99,155.35) v2(139.99,154.44) v2(140.9,156.27) v2(140.9,155.35) v2(180.53,100.08) v2(180.53,99.06) v2(183.36,100.99) v4(168.31,89.54) v4(168.31,88.57) v4(169.27,89.54) v4(169.27,88.57) v4(170.24,89.54) v4(170.24,88.57)
VSYS_IO_1V8_IN+: length 4.8
  BOTTOM w0.127: U210.D3 192.05,98.62 U209.10 192.05,96.66 191.84,96.45 C799.2 191.84,95.41 191.73,95.3 R972.1
VSYS_IO_1V8_IN-: length 6.3
  BOTTOM w0.127: 192.76,96.44 C799.1 192.76,95.37 192.87,95.26 R971.1 ; 192.76,96.44 192.55,96.65 U209.9 ; 192.76,96.44 193.05,96.73 U209.8 193.05,98.6 193.25,98.8 193.25,99.02 ; 193.25,99.02 U210.D1 ; 193.25,99.02 U210.D2
VSYS_IO_1V8_N: length 28.5
  L3-SIGNAL1 w0.089: v2(193.01,92.56) 192.57,92.56 192.39,92.74 192.39,93.56 192.08,93.86 189.09,93.86 188.42,93.2 176.77,93.2 170.75,87.18 170.56,87.18 v2(170.35,87.39)
  BOTTOM w0.127: R971.2 192.46,93.51 192.46,92.69 192.58,92.56 v2(193.01,92.56)
VSYS_IO_1V8_P: length 28.2
  L3-SIGNAL1 w0.089: v2(170.35,86.67) 170.61,86.93 170.82,86.93 176.86,92.97 188.55,92.97 189.23,93.64 191.98,93.64 192.17,93.45 192.17,92.7 192.03,92.56 v2(191.59,92.56)
  BOTTOM w0.127: R972.2 192.15,93.5 192.15,92.69 192.02,92.56 v2(191.59,92.56)
VSYS_IO_3V3: length 354.2
  TOP w0.127: R90.1 v2(7.55,160.3) R96.1
  TOP w0.254: U148.5 117.79,16.31 117.64,16.47 C492.1 ; U151.5 148.15,9.16 148.15,8.35 147.53,7.73 v2(147.46,7.73) ; R87.2 v2(26.02,162.19) R85.2 ; v2(107.58,151.77) 108.46,150.89 R135.1 ; U15.5 28.53,166.01 v2(27.01,166.01) ; v2(46.82,32.55) 47.48,32.55 47.58,32.65 U112.16 ; R339.2 R328.2 v2(55.43,90.96) ; v2(100.34,171.13) 100.58,170.89 R43.2 ; U72.8 v2(27.85,69.98) ; v2(73.33,29.55) 73.14,29.36 C422.1 ; v2(48.81,113.09) 48.75,113.16 U43.21 ; C436.1 78.04,26.09 v2(78.24,25.9) ; R103.1 v2(147.81,157.75) R105.1 R106.1 R107.1 v2(152.89,157.75) ; v2(54.42,13.92) 53.64,13.92 53.58,13.99 U154.46 ; U38.5 49.37,118.22 v2(49.37,116.71) ; R72.2 v2(135.52,163.93) ; R926.1 88.17,91.31 87.39,92.08 87.39,93.15 87.13,93.41 84.58,93.41 v2(83.83,94.17) 84.79,95.13 R303.1 86.3,95.15 R297.1 ; R54.1 v2(35.65,167.65) ; v2(105.19,166.3) 105.38,166.11 R65.1 ; C520.1 v2(39.29,9.81) 39.81,9.81 40.13,9.49 U154.12 ; v2(55.18,29.37) 55.18,30.21 54.77,30.63 R610.1 ; C441.2 204.51,24.24 ; 204.51,24.24 v2(204.5,24.23) ; 204.51,24.24 204.51,24.15 204.39,24.03 U143.1 ; R158.1 R157.2 ; R158.1 R159.1 R160.2 v2(24.14,143.09) ; R158.1 v2(21.85,143.09) ; R45.2 v2(126.45,171.14) ; R624.1 137.58,26.1 v2(137.02,25.53) ; U132.15 52.13,26.28 v2(51.88,26.53) 52.13,26.78 U132.14 ; U108.16 v2(58.2,42.21) ; U33.5 C161.1 v2(45.73,121.93) ; R145.2 R146.1 ; R146.1 R147.1 ; R146.1 v2(21.85,146.46) ; U155.5 v2(126.26,8.78) ; U92.5 v2(67.96,46.82) ; R164.2 v2(27.57,142.2) R162.2 ; R1292.1 57.1,104.92 57.69,105.51 v2(57.69,105.95) ; R200.1 42.55,124.14 v2(42.55,124.14) ; C64.2 132.07,161.38 U18.15 ; C64.2 v2(130.9,161.88) ; C64.2 U18.14 ; v2(187.15,55.85) 187.2,55.8 U80.16 ; v2(50.99,24.34) 51,24.33 R638.2 ; U107.5 v2(75.87,35) ; v2(80.17,35.72) 80.73,35.72 80.91,35.91 U110.6 ; U152.5 157.95,9.16 157.95,8.35 157.34,7.73 v2(157.26,7.73) ; U76.15 193.1,63.66 v2(192.85,63.41) 192.6,63.66 U76.14 ; U14.5 C34.1 v2(32.23,169.65) ; R463.2 v2(25.89,60.38) ; U73.8 v2(24.38,63.97) ; C369.1 58.59,44.35 v2(58.53,44.41) ; U143.3 v2(203.09,21.72) ; v2(48.94,114.26) 48.84,114.16 U43.23 ; R100.1 v2(144,157.75) ; v2(202.23,51.65) 201.83,52.05 R1305.2 ; R456.2 v2(25.89,63.99) ; U12.10 v2(140.52,168.74)
  TOP w0.305: R71.1 v2(126.68,165.69)
  TOP w0.381: v2(117.88,18.16) 117.88,17.13 C492.1 ; FL6.1 v2(114.25,151.72)
  L3-SIGNAL1 w0.305: v2(192.85,63.41) 192.85,63.96 191.24,65.57 190.08,65.57 v2(189.54,65.03) 189.54,56.73 188.67,55.85 v2(187.15,55.85) ; v2(210.67,107.81) 212.74,107.81 214.38,109.46 217.92,109.46 218.42,108.95 221.64,108.95 222.28,108.31 230.82,108.31 239.94,117.43 v2(241.29,117.43)
  L5-SIGNAL2 w0.305: v2(7.55,160.3) 9.85,160.3 12,158.15 13.49,158.15 v2(16.57,155.07)
  L7-SIGNAL3 w0.305: v2(58.56,86.06) 58.56,87.84 v2(55.43,90.96)
  L8-PWR1 w0.305: v4(73.83,93.17) 74.77,94.11 80.69,94.11 81.35,93.46 83.12,93.46 v2(83.83,94.17)
  L10-SIGNAL4 w0.305: v2(57.69,105.95) 60.38,105.95 62.06,107.63 62.06,110.55 62.96,111.45 v2(62.96,113.19)
  L10-SIGNAL4 w0.381: v4(77.6,65) 77.3,65 76.43,65.87 75.73,66.57 75.73,68.83 72.87,71.69 72.87,82.09 74.04,83.26 v4(74.04,84.57) 74.04,86.35 72.27,88.12 72.27,90.14 73.83,91.7 v4(73.83,93.17)
  L12-SIGNAL5 w0.305: v2(192.85,63.41) 191.56,64.69 191.56,74.58 191.56,74.58 191.56,75.2 186.76,80.01 183.35,80.01 182.1,81.25 182.1,87.76 179.83,90.04 v2(179.83,102.21)
  BOTTOM w0.127: v2(55.7,11.6) 55.66,11.6 55.43,11.83 R1280.1 R1281.1
  BOTTOM w0.254: U175.5 v2(32.93,164.16) ; R802.2 v2(29.3,164.16) U176.5 ; R809.1 129.26,162.2 129.29,162.17 129.3,162.17 129.69,161.78 ; 129.69,161.78 130.3,162.39 131.11,162.39 131.46,162.03 ; 129.69,161.78 R810.1 ; U181.14 v2(19.25,140.19) ; U167.5 C1266.1 120.4,174.31 v2(119.91,173.82) ; v2(194.24,61.37) 194.24,60.77 193.91,60.44 U242.19 ; v2(214.55,15.71) 215.01,15.71 215.16,15.86 U273.1 ; U168.5 96.8,173.93 96.5,173.63 C1267.1 97.21,172.83 v2(97.27,172.78) ; R1161.2 v2(29.44,48.11) ; U206.16 v2(29.66,101.58) ; v2(32.23,169.65) 31.81,169.65 31.39,170.07 31.39,170.92 R779.1 ; U177.16 v2(142.07,166.96) ; v2(73.33,29.55) 73.46,29.42 U262.30 ; R1095.1 22.3,66.93 v2(22.11,66.73) ; R821.2 v2(20.21,150.41) ; v2(80.17,35.72) 80.55,35.34 C1169.1 81.09,35.86 81.23,36 U254.5 ; v2(214.62,21.79) 215.09,21.79 215.23,21.94 U264.1 ; R787.2 v2(58.28,167.39) ; v2(207.87,52.21) 208.19,51.88 R1143.1 R1147.1 ; v2(155.2,175.59) 155.39,175.78 R764.2 ; U196.5 v2(51.21,119) R912.2 ; v2(115.52,162.82) 115.31,162.61 R808.1 ; v2(180.8,171.86) C571.1 180.82,173.05 U165.5 ; v2(66.1,121.71) 64.9,121.71 63.74,120.56 63.74,119.26 63.18,118.7 R921.1 ; C769.1 178.72,102.01 v2(178.91,102.21) ; v2(215.3,23.43) 215.49,23.24 U264.3 ; C574.1 159.97,172.19 159.41,171.63 v2(158.91,171.63) U173.31 ; R785.1 149.97,168.23 149.72,168.49 v2(149.72,169.3) ; R863.1 v2(78.39,130.97) ; v2(78.24,25.9) 78.1,25.77 U262.41 ; R1245.2 v2(80.06,23.13) ; U262.19 69.62,25.27 69.17,25.71 v2(68.72,25.71) ; U273.3 215.42,17.16 v2(215.23,17.35) ; R781.2 v2(58.28,169.68) ; U173.27 v2(156.91,171.33) ; U190.5 v2(51.21,122.63) ; v2(26.02,73.01) U227.16 ; R771.2 v2(155.26,173.43)
  BOTTOM w0.381: R1104.1 78.1,65.49 v4(77.6,65) ; R1267.2 117.97,18.07 v2(117.88,18.16) ; U161.5 161.08,179.32 v2(160.65,178.89)
  vias: v2(6.95,85.92) v2(7.8,79.06) v2(15.5,81.9) v2(16.82,135.13) v2(17.27,81.34) v2(19.68,104.18) v2(19.74,72.18) v2(20.66,81.92) v2(22.08,69.68) v2(22.23,33.45) v2(24.47,100.3) v2(24.74,80.84) v2(24.79,69.68) v2(27.03,123.47) v2(27.22,33.45) v2(28.28,82.84) v2(33.02,149.5) v2(33.02,129.43) v2(41.06,77.7) v2(41.05,75.19) v2(42.04,66.64) v2(42.04,65.62) v2(44.34,118.11) v2(44.46,123.47) v2(47.35,109.51) v2(48.11,31.31) v2(48.43,125.34) v2(53.91,123.9) v2(53.91,122.98) v2(53.87,115.86) v2(55.69,16.82) v2(55.67,15.1) v2(56.5,44.41) v2(56.5,43.39) v2(57.51,44.41) v2(57.51,43.39) v2(58.53,43.39) v2(58.54,13.9) v2(58.54,12.38) v2(58.56,85.05) v2(58.56,84.03) v2(59.47,86.06) v2(59.47,85.05) v2(59.47,84.03) v2(60.41,176.62) v2(60.41,175.71) v2(61.32,175.71) v2(61.78,25.27) v2(65.02,5.34) v2(65.02,3.31) v2(65.41,46.79) v2(65.63,27.41) v2(66.54,27.41) v2(74.08,41.83) v2(74.96,31.19) v2(77.07,31.19) v2(78.71,169.07) v2(78.71,167.67) v2(79.37,36.79) v2(80.06,30.06) v2(80.06,26.63) v2(80.06,19.82) v2(84.63,5.34) v2(87.08,31.26) v2(132.24,159.96) v2(132.24,158.19) v2(132.24,157.55) v2(137.02,24.62) v2(154.48,10.7) v2(155,159.88) v2(155,159.04) v2(155.07,163.59) v2(155.96,159.88) v2(155.96,159.04) v2(164.05,169.03) v2(164.28,10.7) v2(195.04,63.33) v2(203.16,50.74) v2(210.67,102.19) v2(214.18,49.41) v2(214.18,48.5) v2(215.1,49.41)
VSYS_IO_3V3_IN+: length 4.8
  BOTTOM w0.127: R1015.1 68.62,82.91 68.51,83.02 C896.2 67.48,83.02 67.27,83.23 U221.10 65.3,83.23 U222.D3
VSYS_IO_3V3_IN-: length 6.3
  BOTTOM w0.127: 67.48,83.94 67.19,84.23 U221.8 65.32,84.23 65.12,84.43 64.9,84.43 ; 67.48,83.94 C896.1 68.55,83.94 68.66,84.05 R1013.1 ; 67.48,83.94 67.27,83.73 U221.9 ; U222.D2 64.9,84.43 ; 64.9,84.43 U222.D1
VSYS_IO_3V3_N: length 10.6
  L7-SIGNAL3 w0.109: v2(76.25,80.77) 76.5,80.52 76.5,80.29 76.28,80.08 74.93,80.08 73.47,81.54 73.47,83.04 72.75,83.76 71.47,83.76 71.36,83.87 v2(71.36,84.19)
  BOTTOM w0.127: R1013.2 70.42,83.64 71.24,83.64 71.36,83.76 v2(71.36,84.19)
VSYS_IO_3V3_P: length 11.3
  L7-SIGNAL3 w0.109: v2(76.98,80.77) 76.74,80.53 76.74,80.19 76.39,79.84 74.84,79.84 73.24,81.44 73.24,82.94 72.65,83.52 71.51,83.52 71.36,83.38 v2(71.36,82.77)
  BOTTOM w0.127: v2(71.36,82.77) 71.36,83.21 71.24,83.33 70.42,83.33 R1015.2
VSYS_MCU_5V0: length 7.9
  TOP w0.254: C469.1 137.49,19.83 U142.3 ; v2(130.16,16.54) 130.16,15.98 129.98,15.8 U149.3 ; U138.4 v2(118.42,23.57) ; v2(139.96,16.54) 139.96,15.98 139.78,15.8 U150.3
  TOP w0.381: v2(135.47,20.21) TP237.1
  vias: v2(135.47,19.2)
VSYS_MCU_5V0_EN: length 1.6
  TOP w0.127: R671.1 141.47,19.03 140.67,19.83 U142.4
VSYS_MCUIO_1V8: length 250.2
  TOP w0.254: U79.B4 v2(137.1,45.23) ; TP147.1 164.66,68.78 164.89,68.54 v2(165.43,68.54) ; U86.5 72,48.41 v4(72.02,48.39) ; U97.5 72,44.53 72,43.52 v4(72,43.52) ; C376.1 47.08,40.64 47.32,40.4 U103.5 ; R1126.2 R1125.2 v2(139.61,53.43)
  TOP w0.305: U245.B4 v4(118.85,36.4) ; U246.E4 v4(126.6,40.4) ; U245.E4 v2(118.85,40.4) ; v4(130.6,39.4) U246.D1 ; U246.B4 v2(126.6,36.4) ; U245.D1 v2(122.85,39.4)
  TOP w0.381: C376.1 46.63,39.6 47.1,39.13 47.1,37.85 v2(46.73,37.48)
  L7-SIGNAL3 w0.381: v2(20.61,73.62) 20.61,68.71 19.68,67.78 19.68,62.34 21.27,60.74 21.27,56.37 21.61,56.03 21.61,51.47 22.94,50.14 22.94,40.55 25.23,38.26 27.75,38.26 30.69,35.31 33.28,35.31 35.43,37.46 46.72,37.46 v2(46.73,37.48)
  L14-SIGNAL6 w0.254: v2(177.99,182.61) 178.47,182.13 178.47,173.86 176.54,171.93 176.54,169.75 169.3,162.51 169.3,142.96 165.24,138.9 165.24,131.65 162.7,129.1 162.7,118.04 164.87,115.87 174.32,115.87 175.7,114.49 175.7,112.33 180.74,107.28 180.74,101.65 181.26,101.12 181.26,94.6 176.18,89.52 176.18,83.01 175.54,82.37 173.43,82.37 169.81,78.75 169.81,72.11 167.97,70.28 167.97,70.05 167.07,69.15 v2(166.35,69.15)
  BOTTOM w0.203: v2(63.86,45.22) 63.36,45.22 63.21,45.37 U248.16
  BOTTOM w0.254: C325.1 130.89,39.7 v4(130.6,39.4) R506.1 ; R508.1 R518.1 R507.1 122.69,39.24 v2(122.85,39.4) ; 125.6,37.38 125.78,37.56 R523.1 ; 125.6,37.38 v2(125.59,37.37) ; 125.6,37.38 R500.1 ; v2(177.99,182.61) 178.46,183.08 R734.2 ; v2(137.1,45.23) C1095.1 ; R525.2 130.7,37.4 v4(131.63,38.34) ; R491.1 R490.1 R489.1 v4(129.6,41.91) ; R513.1 v4(126.6,40.4) 126.53,40.48 C322.1 ; v4(118.85,36.4) 118.75,36.3 C347.1 ; v2(20.61,73.62) 20.29,73.93 U228.8
  BOTTOM w0.305: v4(72,43.52) 72,44.22 C1135.1 ; R527.1 118.01,36.96 118.15,36.83 C347.1 ; v2(117.85,39.41) 117.85,39.4 R516.1 ; v2(118.85,40.4) 118.78,40.48 C327.1 118.8,41.24 R495.1 R494.1 R493.1 ; C1098.1 C1096.1 v2(137.1,45.23) ; C1120.1 71.94,48.47 v4(72.02,48.39) ; R541.2 v2(124.23,35.4) ; C326.1 122.85,39.82 v2(122.85,39.4) ; R519.1 v2(122.85,37.4) ; R1162.2 v4(70.93,43.47) ; R1141.2 v4(69.3,52.38)
  vias: v2(127.59,38.37) v2(128.6,35.4) v2(133.65,46.73) v2(143.91,47.19) v2(166.35,68.54)
