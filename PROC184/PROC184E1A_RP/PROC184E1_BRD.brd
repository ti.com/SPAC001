# Allegro board PROC184E1_BRD.brd (continued)
## Nets (continued)
OSPI/ONAND_MUX_SEL: R41.2 SW2.1 U59.B15(WKUP_GPIO0_6) U241.9(SEL1) U241.10(SEL2)
OSPI_DQS_R: R526.1 U246.C3(DS)
OSPI_RST#: U97.4(Y) U246.A4(RESET#)
PB_CAN_WAKEN: R726.1 R1302.1 SW15.2 SW15.3
PB_EXTINTN: U92.1(A) U98.15(OUT5)
PB_MCU_PORZ: U98.19(OUT1) U258.6(C)
PB_MCU_RESETZ: U98.18(OUT2) U101.2(B)
PB_PORZ: U98.17(OUT3) U247.2(B)
PB_RESETZ: U98.16(OUT4) U249.1(A)
PB_SYS_IRQZ: R585.2 U98.14(OUT6) U102.1(A) U123.3(M\R\)
PCIE0_4L_EP_RST_EN: R54.2 R73.2 U14.2(B) U43.8(P07)
PCIE0_4L_MODE_SEL: R37.2 SW2.5 U14.1(A) U15.1(O\E\) U43.5(P04)
PCIE0_4L_PERSTZ: J14.A11(PERST#) U15.4(B) U43.6(P05) U176.2(A)
PCIE0_4L_PRSNT#: R818.2 U43.11(P11)
PCIE0_4L_RC_RSTZ: R779.2 R782.1 U43.7(P06) U175.1(A)
PCIE0_4L_SCL: J14.B5(SMCLK) R147.2 U181.6(SC0)
PCIE0_4L_SDA: J14.B6(SMDAT) R146.2 U181.5(SD0)
PCIE0_AND_OUT: U15.2(A) U175.4(Y)
PCIE0_CLKREQ#: J14.B12(RSVD4) R823.2
PCIE0_INT#: J14.B11(WAKE#) R145.1 U181.4(I\N\T\0\)
PCIE0_NAND_OUT: U14.4(Y) U176.1(O\E\)
PCIE0_PORZ: R802.1 TP16.1(TP) U176.4(B) U251.3(B)
PCIE0_PRSNT1#: J14.A1(PRSNT1#) R813.2 R814.2 R815.2
PCIE0_PRSNT2#_1: J14.B17(PRSNT2#_1) R811.2
PCIE0_PRSNT2#_2: J14.B31(PRSNT2#_2) R812.2 R818.1
PCIE0_RX0_N: J14.A17(PERN0) U59.AL10(SERDES1_RX0_N)
PCIE0_RX0_P: J14.A16(PERP0) U59.AL11(SERDES1_RX0_P)
PCIE0_RX1_N: J14.A22(PERN1) U59.AN8(SERDES1_RX1_N)
PCIE0_RX1_P: J14.A21(PERP1) U59.AN9(SERDES1_RX1_P)
PCIE0_RX2_N: J14.A26(PERN2) U59.AM6(SERDES1_RX2_N)
PCIE0_RX2_P: J14.A25(PERP2) U59.AM7(SERDES1_RX2_P)
PCIE0_RX3_N: J14.A30(PERN3) U59.AL7(SERDES1_RX3_N)
PCIE0_RX3_P: J14.A29(PERP3) U59.AL8(SERDES1_RX3_P)
PCIE0_TCK: J14.A5(JTAG2) R84.2
PCIE0_TDI: J14.A6(JTAG3) R85.1
PCIE0_TDO: J14.A7(JTAG4) R86.1
PCIE0_TMS: J14.A8(JTAG5) R87.1
PCIE0_TRST#: J14.B9(JTAG1) R824.1
PCIE0_TX0_N: C627.2 J14.B15(PETN0)
PCIE0_TX0_P: C628.2 J14.B14(PETP0)
PCIE0_TX1_N: C625.2 J14.B20(PETN1)
PCIE0_TX1_P: C626.2 J14.B19(PETP1)
PCIE0_TX2_N: C623.2 J14.B24(PETN2)
PCIE0_TX2_P: C624.2 J14.B23(PETP2)
PCIE0_TX3_N: C621.2 J14.B28(PETN3)
PCIE0_TX3_P: C622.2 J14.B27(PETP3)
PCIE1/HYP0_RX0_N: J17.A17(PERN0) U59.AM12(SERDES0_RX0_N)
PCIE1/HYP0_RX0_P: J17.A16(PERP0) U59.AM13(SERDES0_RX0_P)
PCIE1/HYP0_RX1_N: J17.A22(PERN1) U59.AL13(SERDES0_RX1_N)
PCIE1/HYP0_RX1_P: J17.A21(PERP1) U59.AL14(SERDES0_RX1_P)
PCIE1/HYP0_RX2_N: J17.A26(PERN2) R885.1
PCIE1/HYP0_RX2_P: J17.A25(PERP2) R886.1
PCIE1/HYP0_RX3_N: J17.A30(PERN3) R867.2
PCIE1/HYP0_RX3_P: J17.A29(PERP3) R868.2
PCIE1/HYP0_TX0_N: C689.2 J17.B15(PETN0)
PCIE1/HYP0_TX0_P: C690.2 J17.B14(PETP0)
PCIE1/HYP0_TX1_N: C687.2 J17.B20(PETN1)
PCIE1/HYP0_TX1_P: C688.2 J17.B19(PETP1)
PCIE1/HYP0_TX2_N: C694.2 J17.B24(PETN2)
PCIE1/HYP0_TX2_P: C695.2 J17.B23(PETP2)
PCIE1/HYP0_TX3_N: C679.2 J17.B28(PETN3)
PCIE1/HYP0_TX3_P: C680.2 J17.B27(PETP3)
PCIE1_2L_EP_RST_EN: R182.2 R183.2 U33.2(B) U43.4(P03)
PCIE1_2L_MODE_SEL: R36.2 SW2.6 U33.1(A) U38.1(O\E\) U43.1(P00)
PCIE1_2L_RC_RSTZ: R901.1 R902.2 U43.3(P02) U190.1(A)
PCIE1_2L_SCL: J17.B5(SMCLK) R158.2 U181.10(SC1)
PCIE1_2L_SDA: J17.B6(SMDAT) R159.2 U181.9(SD1)
PCIE1_4L_PERSTZ: J17.A11(PERST#) U38.4(B) U43.2(P01) U196.2(A)
PCIE1_4L_PRSNT#: R878.2 U43.10(P10)
PCIE1_AND_OUT: U38.2(A) U190.4(Y)
PCIE1_CLKREQ#: J17.B12(RSVD4) R871.2
PCIE1_INT#: J17.B11(WAKE#) R160.1 U181.8(I\N\T\1\)
PCIE1_NAND_OUT: U33.4(Y) U196.1(O\E\)
PCIE1_PORZ: R912.1 TP40.1(TP) U196.4(B) U251.6(C)
PCIE1_PRSNT1#: J17.A1(PRSNT1#) R848.2 R853.2 R854.2
PCIE1_PRSNT2_1#: J17.B17(PRSNT2#_1) R882.2
PCIE1_PRSNT2_2#: J17.B31(PRSNT2#_2) R878.1 R879.2
PCIE1_TCK: J17.A5(JTAG2) R161.2
PCIE1_TDI: J17.A6(JTAG3) R162.1
PCIE1_TDO: J17.A7(JTAG4) R163.1
PCIE1_TMS: J17.A8(JTAG5) R164.1
PCIE1_TRST#: J17.B9(JTAG1) R873.1
PCIE_REFCLK0_OUT_N: R905.2 U59.AH14(PCIE_REFCLK1_N_OUT)
PCIE_REFCLK0_OUT_P: R906.2 U59.AH13(PCIE_REFCLK1_P_OUT)
PCIE_REFCLK1_OUT_N: R859.2 U59.AJ13(PCIE_REFCLK0_N_OUT)
PCIE_REFCLK1_OUT_P: R860.2 U59.AJ12(PCIE_REFCLK0_P_OUT)
PCIE_REFCLK2_OUT_N: TP10124.1(TP) U59.AH11(PCIE_REFCLK2_N_OUT)
PCIE_REFCLK2_OUT_P: TP10123.1(TP) U59.AH10(PCIE_REFCLK2_P_OUT)
PCIE_REFCLK3_OUT_N: TP272.1(TP) U59.AJ16(PCIE_REFCLK3_N_OUT)
PCIE_REFCLK3_OUT_P: TP266.1(TP) U59.AJ15(PCIE_REFCLK3_P_OUT)
PERIPH_RSTZ: J56.28 R964.2 U18.1(R\E\S\E\T\) U43.24(R\E\S\E\T\) U76.1(R\E\S\E\T\) U132.1(R\E\S\E\T\) U173.28(R\E\S\E\T\) U213.2(A)
PG_MCU_V2V5: R648.2 U125.5(EN) U138.3(PG)
PG_V1V2: R875.2 U186.3(PG)
PG_V2V5: R1207.2 U260.3(PG)
PHYIO_1V8_IN+: C710.2 R910.1 U192.D3(IN+) U193.10(VIN+)
PHYIO_1V8_IN-: C710.1 R909.1 U192.D1(BUS) U192.D2(IN-) U193.8(VBUS) U193.9(VIN-)
PLL_1V8_IN+: C951.2 R1036.1 U225.D3(IN+) U226.10(VIN+)
PLL_1V8_IN-: C951.1 R1031.1 U225.D1(BUS) U225.D2(IN-) U226.8(VBUS) U226.9(VIN-)
PM1_SCL: J50.36 R63.2 R1312.1 U19.2(1B1) U29.9(3A) U60.5(SCL) U61.A1(SCL) U64.A1(SCL) U65.5(SCL) U105.A1(SCL) U106.5(SCL) U114.A1(SCL) U114.B3(A0) U115.2(A0) U115.5(SCL) U118.5(SCL) U119.A1(SCL) U188.A1(SCL) U189.5(SCL) U207.A1(SCL) U208.5(SCL) U231.A1(SCL) U231.B3(A0) U232.2(A0) U232.5(SCL) U269.2(1A)
PM1_SCL_1: R1312.2 U83.5(SCL) U84.A1(SCL) U184.1(A1) U184.5(SCL) U185.A1(SCL) U185.C3(A1) U192.A1(SCL) U192.C3(A1) U193.1(A1) U193.5(SCL) U194.A1(SCL) U195.5(SCL) U198.A1(SCL) U198.B3(A0) U199.2(A0) U199.5(SCL) U225.A1(SCL) U225.C3(A1) U226.1(A1) U226.5(SCL) U229.5(SCL) U230.A1(SCL) U235.A1(SCL) U235.B3(A0) U235.C3(A1) U236.1(A1) U236.2(A0) U236.5(SCL)
PM1_SDA: J50.38 R61.2 R1311.1 U19.5(2B1) U29.12(4A) U60.4(SDA) U61.A2(SDA) U64.A2(SDA) U65.4(SDA) U105.A2(SDA) U106.4(SDA) U114.A2(SDA) U115.4(SDA) U118.2(A0) U118.4(SDA) U119.A2(SDA) U119.B3(A0) U188.A2(SDA) U189.4(SDA) U207.A2(SDA) U207.B3(A0) U208.2(A0) U208.4(SDA) U231.A2(SDA) U232.4(SDA) U269.5(2A)
PM1_SDA_1: R1311.2 U83.1(A1) U83.4(SDA) U84.A2(SDA) U84.B3(A0) U84.C3(A1) U184.2(A0) U184.4(SDA) U185.A2(SDA) U185.B3(A0) U192.A2(SDA) U193.4(SDA) U194.A2(SDA) U194.C3(A1) U195.1(A1) U195.4(SDA) U198.A2(SDA) U198.C3(A1) U199.1(A1) U199.4(SDA) U225.A2(SDA) U226.4(SDA) U229.1(A1) U229.4(SDA) U230.A2(SDA) U230.C3(A1) U235.A2(SDA) U236.4(SDA)
PM2_SCL: J50.37 R62.2 R1314.1 U19.3(1B2) U29.2(1A) U56.5(SCL) U57.A1(SCL) U93.A1(SCL) U94.5(SCL) U116.A1(SCL) U116.B3(A0) U117.2(A0) U117.5(SCL) U120.5(SCL) U121.A1(SCL) U128.2(A0) U128.5(SCL) U129.A1(SCL) U129.B3(A0) U203.5(SCL) U204.A1(SCL) U214.A1(SCL) U215.5(SCL) U218.5(SCL) U219.A1(SCL) U243.29(SCL) U269.12(4A)
PM2_SCL_1: R1314.2 U31.A1(SCL) U31.B3(A0) U31.C3(A1) U32.1(A1) U32.2(A0) U32.5(SCL) U99.A1(SCL) U99.C3(A1) U100.1(A1) U100.5(SCL) U171.A1(SCL) U171.C3(A1) U172.1(A1) U172.5(SCL) U209.5(SCL) U210.A1(SCL) U211.A1(SCL) U211.C3(A1) U212.1(A1) U212.5(SCL) U221.5(SCL) U222.A1(SCL) U223.A1(SCL) U223.B3(A0) U224.2(A0) U224.5(SCL) U238.A1(SCL) U239.5(SCL)
PM2_SDA: J50.39 R60.2 R1313.1 U19.6(2B2) U29.5(2A) U56.4(SDA) U57.A2(SDA) U93.A2(SDA) U94.4(SDA) U116.A2(SDA) U117.4(SDA) U120.2(A0) U120.4(SDA) U121.A2(SDA) U121.B3(A0) U128.4(SDA) U129.A2(SDA) U203.4(SDA) U204.A2(SDA) U214.A2(SDA) U214.B3(A0) U215.2(A0) U215.4(SDA) U218.4(SDA) U219.A2(SDA) U243.30(SDA) U269.9(3A)
PM2_SDA_1: R1313.2 U31.A2(SDA) U32.4(SDA) U99.A2(SDA) U99.B3(A0) U100.2(A0) U100.4(SDA) U171.A2(SDA) U172.4(SDA) U209.1(A1) U209.4(SDA) U210.A2(SDA) U210.C3(A1) U211.A2(SDA) U212.4(SDA) U221.1(A1) U221.4(SDA) U222.A2(SDA) U222.C3(A1) U223.A2(SDA) U223.C3(A1) U224.1(A1) U224.4(SDA) U238.A2(SDA) U238.B3(A0) U238.C3(A1) U239.1(A1) U239.2(A0) U239.4(SDA)
PM_I2C_OE#: Q1.3(D) R116.2 U19.15(O\E\)
PM_I2C_SEL: R64.2 R1138.1 U19.1(S) U59.A17(WKUP_GPIO0_66)
PM_OE#: Q2.3(D) R590.2 U269.1(1\O\E\) U269.4(2\O\E\) U269.10(3\O\E\) U269.13(4\O\E\)
PMIC_ENABLE: TP153.1(TP) U68.20(NPWRON/ENABLE) U268.9(3A)
PMIC_GPIO3: R1035.2 U68.46(GPIO3)
PMIC_GPIO4: R1026.2 U68.47(GPIO4)
PMIC_GPIO7: R1081.2 U68.18(GPIO7)
PMIC_GPIO8: R398.2 U68.41(GPIO8)
PMIC_POWER_EN1: R1061.2 U59.B16(PMIC_POWER_EN1)
PMIC_WDOG_DISABLE: R398.1 R1061.1 R1079.2 R1089.2 SW16.4
PORZ: TP182.1(TP) U59.D24(PORZ) U110.3(A) U252.4(Y)
PORZ_3V3: U110.4(B) U254.1(A)
PORZ_OE: R584.2 U110.5(OE)
R_CAN_STB: R788.2 R792.2 R794.2 U173.8(P07)
R_CAN_WKUP: R658.1 R659.2 U137.1(G)
R_CSI2_RSTZ_DV: R471.2 U80.7(2A2)
R_DP1_HPD: R776.1 U187.32(HPD)
R_GPIO_RGMII1_RST#: R777.2 R778.2 U173.1(P00)
R_MCAN3_RX: R677.2 U148.4(RXD)
R_MCAN3_WAKE: R723.2 U148.9(WAKE)
R_MCAN4_RX: R954.1 R955.1 U50.37(8B2)
R_MCAN4_RXD: R682.2 U152.4(RXD)
R_MCAN4_TX: R958.1 R959.1 U50.40(7B2)
R_MCAN5_RXD: R681.2 U151.4(RXD)
R_MCAN16_RXD: R683.2 U153.4(RXD)
R_MCU_ADC0_REF_N: J27.12 R1039.2
R_MCU_ADC0_REF_P: J27.10 R1049.2
R_MCU_ADC1_AIN5: R385.1 U59.A32(MCU_ADC1_AIN5)
R_MCU_ADC1_AIN6: R392.1 U59.A30(MCU_ADC1_AIN6)
R_MCU_ADC1_AIN7: R379.1 R384.1 U59.C28(MCU_ADC1_AIN7)
R_MCU_ADC_EXT_TRIGGER: R1098.1 R1099.1 TP154.1(TP) U59.B18(WKUP_GPIO0_10)
R_MCU_MCAN0_RX: R679.2 U149.4(RXD)
R_MCU_MCAN1_RX: R680.2 U150.4(RXD)
R_MCU_ONAND_DS: R532.1 U245.C3(DS)
R_MUX_USB0_DATA_N: R775.1 R796.1
R_MUX_USB0_DATA_P: R774.1 R795.1
R_RGMII1_INT#: R957.1 R962.1 R963.1 U50.48(3B2)
R_RGMII1_RD0: R1005.1 R1011.1 TP109.1(TP) U59.U32(MCASP1_ACLKX)
R_RGMII1_RD1: R363.1 R1004.1 R1010.1 TP110.1(TP) U59.M32(MCASP0_AXR12)
R_RGMII1_RD2: R365.1 R1002.1 R1008.1 TP112.1(TP) U59.L33(MCASP0_AXR13)
R_RGMII1_RD3: R367.1 R1000.1 R1006.1 TP113.1(TP) U59.U31(MCASP0_AXR14)
R_RGMII1_RX_CTL: R364.1 R1003.1 R1009.1 TP111.1(TP) U59.M33(MCASP0_AXR15)
R_RGMII1_RXC: R366.1 R1001.1 R1007.1 U59.P31(MCASP1_AXR3)
R_RGMII1_TD0: R989.1 R996.1 TP103.1(TP) U59.M31(MCASP0_AXR7)
R_RGMII1_TD1: R332.1 R990.1 R997.1 TP102.1(TP) U59.N30(MCASP0_AXR8)
R_RGMII1_TD2: R334.1 R986.1 R993.1 TP106.1(TP) U59.T33(MCASP0_AXR9)
R_RGMII1_TD3: R335.1 R985.1 R992.1 TP107.1(TP) U59.L32(MCASP0_AXR10)
R_RGMII1_TX_CTL: R333.1 R987.1 R994.1 TP105.1(TP) U59.P30(MCASP0_AXR11)
R_RGMII1_TXC: R988.1 R995.1 TP104.1(TP) U59.N31(MCASP1_AXR4)
R_SERDES0_REFCLK_N: C125.1 R168.2
R_SERDES0_REFCLK_P: C129.1 R169.2
R_SERDES1_REFCLK_N: C66.1 R167.2
R_SERDES1_REFCLK_P: C63.1 R177.2
R_SOC_SERDES0_REFCLK_N: R899.2 U59.AK15(SERDES0_REFCLK_N)
R_SOC_SERDES0_REFCLK_P: R900.2 U59.AK14(SERDES0_REFCLK_P)
R_SOC_SERDES1_REFCLK_N: R869.2 U59.AN5(SERDES1_REFCLK_N)
R_SOC_SERDES1_REFCLK_P: R870.2 U59.AN6(SERDES1_REFCLK_P)
R_SOC_SERDES4_REFCLK_N: R174.2 U59.AK21(SERDES4_REFCLK_N)
R_SOC_SERDES4_REFCLK_P: R175.2 U59.AK20(SERDES4_REFCLK_P)
R_SPI5_CLK: R1059.1 R1060.1 U58.16(7B3)
R_SPI5_CS0: R1093.1 R1094.1 U50.26(11B3)
R_SPI5_CS1: R1101.1 R1102.1 U58.24(10B3)
R_SPI5_D0: R1075.1 R1076.1 U50.28(12B3)
R_SPI5_D1: R1085.1 R1086.1 U50.20(8B3)
R_USB0_DATA_N: R29.2 U12.2(1D-)
R_USB0_DATA_P: R30.2 U12.1(1D+)
R_USB1_HUB_XI: C77.2 R89.2 R94.1 Y2.2
R_USB1_HUB_XO: C76.2 R88.2 R94.2 Y2.1
RES_LM5140: C217.1 U46.32(RES)
RES_LM5141: C318.1 U81.24(RES)
RES_LM5143: C117.1 U25.32(RES)
RESET_REQZ: TP321.1(TP) U59.G20(RESET_REQZ) U249.4(Y)
RESETSTATZ: J56.30 R564.1 R964.1 R1172.1 TP86.1(TP) U59.W32(RESETSTATZ)
RGMII1_100MBPS: J39.14 R1291.1 U126.3(DRAIN)
RGMII1_1000MBPS: J39.13 R1289.1 U272.3(DRAIN)
RGMII1_ACT_LED: J39.12 U140.3(DRAIN)
RGMII1_CLK_OUT: TP229.1(TP) U262.18(CLK_OUT)
RGMII1_D0_N: J39.10(MX0-) U262.2(TD_M_A)
RGMII1_D0_P: J39.9(MX0+) U262.1(TD_P_A)
RGMII1_D1_N: J39.8(MX1-) U262.5(TD_M_B)
RGMII1_D1_P: J39.7(MX1+) U262.4(TD_P_B)
RGMII1_D2_N: J39.6(MX2-) U262.8(TD_M_C)
RGMII1_D2_P: J39.5(MX2+) U262.7(TD_P_C)
RGMII1_D3_N: J39.4(MX3-) U262.11(TD_M_D)
RGMII1_D3_P: J39.3(MX3+) U262.10(TD_P_D)
RGMII1_GPIO0_100: R621.1 R629.2 U126.1(GATE) U262.39(GPIO_0)
RGMII1_GPIO1: R1232.1 R1235.2 U262.40(GPIO_1)
RGMII1_INT#: R957.2 R1245.1 U262.44(INT/PWDN)
RGMII1_LED0: R649.2 R654.1 U262.47(LED0)
RGMII1_LED1_1000: R1256.1 R1261.2 U262.46(LED1) U272.1(GATE)
RGMII1_LED2_ACT: R1249.2 R1254.1 U140.1(GATE) U262.45(LED2)
RGMII1_LED2_ANODE: J39.11 R1288.1
RGMII1_MDIO0_MDC: R349.1 U262.16(MDC)
RGMII1_MDIO0_MDIO: R344.1 U262.17(MDIO)
RGMII1_RBIAS: R1259.2 U262.12(RBIAS)
RGMII1_RD0: R1011.2 R1202.1
RGMII1_RD0_R: R1200.1 R1202.2 R1218.2 U262.33(RX_D0/SGMII_COP)
RGMII1_RD1: R1010.2 R1213.1
RGMII1_RD1_R: R1213.2 U262.34(RX_D1/SGMII_CON)
RGMII1_RD2: R1008.2 R1201.1
RGMII1_RD2_R: R1199.1 R1201.2 R1217.2 U262.35(RX_D2/SGMII_SOP)
RGMII1_RD3: R1006.2 R1212.1
RGMII1_RD3_R: R1212.2 U262.36(RX_D3/SGMII_SON)
RGMII1_RESET_N: U107.4(Y) U262.43(RESET_N)
RGMII1_RX_CTL: R1009.2 R1205.1
RGMII1_RX_CTL_R: R1205.2 R1221.2 R1224.1 U262.38(RX_CTRL)
RGMII1_RXC: R1007.2 R1214.1
RGMII1_RXC_R: R1214.2 U262.32(RX_CLK)
RGMII1_TD0: R996.2 U262.28(TX_D0/SGMII_SIN)
RGMII1_TD1: R997.2 U262.27(TX_D1/SGMII_SIP)
RGMII1_TD2: R993.2 U262.26(TX_D2)
RGMII1_TD3: R992.2 U262.25(TX_D3)
RGMII1_TX_CTL: R994.2 U262.37(TX_CTRL)
RGMII1_TXC: R995.2 U262.29(GTX_CLK)
RGMII1_XIN: C1208.2 U262.15(X_I) Y13.2
RGMII1_XOUT: C1219.2 U262.14(X_O) Y13.1
RGMII_REFCLK: J54.106 R126.2
RT_LM5141: R492.1 U81.4(RT)
RTC_REF_CLK: R613.2 R624.2 TP222.1(TP) U256.7(MFP)
RTC_XIN: C1173.1 U256.1(X1) Y11.2
RTC_XOUT: C1172.1 U256.2(X2) Y11.1
SEL_SDIO_3V3_1V8N: R316.1 U59.R31(MCAN15_RX) U281.6(IN2)
SERDES0_REXT: R947.1 U59.AG7(SERDES0_REXT)
SERDES0_RX2_N: R885.2 R891.2 U59.AN15(SERDES0_RX2_N)
SERDES0_RX2_P: R886.2 R892.2 U59.AN14(SERDES0_RX2_P)
SERDES0_RX3_N: R867.1 R876.1 U59.AL17(SERDES0_RX3_N)
SERDES0_RX3_P: R868.1 R877.1 U59.AL16(SERDES0_RX3_P)
SERDES0_TX2_N: C694.1 C696.1 U59.AM16(SERDES0_TX2_N)
SERDES0_TX2_P: C695.1 C697.1 U59.AM15(SERDES0_TX2_P)
SERDES0_TX3_N: C679.1 C683.2 U59.AK18(SERDES0_TX3_N)
SERDES0_TX3_P: C680.1 C684.2 U59.AK17(SERDES0_TX3_P)
SERDES1_REXT: R945.1 U59.AH9(SERDES1_REXT)
SERDES4_REXT: R938.1 U59.AH23(SERDES4_REXT)
SOC_EDP_IRQ: R1017.2 U220.4(Y) U227.3(1B2)
SOC_EMU0: R241.2 SW4.1 TP78.1(TP) U47.9(3A) U59.F19(EMU0)
SOC_EMU1: R232.2 SW4.2 TP72.1(TP) U47.12(4A) U59.E17(EMU1)
SOC_EXTINTN: R550.1 U59.Y29(EXTINTN) U92.4(Y)
SOC_GPIO0_21_MUX: R291.1 R294.1 U59.P33(MCASP2_ACLKX)
SOC_I2C1_SCL_R: R95.2 U19.4(1A)
SOC_I2C1_SDA_R: R91.2 U19.7(2A)
SOC_I2C3_SDA_MUX: R258.1 R259.1 U59.R32(MCASP2_AXR1)
SOC_MCAN5_RX_MUX: R302.1 R304.1 U59.K31(MCASP0_AFSX)
SOC_MCAN5_TX_MUX: R311.1 R315.1 U59.J30(MCASP0_ACLKX)
SOC_MCU_OSPI0_CLK: R1119.2 U241.2(A0)
SOC_MCU_OSPI0_CLK_R: R1119.1 U59.D8(MCU_OSPI0_CLK)
SOC_MCU_OSPI0_CS0#: U59.F12(MCU_OSPI0_CSN0) U241.4(A2)
SOC_MCU_OSPI0_D0: R1116.1 U59.E10(MCU_OSPI0_D0) U241.6(A4)
SOC_MCU_OSPI0_D1: R1117.1 U59.F9(MCU_OSPI0_D1) U241.5(A3)
SOC_MCU_OSPI0_D2: U59.E9(MCU_OSPI0_D2) U241.12(A7)
SOC_MCU_OSPI0_D3: U59.D11(MCU_OSPI0_D3) U241.7(A5)
SOC_MCU_OSPI0_D4: R1115.1 U59.D9(MCU_OSPI0_D4) U241.13(A8)
SOC_MCU_OSPI0_D5: R1114.1 U59.C9(MCU_OSPI0_D5) U241.14(A9)
SOC_MCU_OSPI0_D6: U59.C7(MCU_OSPI0_D6) U241.15(A10)
SOC_MCU_OSPI0_D7: U59.C8(MCU_OSPI0_D7) U241.16(A11)
SOC_MCU_OSPI0_DQS: U59.C10(MCU_OSPI0_DQS) U241.11(A6)
SOC_MDIO1_MDC_MUX: R282.1 R283.1 U59.G32(MCASP2_AFSX)
SOC_MDIO1_MDIO: R263.1 R264.1 R1292.2 U59.K32(MCASP2_AXR0)
SOC_PORZ_OUT: J54.64 R462.1 R1111.1 R1185.1 R1187.2 R1194.1 TP206.1(TP) U11.18(GRSTZ) U39.1(A) U40.8(RESETN/SYNC) U107.1(A) U175.2(B) U181.3(R\E\S\E\T\) U190.2(B)
SOC_PWR_WKN: R627.1 R1026.1 U134.4(Y) U137.3(D) U278.4(Y)
SOC_SAFETY_ERRZ: R1035.1 U59.Y31(SOC_SAFETY_ERRORN)
SOC_SERDES0_REFCLK_N: R168.1 R170.1 R895.1 R899.1 R905.1
SOC_SERDES0_REFCLK_P: R169.1 R171.1 R896.1 R900.1 R906.1
SOC_SERDES1_REFCLK_N: R166.1 R167.1 R859.1 R861.1 R869.1
SOC_SERDES1_REFCLK_P: R176.1 R177.1 R860.1 R862.1 R870.1
SOC_SERDES4_REFCLK_N: R122.2 R129.1 R174.1
SOC_SERDES4_REFCLK_P: R123.2 R130.1 R175.1
SOC_TCK: TP82.1(TP) U47.4(1A) U59.F21(TCK)
SOC_TDI: TP69.1(TP) U59.V33(TDI) U206.7(2A)
SOC_TDO: TP71.1(TP) U59.W33(TDO) U206.4(1A)
SOC_TMS: TP68.1(TP) U59.V32(TMS) U206.9(3A)
SOC_TRST#: TP84.1(TP) U47.7(2A) U59.F17(TRSTN)
SOC_UART8_CTSN_MUX: R275.1 R276.1 U59.F32(MCASP0_AXR0)
SOC_UART8_RTSN_MUX: R268.1 R270.1 U59.H32(MCASP0_AXR1)
SOC_WKUP_I2C0_SCL: R445.2 U59.A16(WKUP_I2C0_SCL) U78.1(1A) U268.3(1B2)
SOC_WKUP_I2C0_SDA: R478.2 U59.D23(WKUP_I2C0_SDA) U78.5(2A) U268.6(2B2)
SPI5_CLK: J26.1 R1060.2
SPI5_CS0: J26.5 R1102.2
SPI5_CS1: J26.4 R1094.2
SPI5_D0: J26.2 R1076.2
SPI5_D1: J26.3 R1086.2
SS1_LM5140: C205.1 U46.30(SS1)
SS1_LM5143: C123.1 U25.1(SS2) U25.30(SS1)
SS2_LM5140: C223.1 U46.1(SS2)
SS_LM5141: C314.1 U81.22(SS)
SVS_ENABLE: R545.2 U87.5(ACT) U89.5(ACT) U268.12(4A)
SVS_SYNCN: R538.1 U87.9(NSYNC) U89.9(NSYNC)
SW_LM5141: C302.1 L35.1 U81.12(SW) U237.1(S1) U237.2(S2) U237.3(S3) U240.5(D)
SW_PB_EXTINTN: SW6.2 SW6.3 U98.6(IN5)
SW_PB_MCU_PORZ: SW14.2 SW14.3 U98.2(IN1)
SW_PB_MCU_RESETZ: SW12.2 SW12.3 U98.3(IN2)
SW_PB_PORZ: SW10.2 SW10.3 U98.4(IN3)
SW_PB_RESETZ: SW9.2 SW9.3 U98.5(IN4)
SW_PB_SYS_IRQZ: SW5.2 SW5.3 U98.7(IN6)
SYNOUT_LM5140: TP75.1(TP) U46.39(SYNOUT)
SYNOUT_LM5143: TP23.1(TP) U25.39(SYNCOUT)
SYS_BOOTMODE0: R554.2 SW11.1 U243.9(P10) U248.4(1A1)
SYS_BOOTMODE1: R549.2 SW11.2 U243.10(P11) U248.5(1A2)
SYS_BOOTMODE2: R537.2 SW11.3 U243.11(P12) U248.6(2A1)
SYS_BOOTMODE3: R530.2 SW11.4 U243.12(P13) U248.7(2A2)
SYS_BOOTMODE4: R515.2 SW11.5 U243.13(P14) U244.4(1A1)
SYS_BOOTMODE5: R503.2 SW11.6 U243.14(P15) U244.5(1A2)
SYS_BOOTMODE6: R497.2 SW11.7 U243.15(P16) U244.6(2A1)
SYS_BOOTMODE7: R484.2 SW11.8 U243.16(P17) U244.7(2A2)
SYS_IRQZ: U59.B17(WKUP_GPIO0_7) U102.4(Y)
SYS_MCU_EN: TP226.1(TP) U130.4(Y) U268.10(3B2) U268.13(4B2)
SYS_MCU_PWRDN: R428.1 R578.1 U59.E18(MCU_SPI0_D0) U113.1(CLK)
SYS_PWR_PG: Q2.1(G) U130.6(C) U255.4(Y) U258.3(B)
SYSBOOT_BUF_ENZ: R1172.2 R1181.2 R1185.2 U253.2(B)
TA_BM_IOEXP_RSTN: J50.33 R137.1 U10.9(A7) U243.28(R\E\S\E\T\)
TA_BOOTMODE_CNTL#: J50.32 R142.1 TP26.1(TP) U10.8(A6)
TA_PORZN: J50.27 R827.1 U10.4(A2) U124.3(B) U251.1(A)
TA_POWERDOWNZ: J50.26 R623.1 U10.3(A1) U130.3(B)
TA_RESETZ: J50.28 R826.1 U10.5(A3) U249.3(B)
TA_SOC_INT1Z: J50.30 R144.1 U10.6(A4) U92.2(B)
TA_SOC_INT2Z: J50.31 R143.1 U10.7(A5) U102.2(B)
TCA6424_EXP_INT: R1135.1 U243.32(I\N\T\)
TCA9543_A0: R821.1 R822.2 U181.1(A0)
TCA9543_A1: R819.2 R820.1 U181.2(A1)
TCA9543_INT#: R157.1 U181.11(I\N\T\)
TEMP_DIODE_P0: TP162.1(TP) U59.E28(RSVD_E28)
TEMP_DIODE_P1: TP132.1(TP) U59.F27(RSVD_F27)
TIMER_IO0_R: R292.2 TP81.1(TP) U59.AA32(TIMER_IO0)
TIMER_IO1: R310.2 TP93.1(TP) U59.W30(TIMER_IO1)
TM4C129_RST#: R735.2 TP3.1(TP)
TM4C129_TCK: TP12.1(TP) U170.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP8.1(TP) U170.98(PC2/TDI)
TM4C129_TDO: TP7.1(TP) U170.97(PC3/TDO/SWO)
TM4C129_TMS: TP11.1(TP) U170.99(PC1/TMS/SWDIO)
TMP1_ADD0: R498.2 R499.2 U82.5(ADD0)
TMP1_ADD1: R472.2 R479.2 U82.3(ADD1)
TMP2_ADD0: R353.2 R358.1 U55.5(ADD0)
TMP2_ADD1: R331.2 R336.2 U55.3(ADD1)
TRC_CLK: R355.1 U58.30(12B1)
TRC_CTL: R348.1 U58.52(2B1)
TRC_DATA0: R347.1 U227.2(1B1)
TRC_DATA0_MUX: U59.T31(MCAN13_TX) U227.4(1A)
TRC_DATA1: R341.1 U58.32(11B1)
TRC_DATA2: R340.1 U58.54(1B1)
TRC_DATA3: R330.1 U58.50(3B1)
TRC_DATA4: R329.1 U50.50(3B1)
TRC_DATA5: R326.1 U50.30(12B1)
TRC_DATA6: R325.1 U58.43(6B1)
TRC_DATA7: R320.1 U58.41(7B1)
TRC_DATA8: R319.1 U58.45(5B1)
TRC_DATA9: R313.1 U50.47(4B1)
TRC_DATA10: R312.1 U58.36(9B1)
TRC_DATA11: R306.1 U58.34(10B1)
TRC_DATA12: R305.1 U50.43(6B1)
TRC_DATA13: R301.1 U50.34(10B1)
TRC_DATA14: R300.1 U50.45(5B1)
TRC_DATA15: R296.1 U50.36(9B1)
TRC_DATA16: R295.1 U50.32(11B1)
TRC_DATA17: R286.1 U58.47(4B1)
TRC_DATA18: R285.1 U58.39(8B1)
TRC_DATA19: R350.2 U50.41(7B1)
TRC_DATA20: R343.2 U50.39(8B1)
TXS0108_OE: R1134.2 U242.10(OE)
UART2_RXD: R1251.1 U264.5(1A2)
UART2_TXD: R1228.2 R1247.1 U264.7(2A2)
UART3_RXD: U58.48(3B2) U143.4(1A1)
UART3_RXD_MUX: U58.6(3A) U59.G28(MCAN2_TX)
UART3_TXD: R635.2 U112.6(2B2) U143.6(2A1)
UART3_TXD_MUX: U58.9(4A) U59.F33(MCAN2_RX)
UART5_RXD: U59.T29(MCAN12_RX) U264.4(1A1)
UART5_TXD: R1227.2 U59.P29(MCAN12_TX) U264.6(2A1)
UART6_RXD: R581.2 R602.1
UART6_RXD_MUX: U58.2(1A) U59.E33(GPIO0_12)
UART6_TXD: R576.2 R603.1
UART6_TXD_MUX: U58.4(2A) U59.G33(MCAN1_TX)
UART8_CTSN: U50.44(5B2) U273.5(1A2)
UART8_CTSN_MUX: R276.2 U50.11(5A)
UART8_RTSN: U50.42(6B2) U273.7(2A2)
UART8_RTSN_MUX: R270.2 U50.13(6A)
UART8_RXD: U59.Y32(SPI0_CS1) U273.4(1A1)
UART8_TXD: R1262.2 U59.V31(SPI0_CLK) U273.6(2A1)
UART9_RXD: R604.1 R1112.2
UART9_RXD_MUX: U58.11(5A) U59.G31(MCASP1_AXR1)
UART9_TXD: R605.1 R1107.2
UART9_TXD_MUX: U58.13(6A) U59.J31(MCASP1_AXR2)
UFS0_REF_CLK: U26.H1(REF_CLK) U59.AJ5(UFS0_REF_CLK)
UFS0_RST#: U26.H2(RESET_N) U59.AJ7(UFS0_RSTN)
UFS0_RX0_N: U26.K1(DOUT0_C) U59.AK5(UFS0_RX_DN0)
UFS0_RX0_P: U26.K2(DOUT0_T) U59.AK6(UFS0_RX_DP0)
UFS0_RX1_N: U26.M1(DOUT1_C) U59.AL4(UFS0_RX_DN1)
UFS0_RX1_P: U26.M2(DOUT1_T) U59.AL5(UFS0_RX_DP1)
UFS0_TX0_N: U26.F2(DIN0_C) U59.AN2(UFS0_TX_DN0)
UFS0_TX0_P: U26.F1(DIN0_T) U59.AN3(UFS0_TX_DP0)
UFS0_TX1_N: U26.D2(DIN1_C) U59.AM3(UFS0_TX_DN1)
UFS0_TX1_P: U26.D1(DIN1_T) U59.AM4(UFS0_TX_DP1)
USB0_D_N: R56.2 R796.2 U59.AH16(USB0_DM)
USB0_D_P: R57.2 R795.2 U59.AH17(USB0_DP)
USB0_DATA_N: L7.4(OUT2) R29.1 R775.2
USB0_DATA_P: L7.1(IN1) R30.1 R774.2
USB0_DRVVBUS: R803.1 U161.1(A) U177.11(3B1)
USB0_DRVVBUS_MUX: R310.1 U177.9(3A)
USB0_ID: R752.2 U165.4(B) U177.2(1B1)
USB0_ID_MUX: U59.AH20(USB0_ID) U177.4(1A)
USB0_RCALIB: R198.1 U59.AH22(USB0_RCALIB)
USB0_VBUS_MUX: U59.AG19(USB0_VBUS) U177.7(2A)
USB0_VBUS_SOC: R13.2 R14.2 U177.5(2B1)
USB1_DN1_D_N: L39.2(IN2) U11.34(USB_DM_DN1)
USB1_DN1_D_P: L39.3(OUT1) U11.33(USB_DP_DN1)
USB1_DN1_PE: R27.2 R772.2 U11.4(PWRCTL1/BATEN1)
USB1_DN2_D_N: L38.1(IN1) U11.42(USB_DM_DN2)
USB1_DN2_D_P: L38.4(OUT2) U11.41(USB_DP_DN2)
USB1_DN2_PE: R25.2 R740.2 U11.3(PWRCTL2/BATEN2)
USB1_DN3_D_N: L8.1(IN1) U11.50(USB_DM_DN3)
USB1_DN3_D_P: L8.4(OUT2) U11.49(USB_DP_DN3)
USB1_DN3_PE: R20.2 R46.2 U11.1(PWRCTL3/BATEN3)
USB1_DN4_D_N: J56.115 U11.57(USB_DM_DN4)
USB1_DN4_D_P: J56.117 U11.56(USB_DP_DN4)
USB1_DN4_PE: J56.113 R765.2 U11.64(PWRCTL4/BATEN4)
USB1_DRVVBUS: R58.1 R806.1 R807.1 U177.10(3B2)
USB1_HUB_AUTOEN#: R51.2 R787.1 U11.13(AUTOENZ/HS_SUSPEND)
USB1_HUB_D_N: U11.22(USB_DM_UP) U12.4(2D-)
USB1_HUB_D_P: U11.21(USB_DP_UP) U12.3(2D+)
USB1_HUB_FULLPWRMGMT#: R31.2 U11.8(FULLPWRMGMTZ/SMBA1)
USB1_HUB_GANGED: R48.2 U11.10(GANGED/SMBA2/HS_UP)
USB1_HUB_PWRCTR_POL: R47.2 R781.1 U11.9(PWRCTL_POL)
USB1_HUB_R1: R82.2 U11.32(USB_R1)
USB1_HUB_REFCLK: R81.2 R115.2
USB1_HUB_TEST: R79.2 U11.17(TEST)
USB1_HUB_VBUS: R58.2 R59.2 U11.16(USB_VBUS)
USB1_HUB_XI: R81.1 R89.1 U11.30(XI)
USB1_HUB_XO: R88.1 U11.29(XO)
USB1_ID: R797.2 U177.3(1B2)
USB1_VBUS_SOC: R804.1 R806.2 U177.6(2B2)
USB2.0_MUX_OEN: R799.1 U12.6(O\E\) U177.12(4A) U177.15(O\E\)
USB2.0_MUX_SEL: R785.2 R790.1 U12.9(S) U173.13(P14) U177.1(S)
USB_3V3_IN+: C699.2 R888.1 U184.10(VIN+) U185.D3(IN+)
USB_3V3_IN-: C699.1 R887.1 U184.8(VBUS) U184.9(VIN-) U185.D1(BUS) U185.D2(IN-)
USB_CONN#1_D_N: J5.2 L8.2(IN2) U9.5(D1)
USB_CONN#1_D_P: J5.3 L8.3(OUT1) U9.6(D2)
USB_CONN#2_D_N: J5.6 L38.2(IN2) U160.5(D1)
USB_CONN#2_D_P: J5.7 L38.3(OUT1) U160.6(D2)
USB_DM_FT2232: J48.2(D-) U144.7(DM) U156.3(IO1)
USB_DM_FT4232: J49.2(D-) U145.7(DM) U157.5(IO2)
USB_DP_FT2232: J48.3(D+) U144.8(DP) U156.5(IO2)
USB_DP_FT4232: J49.3(D+) U145.8(DP) U157.3(IO1)
USB_FT2232_EARTH: J48.SH1 J48.SH2 J48.SH3 J48.SH4 J48.SH5 J48.SH6 R728.1
USB_FT4232_EARTH: J49.SH1 J49.SH2 J49.SH3 J49.SH4 J49.SH5 J49.SH6 R729.1
USB_TYPEA_EARTH1: C547.2 J5.SH1 J5.SH2 J5.SH3 J5.SH4 R737.2
USBC_CC1: J4.A5(CC1) U158.1(CC1) U164.2(IO2)
USBC_CC2: J4.B5(CC2) U158.2(CC2) U164.1(IO1)
USBC_CTRL1_SW: R763.2 R764.1 U162.3(DRAIN)
USBC_CURRENT_MODE: R731.2 U158.3(CURRENT_MODE)
USBC_DATA_CONN_N: J4.A7(D-_1) J4.B7(D-_2) L7.3(OUT1) U5.1(IO1)
USBC_DATA_CONN_P: J4.A6(D+_1) J4.B6(D+_2) L7.2(IN2) U5.2(IO2)
USBC_DIR_SOC: R734.1 U59.F11(MCU_OSPI0_CSN1) U158.11(DIR)
USBC_EARTH: C2.2 J4.SH1 J4.SH2 J4.SH3 J4.SH4 R730.2
USBC_ID: R745.1 U158.9(ID) U165.1(O\E\)
USBC_MODE_SEL0: R38.2 SW2.4 U7.1(GATE) U173.6(P05)
USBC_MODE_SEL1: R39.2 SW2.3 U4.1(GATE) U162.1(GATE) U173.5(P04)
USBC_OUT1: R743.1 R753.2 TP253.1(TP) U158.7(OUT1)
USBC_OUT2: R744.2 TP254.1(TP) U158.8(OUT2)
USBC_PD_BOOT: C568.2 U8.32(BOOT)
USBC_PD_CC1: R745.2 U8.20(CC1)
USBC_PD_CSN/OUT: C3.1 C7.1 C20.2 R6.2 U1.1(DRAIN1) U8.13(CSN/OUT)
USBC_PD_CSP: R11.1 U8.14(CSP)
USBC_PD_CTRL1: U8.5(CTRL1) U161.4(Y)
USBC_PD_CTRL2: R28.1 U8.6(CTRL2)
USBC_PD_FAULT#: R748.1 U8.24(F\A\U\L\T\)
USBC_PD_ILIMIT: R18.1 U8.12(ILIMIT)
USBC_PD_IMON: R24.1 U8.11(IMON)
USBC_PD_LD_DET#: R746.2 R752.1 U8.23(L\D\_\D\E\T\) U166.1(G)
USBC_PD_LS_GD: U1.5(GATE) U8.10(LS_GD)
USBC_PD_POL#: R747.1 U8.22(P\O\L\)
USBC_PD_RT/SYNC: R26.1 U8.9(RT/SYNC)
USBC_PD_SW: C568.1 L4.1 U8.28(SW1) U8.29(SW2) U8.30(SW3) U8.31(SW4)
USBC_PORT: R8.1 R10.1 R16.1 U158.4(PORT)
USBC_PORT_SW1: R10.2 U4.3(DRAIN)
USBC_PORT_SW2: R16.2 U7.3(DRAIN)
USBC_PWR_EN: R783.2 U8.4(EN/UVLO) U173.4(P03)
USBC_SS_RX1_CONN_N: D2.1(I/O) J4.B10(RX1-) L3.2(IN2)
USBC_SS_RX1_CONN_P: D4.1(I/O) J4.B11(RX1+) L3.3(OUT1)
USBC_SS_RX1_N: L3.1(IN1) R891.1
USBC_SS_RX1_P: L3.4(OUT2) R892.1
USBC_SS_RX2_CONN_N: D6.1(I/O) J4.A10(RX2-) L5.2(IN2)
USBC_SS_RX2_CONN_P: D5.1(I/O) J4.A11(RX2+) L5.3(OUT1)
USBC_SS_RX2_N: L5.1(IN1) R876.2
USBC_SS_RX2_P: L5.4(OUT2) R877.2
USBC_SS_TX1_CONN_N: D7.1(I/O) J4.A3(TX1-) L6.3(OUT1)
USBC_SS_TX1_CONN_P: D8.1(I/O) J4.A2(TX1+) L6.2(IN2)
USBC_SS_TX1_N: C696.2 L6.4(OUT2)
USBC_SS_TX1_P: C697.2 L6.1(IN1)
USBC_SS_TX2_CONN_N: D1.1(I/O) J4.B3(TX2-) L2.3(OUT1)
USBC_SS_TX2_CONN_P: D3.1(I/O) J4.B2(TX2+) L2.2(IN2)
USBC_SS_TX2_N: C683.1 L2.4(OUT2)
USBC_SS_TX2_P: C684.1 L2.1(IN1)
USBC_VBUS_DET: R732.1 U158.5(VBUS_DET)
USBC_VCON_FAULT#: R739.2 TP252.1(TP) U158.6(V\C\O\N\N\_\F\A\U\L\T\)
USER_INPUT1: R32.2 SW2.10 U173.22(P25)
USER_LED1: LD2.1 U173.23(P26)
USER_LED2: LD3.1 U173.24(P27)
V_3V3: C58.2 C82.2 C84.1 C101.1 C112.1 C120.1 C126.1 C629.1 R53.2 R110.2 R136.1 R136.3 R150.2 R165.1
V_12V0: C287.1 C290.1 C295.2 R418.3 R449.2 U81.17(VOUT)
VBUS_5V_WIFI/BT: C549.1 C561.1 J2.1 U163.4(OUT)
VCAP_MCU_VDDS0: C1048.1 U59.J25(CAP_VDDS0_MCU)
VCAP_MCU_VDDS1: C1046.1 U59.J23(CAP_VDDS1_MCU)
VCAP_MCU_VDDS2: C1047.1 U59.J24(CAP_VDDS2_MCU)
VCAP_VDDS0: C927.1 U59.T27(CAP_VDDS0)
VCAP_VDDS2: C1041.1 U59.P27(CAP_VDDS2)
VCAP_VDDS5: C974.1 U59.M27(CAP_VDDS5)
VCAPL: C53.1 U16.4(VCAP)
VCOMAD: C444.1 C450.1 C466.1 C487.1 C508.1 R657.1 R666.1 U135.3(+INA) U135.5(+INB) U136.1(OUTA) U136.2(-INA) U141.3(+INA) U141.5(+INB) U146.3(+INA) U146.5(+INB)
VCOMAD_CODEC: C1238.1 U136.3(+INA) U136.5(+INB) U154.1(VCOMAD)
VCOMAD_SPARE: TP233.1(TP) U136.6(-INB) U136.7(OUTB)
VCOMDA: C544.1 U154.15(VCOMDA)
VCSP_USBC_PD: C4.1 C5.1 C7.2 C9.1 C10.1 C559.2 L4.2 R6.1 R11.2 U166.3(D)
VDA_ADC0_REFN: C940.2 C950.2 C976.2 R1027.1 R1037.1 R1039.1 U59.C26(MCU_ADC0_REFN)
VDA_ADC0_REFP: C950.1 C976.1 FL175.2 R1049.1 U59.D25(MCU_ADC0_REFP)
VDA_ADC1_REFN: C905.2 C911.2 C925.2 R1022.1 R1023.1 U59.D29(MCU_ADC1_REFN)
VDA_ADC1_REFP: C905.1 C911.1 FL132.2 U59.C30(MCU_ADC1_REFP)
VDA_ADC_1V8: C989.1 C1002.1 C1018.1 FL176.1 U59.J28(VDDA_ADC0) U59.K28(VDDA_ADC1)
VDA_CSIRX0_1_0V8: C730.1 C782.1 C826.1 C841.1 FL71.2 U59.AG24(VDDA_0P8_CSIRX0_1)
VDA_CSIRX0_1_1V8: C731.1 C773.1 C851.1 C859.1 FL76.2 U59.AF25(VDDA_1P8_CSIRX0_1#AF25) U59.AF26(VDDA_1P8_CSIRX0_1#AF26)
VDA_CSIRX2_0V8: C749.1 C758.1 C837.1 FL89.2 U59.AG26(VDDA_0P8_CSIRX2)
VDA_CSIRX2_1V8: C750.1 C777.1 C827.1 C863.1 FL81.2 U59.AF27(VDDA_1P8_CSIRX2#AF27) U59.AG27(VDDA_1P8_CSIRX2#AG27)
VDA_DLL_0V8: FL95.2 FL161.2 FL196.2 R1052.2 TP141.1(TP) U217.1(G)
VDA_DLL_0V8_N: R558.2 R1052.1 TP194.1(TP)
VDA_DLL_0V8_P: R562.2 R1052.4 TP195.1(TP)
VDA_DLL_0V8_REG: C281.1 R1052.3 U68.9(VOUT_LDO3)
VDA_DLL_MMC0_0V8: C762.1 C819.1 C880.1 FL95.1 U59.AD7(VDDA_0P8_DLL_MMC0)
VDA_DSITX_0V8: C747.1 C756.1 C832.1 C833.1 FL87.2 U59.AG22(VDDA_0P8_DSITX) U59.AG23(VDDA_0P8_DSITX_C)
VDA_DSITX_1V8: C729.1 C776.1 C856.1 C857.1 FL70.2 U59.AF22(VDDA_1P8_DSITX#AF22) U59.AF23(VDDA_1P8_DSITX#AF23)
VDA_MCU_1V8: C986.1 C1004.1 C1006.1 C1009.1 C1017.1 C1042.1 C1045.1 C1138.2 C1175.2 C1183.1 C1184.1 FL132.1 FL175.1 FL176.2 R1033.2 R1044.2 R1062.2 TP134.1(TP) U59.J27(VDDA_WKUP) U59.K24(VDDA_MCU_TEMP) U59.K26(VDDA_MCU_PLLGRP0) U59.L26(VDDA_POR_WKUP) U124.5(VCC) U252.5(VCC) U258.5(VCC)
VDA_MCU_1V8_N: R573.2 R1044.1 TP201.1(TP)
VDA_MCU_1V8_P: R572.2 R1044.4 TP200.1(TP)
VDA_MCU_1V8_REG: C277.1 C381.1 C393.1 R1044.3 U68.7(VOUT_LDO4) U104.1(VCCA) U110.1(VCCA)
VDA_PHY_1V8: C340.1 FL65.1 FL67.2 FL70.1 FL76.1 FL81.1 FL82.1 FL96.2 R243.2 TP67.1(TP) U87.3(VMON4)
VDA_PHY_1V8_N: R243.1 R909.2 TP265.1(TP)
VDA_PHY_1V8_P: R243.4 R910.2 TP270.1(TP)
VDA_PHY_1V8_PG: R209.1 R1298.2 TP52.1(TP) U41.5(PG)
VDA_PHY_1V8_REG: C185.1 C192.1 R209.2 R235.2 R243.3 U41.1(OUT)
VDA_PLL_1V8: C330.1 C865.1 C866.1 C878.1 C885.1 C893.1 C898.1 C900.1 C901.1 C908.1 C909.1 C910.1 C921.1 C932.1 C967.1 C969.1 C983.1 C993.1 C997.1 R377.2 TP120.1(TP) U59.AB16(VDDA_TEMP4) U59.AC11(VDDA_TEMP3) U59.AD20(VDDA_PLLGRP10) U59.AE11(VDDA_PLLGRP2) U59.K10(VDDA_TEMP1) U59.K13(VDDA_PLLGRP8) U59.L27(VDDA_OSC1) U59.M10(VDDA_PLLGRP7) U59.N19(VDDA_PLLGRP6) U59.T12(VDDA_PLLGRP5) U59.U21(VDDA_TEMP2) U59.V24(VDDA_PLLGRP9) U59.V25(VDDA_PLLGRP1) U59.V26(VDDA_TEMP0) U59.W21(VDDA_PLLGRP12) U59.W25(VDDA_PLLGRP0) U59.Y24(VDDA_PLLGRP13) U87.1(VMON3)
VDA_PLL_1V8_N: R377.1 R1031.2 TP307.1(TP)
VDA_PLL_1V8_P: R377.4 R1036.2 TP309.1(TP)
VDA_PLL_1V8_PG: R1294.2 R1296.1 U63.5(PG)
VDA_PLL_1V8_REG: C256.1 R377.3 R1295.2 R1296.2 U63.1(OUT)
VDA_PLL_DDR0_0V8: C942.1 C947.1 C948.1 FL161.1 U59.P8(VDDA_0P8_PLL_DDR0)
VDA_PLL_DDR1_0V8: C1007.1 C1077.1 C1093.1 FL196.1 U59.J11(VDDA_0P8_PLL_DDR1)
VDA_SERDES0_1_0V8: C743.1 C752.1 C821.1 C824.1 C835.1 C840.1 FL83.2 U59.AF12(VDDA_0P8_SERDES0_1#AF12) U59.AG10(VDDA_0P8_SERDES0_1#AG10) U59.AG13(VDDA_0P8_SERDES0_1#AG13)
VDA_SERDES0_1_1V8: C742.1 C751.1 C844.1 C845.1 FL82.2 U59.AG11(VDDA_1P8_SERDES0_1#AG11) U59.AG12(VDDA_1P8_SERDES0_1#AG12)
VDA_SERDES4_0V8: C744.1 C753.1 C829.1 C830.1 FL84.2 U59.AG15(VDDA_0P8_SERDES4#AG15) U59.AG16(VDDA_0P8_SERDES4#AG16)
VDA_SERDES4_1V8: C724.1 C778.1 C850.1 FL65.2 U59.AF15(VDDA_1P8_SERDES4) U59.AG21(VDDA_1P8_SERDES2_4)
VDA_SERDES_C0_1_0V8: C765.1 C813.1 C847.1 C854.1 C860.1 C862.1 FL94.2 U59.AF10(VDDA_0P8_SERDES_C0_1#AF10) U59.AF13(VDDA_0P8_SERDES_C0_1#AF13)
VDA_SERDES_C4_0V8: C725.1 C780.1 C853.1 C867.1 FL66.2 U59.AE15(VDDA_0P8_SERDES_C4#AE15) U59.AF16(VDDA_0P8_SERDES_C4#AF16)
VDA_UFS_0V8: C764.1 C818.1 C855.1 FL97.1 U59.AF9(VDDA_0P8_UFS)
VDA_UFS_1V8: C763.1 C820.1 C834.1 FL96.1 U59.AG8(VDDA_1P8_UFS)
VDA_USB_0V8: C746.1 C755.1 C825.1 FL86.1 U59.AG17(VDDA_0P8_USB)
VDA_USB_1V8: C726.1 C774.1 C822.1 FL67.1 U59.AH19(VDDA_1P8_USB)
VDA_USB_3V3: C779.1 C836.1 R923.2 TP287.1(TP) U59.AF17(VDDA_3P3_USB)
VDA_USB_3V3_N: R887.2 R923.1 TP261.1(TP)
VDA_USB_3V3_P: R888.2 R923.4 TP262.1(TP)
VDA_USB_3V3_REG: C718.1 R924.2 U201.1(OUT)
VDA_USB_3V3_SEL: R923.3 R924.1 R930.1
VEXP_3V3: C150.2 C172.1 C173.1 C174.1 R181.1 R181.3 R187.1 R245.2
VEXT_1V8_RAIL_MON3: R1097.1 TP318.1(TP)
VEXT_1V8_RAIL_MON4: R1050.1 TP312.1(TP)
VEXT_3V3_RAIL_MON5: R1046.1 TP313.1(TP)
VLDO_CSI_1V8: R1241.1 U265.5(OUT2)
VLDO_CSI_3V3: R1240.1 U265.6(OUT1)
VMAIN: C80.1 C602.1 C603.1 C607.1 C666.1 R4.1 R780.1 R846.1 R847.1 R850.1 TP20.1(TP) U21.5(D1) U28.4(D) U182.2(VIN)
VMAIN_CONN: D29.1(CATHODE) F1.1 J3.2 J7.1 J7.2
VMAIN_FUSE: C53.2 F1.2 U16.1(EN) U16.5(SOURCE) U21.1(S1) U21.2(S2) U21.3(S3)
VPLL_1V8_EDP: C139.2 FL7.2 U187.42(VPLL)
VPP_CORE_1V8: C899.1 R1016.1 TP122.1(TP) U59.V29(VPP_CORE)
VPP_EFUSE_1V8: C276.1 R1016.2 R1090.1 U67.1(OUT)
VPP_MCU_1V8: C1014.1 R1090.2 TP155.1(TP) U59.F26(VPP_MCU)
VREF2_CSI: C339.1 R522.2 U88.7(VREF2) U88.8(EN)
VREF2_EDP_I2C: C55.2 R71.2 U20.7(VREF2) U20.8(EN)
VRTC_PMIC_1V8: C271.1 TP310.1(TP) U68.3(VOUT_LDOVRTC)
VSENSE: TP163.1(TP) U59.L29(RSVD_L29)
VSYS3V3_MON_CT: C435.1 U131.4(CT)
VSYS3V3_MON_MR#: R631.2 U131.3(M\R\)
VSYS3V3_MON_RESET#: R618.1 U131.1(R\E\S\E\T)
VSYS_3V3: C43.1 C93.1 C143.1 C144.1 C149.1 C372.2 C400.1 C404.1 C408.2 C418.2 C419.1 C420.2 C421.1 C426.2 C451.2 C455.2 C463.2 C464.1 C702.2 C703.2 C1064.1 C1097.1 C1117.1 C1123.1 C1131.2 C1137.1 C1161.1 C1176.1 C1182.2 C1185.2 C1200.1 C1203.2 C1205.1 C1206.2 C1241.1 C1268.1 J50.1 J50.2 J50.3 L37.1 R1.1 R2.1 R60.1 R61.1 R62.1 R63.1 R80.1 R102.1 R116.1 R136.4 R136.6 R137.2 R142.2 R143.2 R144.2 R180.1 R180.3 R184.1 R185.1 R185.3 R430.1 R435.1 R441.1 R444.1 R450.1 R454.1 R460.1 R467.1 R474.1 R481.2 R483.1 R496.1 R502.1 R514.1 R529.1 R536.1 R548.1 R553.1 R585.1 R589.2 R590.1 R591.1 R612.2 R614.2 R623.2 R631.1 R653.2 R661.2 R664.2 R817.2 R826.2 R827.2 R828.2 R834.1 R939.2 R956.2 R1105.1 R1109.2 R1131.2 R1135.2 R1144.2 R1170.2 R1301.2 R1303.2 R1315.2 R1316.2 R1317.2 R1318.2 TP27.1(TP) U10.1(VCCA) U19.16(VCC) U30.5(D) U34.1(VIN) U64.B3(A0) U93.C3(A1) U98.20(VCC) U105.C3(A1) U113.6(C\L\R\) U113.8(VCC) U116.C3(A1) U121.C3(A1) U122.5(VDD) U123.5(SENSE) U123.6(VDD) U125.1(IN1) U125.2(IN2) U125.4(BIAS) U130.5(VCC) U131.5(SENSE) U131.6(VDD) U138.1(IN1) U138.2(IN2) U142.6(VIN) U186.1(IN1) U186.2(IN2) U186.4(BIAS) U188.B3(A0) U188.C3(A1) U192.B3(A0) U207.C3(A1) U211.B3(A0) U221.2(A0) U222.B3(A0) U230.B3(A0) U231.C3(A1) U233.1(VCCA) U243.27(VCCP) U243.31(VCC) U244.1(VCCA) U247.5(VCC) U248.1(VCCA) U251.5(VCC) U253.5(VCC) U255.5(VCC) U260.1(IN1) U260.2(IN2) U266.1(IN1) U266.2(IN2) U266.4(BIAS) U268.16(VCC) U269.14(VCC) U278.5(VCC)
VSYS_3V3_1: C380.1 C395.1 C704.1 C723.1 C796.1 C805.1 C823.1 C1040.1 R1315.1 U105.B1(VS) U106.1(A1) U106.6(VS+) U114.B1(VS) U115.6(VS+) U188.B1(VS) U189.1(A1) U189.2(A0) U189.6(VS+) U203.1(A1) U203.2(A0) U203.6(VS+) U204.B1(VS) U204.B3(A0) U204.C3(A1) U207.B1(VS) U208.1(A1) U208.6(VS+) U214.B1(VS) U215.6(VS+) U218.2(A0) U218.6(VS+) U219.B1(VS) U219.B3(A0) U231.B1(VS) U232.1(A1) U232.6(VS+)
VSYS_3V3_2: C698.1 C706.1 C709.1 C716.1 C882.1 C931.1 C988.1 C1065.1 R1316.1 U184.6(VS+) U185.B1(VS) U192.B1(VS) U193.2(A0) U193.6(VS+) U194.B1(VS) U195.6(VS+) U198.B1(VS) U199.6(VS+) U221.6(VS+) U222.B1(VS) U225.B1(VS) U226.6(VS+) U229.6(VS+) U230.B1(VS) U235.B1(VS) U236.6(VS+)
VSYS_3V3_3: C250.1 C257.1 C269.1 C348.1 C388.1 C390.1 C392.1 C403.1 R1317.1 U56.6(VS+) U57.B1(VS) U60.6(VS+) U61.B1(VS) U64.B1(VS) U65.2(A0) U65.6(VS+) U93.B1(VS) U94.1(A1) U94.6(VS+) U116.B1(VS) U117.1(A1) U117.6(VS+) U118.6(VS+) U119.B1(VS) U120.1(A1) U120.6(VS+) U121.B1(VS) U128.6(VS+) U129.B1(VS)
VSYS_3V3_4: C145.1 C324.1 C366.1 C586.1 C798.1 C800.1 C949.1 C1058.1 R1318.1 U31.B1(VS) U32.6(VS+) U83.6(VS+) U84.B1(VS) U99.B1(VS) U100.6(VS+) U171.B1(VS) U172.6(VS+) U209.6(VS+) U210.B1(VS) U211.B1(VS) U212.2(A0) U212.6(VS+) U223.B1(VS) U224.6(VS+) U238.B1(VS) U239.6(VS+)
VSYS_3V3_IN+: C587.2 R801.1 U171.D3(IN+) U172.10(VIN+)
VSYS_3V3_IN-: C587.1 R800.1 U171.D1(BUS) U171.D2(IN-) U172.8(VBUS) U172.9(VIN-)
VSYS_3V3_N: R136.5 R800.2
VSYS_3V3_P: R136.2 R801.2
VSYS_5V0: C33.2 C42.2 C245.1 C246.1 C409.1 C413.1 C414.1 C467.1 C486.2 C493.2 C496.2 C497.2 C524.1 C543.1 C545.1 C555.2 C556.2 C557.2 C558.2 C577.1 C578.2 C581.2 C582.2 C583.1 C584.2 C719.1 C766.1 C883.1 C1082.1 C1089.1 C1212.1 C1213.1 FL56.1 FL57.1 FL58.1 FL59.1 J56.78 J56.80 J56.82 R357.3 TP108.1(TP) U9.3(IN) U50.17(VCC) U53.2(IN) U58.17(VCC) U148.3(VCC) U151.3(VCC) U152.3(VCC) U160.3(IN) U163.3(IN) U169.1(IN1) U169.2(IN2) U169.4(BIAS) U174.1(IN1) U174.2(IN2) U174.4(BIAS) U201.6(IN) U260.4(BIAS) U265.2(IN) U265.3(EN2)
VSYS_5V0_IN+: C919.2 R1021.1 U223.D3(IN+) U224.10(VIN+)
VSYS_5V0_IN-: C919.1 R1024.1 U223.D1(BUS) U223.D2(IN-) U224.8(VBUS) U224.9(VIN-)
VSYS_5V0_N: R357.4 R1024.2
VSYS_5V0_P: R357.1 R1021.2
VSYS_GPIORET_5V0: C453.1 C454.1 C498.2 TP238.1(TP) U139.2(VOUT) U139.3(FB) U153.3(VCC)
VSYS_GPIORET_IO_3V3: R1092.3 R1103.1 R1128.1 TP156.1(TP)
VSYS_GPIORET_IO_3V3_IN+: C1016.2 R1053.1 U229.10(VIN+) U230.D3(IN+)
VSYS_GPIORET_IO_3V3_IN-: C1016.1 R1048.1 U229.8(VBUS) U229.9(VIN-) U230.D1(BUS) U230.D2(IN-)
VSYS_GPIORET_IO_3V3_N: R1048.2 R1092.4 TP311.1(TP)
VSYS_GPIORET_IO_3V3_P: R1053.2 R1092.1 TP314.1(TP)
VSYS_IO_1V8: C91.2 C147.2 C153.2 C159.1 C600.1 C601.1 C676.2 C770.1 C785.1 C902.2 C1043.1 C1049.1 FL2.1(IN) FL3.1(IN) FL4.1(IN) FL5.1(IN) FL7.1 FL26.1(IN) FL27.1(IN) FL60.2 J56.114 J56.116 J56.118 R112.1 R113.1 R229.1 R352.2 R864.1 R880.2 R883.1 R889.1 R893.1 R960.2 R999.1 TP10.1(TP) U20.2(VREF1) U183.1(STANDBY) U183.4(VDD) U187.53(VCCIO#53) U187.63(VCCIO#63) U213.5(VCC) U220.5(VCC)
VSYS_IO_1V8_IN+: C799.2 R972.1 U209.10(VIN+) U210.D3(IN+)
VSYS_IO_1V8_IN-: C799.1 R971.1 U209.8(VBUS) U209.9(VIN-) U210.D1(BUS) U210.D2(IN-)
VSYS_IO_1V8_N: R352.1 R971.2 TP299.1(TP)
VSYS_IO_1V8_P: R352.4 R972.2 TP300.1(TP)
VSYS_IO_3V3: C12.1 C19.1 C34.1 C35.1 C36.1 C48.1 C64.2 C161.1 C177.1 C184.1 C188.2 C289.1 C300.2 C317.2 C355.1 C369.1 C370.1 C396.1 C397.1 C401.1 C406.1 C422.1 C433.2 C436.1 C441.2 C485.1 C492.1 C507.1 C520.1 C534.1 C535.1 C571.1 C574.1 C575.2 C585.1 C595.2 C596.1 C606.1 C608.1 C655.1 C708.2 C715.1 C717.2 C768.1 C769.1 C772.1 C923.1 C926.1 C1023.1 C1063.1 C1075.2 C1169.1 C1187.1 C1189.1 C1198.1 C1199.1 C1216.2 C1236.2 C1240.1 C1266.1 C1267.1 FL1.1(IN) FL6.1(IN) FL8.1(IN) FL9.1(IN) FL61.2 FL98.1 J56.100 J56.102 J56.104 L19.2 R12.2 R43.2 R45.2 R54.1 R65.1 R71.1 R72.2 R85.2 R86.2 R87.2 R90.1 R96.1 R98.2 R100.1 R101.1 R103.1 R104.1 R105.1 R106.1 R107.1 R108.1 R135.1 R145.2 R146.1 R147.1 R157.2 R158.1 R159.1 R160.2 R162.2 R163.2 R164.2 R182.1 R199.1 R200.1 R215.1 R224.1 R236.1 R250.1 R255.2 R260.2 R271.2 R297.1 R303.1 R327.2 R328.2 R339.2 R356.1 R380.1 R382.3 R394.1 R403.1 R411.1 R443.2 R453.2 R456.2 R463.2 R522.1 R550.2 R561.2 R584.1 R596.2 R598.2 R610.1 R616.2 R624.1 R629.1 R638.2 R649.1 R688.1 R694.2 R699.2 R708.2 R709.2 R764.2 R771.2 R779.1 R781.2 R783.1 R785.1 R787.2 R802.2 R805.1 R808.1 R809.1 R810.1 R815.1 R820.2 R821.2 R823.1 R854.1 R863.1 R871.1 R902.1 R903.1 R912.2 R921.1 R926.1 R944.1 R1017.1 R1025.1 R1056.1 R1077.1 R1078.1 R1095.1 R1104.1 R1143.1 R1147.1 R1156.1 R1161.2 R1195.2 R1208.1 R1217.1 R1218.1 R1221.1 R1235.1 R1242.1 R1245.2 R1249.1 R1261.1 R1267.2 R1280.1 R1281.1 R1288.2 R1289.2 R1291.2 R1292.1 R1305.2 TP227.1(TP) U12.10(VCC) U14.5(VCC) U15.5(VCC) U18.14(VCCP) U18.15(VCCI) U33.5(VCC) U38.5(VCC) U39.5(VCC) U43.21(VCCP) U43.23(VCCI) U72.8(VCC) U73.8(VCC) U76.14(VCCP) U76.15(VCCI) U80.16(VCCB) U92.5(VCC) U107.5(VCC) U108.16(VCC) U110.6(VCCB) U112.16(VCC) U132.14(VCCP) U132.15(VCCI) U143.1(VCCA) U143.3(2DIR) U148.5(VIO) U151.5(VIO) U152.5(VIO) U154.12(VDD2) U154.46(VDD1) U155.5(VCC) U161.5(VCC) U165.5(VCC) U167.5(VCC) U168.5(VCC) U173.27(VCCP) U173.31(VCC) U175.5(VCC) U176.5(VCC) U177.16(VCC) U181.14(VCC) U190.5(VCC) U196.5(VCC) U206.16(VCC) U227.16(VCC) U242.19(VCCB) U254.5(VCC) U256.8(VCC) U262.19(VDDIO#19) U262.30(VDDIO#30) U262.41(VDDIO#41) U264.1(VCCA) U264.3(2DIR) U273.1(VCCA) U273.3(2DIR)
VSYS_IO_3V3_IN+: C896.2 R1015.1 U221.10(VIN+) U222.D3(IN+)
VSYS_IO_3V3_IN-: C896.1 R1013.1 U221.8(VBUS) U221.9(VIN-) U222.D1(BUS) U222.D2(IN-)
VSYS_IO_3V3_N: R382.4 R1013.2 TP305.1(TP)
VSYS_IO_3V3_P: R382.1 R1015.2 TP306.1(TP)
VSYS_MCU_5V0: C468.1 C469.1 C494.2 C495.2 C1209.1 TP237.1(TP) U138.4(BIAS) U142.2(VOUT) U142.3(FB) U149.3(VCC) U150.3(VCC)
VSYS_MCU_5V0_EN: R671.1 U142.4(EN)
VSYS_MCUIO_1V8: C322.1 C325.1 C326.1 C327.1 C346.1 C347.1 C376.1 C1020.1 C1095.1 C1096.1 C1098.1 C1120.1 C1134.1 C1135.1 R429.2 R489.1 R490.1 R491.1 R493.1 R494.1 R495.1 R500.1 R506.1 R507.1 R508.1 R513.1 R516.1 R517.1 R518.1 R519.1 R523.1 R525.2 R527.1 R541.2 R542.1 R734.2 R1124.2 R1125.2 R1126.2 R1130.2 R1133.2 R1141.2 R1162.2 TP147.1(TP) U79.B4(VCC) U86.5(VCC) U97.5(VCC) U103.5(VCC) U228.8(VDD) U245.B4(VCC) U245.D1(VCCQ#D1) U245.E4(VCCQ#E4) U246.B4(VCC) U246.D1(VCCQ#D1) U246.E4(VCCQ#E4) U248.16(VCCB)
VSYS_MCUIO_1V8_IN+: C391.2 R574.1 U120.10(VIN+) U121.D3(IN+)
VSYS_MCUIO_1V8_IN-: C391.1 R575.1 U120.8(VBUS) U120.9(VIN-) U121.D1(BUS) U121.D2(IN-)
VSYS_MCUIO_1V8_N: R429.1 R575.2 TP203.1(TP)
VSYS_MCUIO_1V8_P: R429.4 R574.2 TP202.1(TP)
VSYS_MCUIO_3V3: C204.1 C216.1 C249.1 C304.1 C313.2 C329.1 C365.2 C373.2 C382.1 C394.1 C415.1 C424.1 C437.1 C532.1 C533.1 C980.1 C1056.1 C1079.2 C1080.1 C1086.2 C1118.1 C1122.1 C1124.1 C1174.2 C1177.2 C1186.1 C1188.1 C1197.1 C1232.2 R109.1 R207.1 R232.1 R241.1 R336.1 R353.1 R360.1 R381.1 R387.1 R419.2 R422.2 R445.1 R470.1 R472.1 R478.1 R499.1 R563.1 R569.1 R586.2 R593.2 R630.1 R639.1 R650.1 R671.2 R673.2 R706.2 R707.2 R1029.1 R1034.2 R1038.2 R1043.1 R1058.2 R1072.2 R1118.1 R1129.1 R1136.2 R1149.1 R1150.1 R1151.1 R1158.2 R1178.1 R1179.1 R1215.1 R1216.1 R1220.1 R1225.2 R1234.1 R1246.2 R1250.1 R1260.1 R1286.2 R1287.2 R1290.2 TP213.1(TP) U47.16(VCC) U55.4(V+) U78.8(VCC) U82.4(V+) U101.5(VCC) U102.5(VCC) U104.6(VCCB) U111.5(VCC) U127.5(VCC) U149.5(VIO) U150.5(VIO) U228.5(VDDIO) U233.23(VCCB1) U233.24(VCCB2) U241.1(VCC#1) U241.17(VCC#17) U241.30(VCC#30) U244.16(VCCB) U249.5(VCC) U250.8(VCC) U257.5(VCC) U259.1(VCCA) U259.3(2DIR) U261.19(VDDIO#19) U261.30(VDDIO#30) U261.41(VDDIO#41) U270.1(VCCA) U270.3(2DIR)
VSYS_MCUIO_3V3_IN+: C387.2 R570.1 U116.D3(IN+) U117.10(VIN+)
VSYS_MCUIO_3V3_IN-: C387.1 R571.1 U116.D1(BUS) U116.D2(IN-) U117.8(VBUS) U117.9(VIN-)
VSYS_MCUIO_3V3_N: R571.2 R1058.1 TP199.1(TP)
VSYS_MCUIO_3V3_P: R570.2 R1058.4 TP198.1(TP)
VSYS_SENSE: D30.1(CATHODE) R78.2 U68.51(VSYS_SENSE)
VSYS_VDDSHV0_MCU: R476.1 R1128.2 R1129.2
VSYS_VDDSHV2: C536.1 R202.1 R662.1 R1103.2 R1104.2 U153.5(VIO)
VSYSMON_RESET#: R589.1 U113.7(P\R\E\) U123.1(R\E\S\E\T)
VUSB_FT2232: C1257.1 C1258.1 J48.1(VBUS) LD11.2 TP251.1(TP) U156.1(VCC) U276.1(IN) U276.3(EN)
VUSB_FT4232: C1260.1 C1261.1 J49.1(VBUS) LD12.2 TP248.1(TP) U157.1(VCC) U277.1(IN) U277.3(EN)
WKUP_GPIO0_0: R1065.1 U59.E15(WKUP_GPIO0_0)
WKUP_GPIO0_54: R416.1 U59.F15(MCU_SPI0_CLK)
WKUP_GPIO0_57: R1028.1 R1142.1 U59.B20(WKUP_GPIO0_57)
WKUP_I2C0_SCL: J54.65 R456.1 U72.6(SCL) U73.6(SCL) U78.2(1B)
WKUP_I2C0_SDA: J54.63 R463.1 U72.5(SDA) U73.5(SDA) U78.6(2B)
WKUP_LFOSC_XI: R1137.1 U59.A18(WKUP_GPIO0_67) U127.4(Y)
WKUP_LFOSC_XI_OE: R619.1 R626.1 U127.1(OE)
WKUP_LFOSC_XI_R: R613.1 U127.2(A)
WKUP_OSC0_XI: C279.1 U59.A24(WKUP_OSC0_XI) Y6.3
WKUP_OSC0_XO: C270.1 U59.B25(WKUP_OSC0_XO) Y6.1
WKUP_UART0_RXD: U59.C20(WKUP_UART0_RXD) U270.4(1A1)
WKUP_UART0_TXD: R1257.2 U59.C19(WKUP_UART0_TXD) U270.6(2A1)
XDS110_BUF_SELN: R34.2 SW2.8 U10.22(O\E\) U29.1(1\O\E\) U29.4(2\O\E\) U29.10(3\O\E\) U29.13(4\O\E\)
XDS110_EMU0: R789.1 U47.10(3B2) U170.42(PF0)
XDS110_EMU1: R784.1 U47.13(4B2) U170.43(PF1)
XDS110_PROG_STAZ1: R7.2 U170.4(PD3/AIN12)
XDS110_PROG_STAZ2: R5.1 U170.3(PD2/AIN13)
XDS110_TCK: U47.3(1B2) U170.35(PA2/SSI0CLK)
XDS110_TDI: U170.38(PA5/SSI0XDAT1) U206.6(2B2)
XDS110_TDO: U170.37(PA4/SSI0XDAT0) U206.3(1B2)
XDS110_TMS: U170.36(PA3/SSI0FSS) U206.10(3B2)
XDS110_TRST#: U47.6(2B2) U170.40(PA6)
XDS110_VBUS_DET: R69.2 R70.1 U170.1(PD0/AIN15)
XDS_PM1_SCL: R738.2 U29.8(3B) U170.82(PL1)
XDS_PM1_SDA: R742.2 U29.11(4B) U170.81(PL0)
XDS_PM2_SCL: R140.2 U29.3(1B) U170.49(PG0)
XDS_PM2_SDA: R139.2 U29.6(2B) U170.50(PG1)
XDS_RBIAS: R22.1 U170.59(RBAIS)
XDS_RESET#: R735.1 R736.2 R741.1 U170.70(R\S\T\)
XDS_SHIELD: J1.SH1 J1.SH2 J1.SH3 J1.SH4 J1.SH5 J1.SH6 L1.1
XDS_TA_BM_IOEXP_RSTN: U10.15(B7) U170.71(PM7)
XDS_TA_BOOTMODE_CNTL#: U10.16(B6) U170.72(PM6)
XDS_TA_PORZN: U10.20(B2) U170.77(PM1)
XDS_TA_POWERDOWNZ: U10.21(B1) U170.78(PM0)
XDS_TA_RESETZ: U10.19(B3) U170.76(PM2)
XDS_TA_SOC_INT1Z: U10.18(B4) U170.74(PM4)
XDS_TA_SOC_INT2Z: U10.17(B5) U170.73(PM5)
XDS_USB_D_N: J1.2(D-) U2.2(IO2) U170.93(PL7/USB0DM)
XDS_USB_D_P: J1.3(D+) U2.1(IO1) U170.94(PL6/USB0DP)
XDS_USB_ID: J1.4(ID) R750.2 U2.4(IO3)
XDS_VREF: C50.1 C54.1 R52.2 U13.3(CATHODE) U170.9(VREFA+)
N16818967: D41.1(CATHODE) R831.2 U179.1(GATE)
N16860253: R9.2 R13.1 U3.3(C)
N19376907: C262.1 R395.2 Y5.3
N19376959: C268.1 R402.2 Y5.1
N22857883: R454.2 SW7.13
N22857884: R460.2 SW7.14
N22857885: R467.2 SW7.15
N22857886: R474.2 SW7.16
N22857888: R435.2 SW7.10
N22857889: R441.2 SW7.11
N22857890: R450.2 SW7.12
N23037276: R529.2 SW11.13
N23037278: R536.2 SW11.14
N23037280: R548.2 SW11.15
N23037282: R553.2 SW11.16
N23037308: R483.2 SW11.9
N23037310: R496.2 SW11.10
N23037312: R502.2 SW11.11
N23037314: R514.2 SW11.12
N23190579: R1284.1 U276.5(OUT)
N23191902: LD11.1 R725.1
N23194116: R1285.1 U277.5(OUT)
N23195767: LD12.1 R727.1
N23200398: C552.1 R749.1 U170.96(PB1/USB0VBUS)
N23200403: R750.1 U170.95(PB0/USB0ID)
N23200423: R768.1 R770.2 U170.60(PK7)
N23200491: LD1.2(ANODE) R5.2
N23200507: R756.2 R761.1 U170.63(PK4)
N23200509: R15.2 R19.1 U170.61(PK6)
N23200516: R762.2 R767.1 U170.62(PK5)
N23200616: LD6.2(ANODE) R7.1
N23320850: R99.1 R114.2 U23.2(S0)
N23722671: R811.1 R812.1 R813.1
N23768120: R848.1 R879.1 R882.1
N23955014: LD4.2 R3.2
N24011787: L29.2 R288.1 R308.4 R308.5 R308.6
N24011809: C234.2 R289.1 U46.5(VOUT2)
N24011946: L23.1 R187.2 R244.1
N24012043: C202.1 R245.1 U46.26(VOUT1)
N24016673: C439.1 U138.7(SS)
N24017280: C1220.1 U266.7(SS)
N24020919: TP236.1(TP) U261.13(VDDA1P8#13) U261.48(VDDA1P8#48)
N24026991: R46.1 U9.1(EN)
N24026992: R740.1 U160.1(EN)
N24132464: C238.1 R279.2
N24135121: C194.1 R253.1
N24222943: LD5.1 U179.3(DRAIN)
N24223544: LD5.2 R4.2
N24353848: R1180.2 U253.4(Y)
N24397394: C588.1 U174.7(SS)
N24401396: C572.1 U169.7(SS)
N24575373: J2.2 L39.1(IN1) U163.5(D1)
N24575375: J2.3 L39.4(OUT2) U163.6(D2)
N24594316: R1118.2 U241.8(EN)
N25567208: R639.2 U138.5(EN)
N25567428: R1242.2 U266.5(EN)
N26384207: U251.4(Y) U252.6(C)
N26384397: R563.2 U101.1(A)
N26384556: C405.1 R615.1 R620.2 U122.3(SENSE)
N26385797: R606.2 U113.5(Q)
N26472696: R1171.1 TP196.1(TP)
N26836401: R606.1 R612.1 U130.1(A)
N26873381: R430.2 SW7.9
N26961694: R109.2 SW2.20
N26961704: R108.2 SW2.19
N26961722: R107.2 SW2.18
N26961724: R106.2 SW2.17
N26961726: R105.2 SW2.16
N26961744: R104.2 SW2.15
N26964770: R103.2 SW2.14
N26964936: R102.2 SW2.13
N26964939: R101.2 SW2.12
N26964942: R100.2 SW2.11
N27350045: LD3.2 R2.2
N27350452: LD2.2 R1.2
N27366714: U247.4(Y) U252.3(B)
N27374629: LD7.2 R184.2
N28043247: R763.1 U161.2(B)
N28381888: R772.1 U163.1(EN)
N28389101: R21.2 U7.2(SOURCE)
N30006402: R614.1 R618.2 U255.6(C)
N30969363: U124.1(A) U258.4(Y)
N32640257: TP235.1(TP) U262.13(VDDA1P8#13) U262.48(VDDA1P8#48)
N32706667: C681.1 R858.1 U183.3(OUTPUT)
N32707436: C713.1 R913.2 R914.1 U187.2(EN)
N33033037: R949.1 U206.12(4A)
N33102148: R462.2 U78.3(2C) U78.7(1C)
N33104471: R1243.1 U268.15(O\E\)
N33138535: J10.30 J10.32 J10.34 J10.36 J10.38 J10.40 R12.1
N33174192: R1136.1 R1139.2 U86.1(A)
N33174210: R1140.2 R1141.1 U86.2(B)
N33175937: R446.1 U59.A9(MCU_OSPI1_CSN1)
N33181549: R1187.1 U254.4(Y)
N33187905: R1042.1 U227.15(O\E\)
N33189610: R345.2 U58.35(9B2)
N33190088: TP290.1(TP) U50.16(7B3)
N33442693: R1186.2 SW13.1
N33442697: D42.1(K) R1186.1
N33442815: D43.1(K) R1188.1
N33442839: R1188.2 SW13.2
N34186667: R600.2 U122.1(OUT)
N34514277: C305.1 R473.2
N34514391: R482.2 R488.2 U240.4(G)
N34888044: L21.2 R53.1 R111.1
N34888058: C94.2 R110.1 U25.5(VOUT2)
N34888105: L22.1 R151.1 R165.2
N34888129: C121.1 R150.1 U25.26(VOUT1)
N34899945: R440.1 R444.2
N34899947: D36.1(CATHODE) R440.2
N34900604: R486.2 U87.14(ADDR)
N34900686: R524.2 U89.14(ADDR)
N34917262: C224.1 C231.1 C233.1 R266.2
N34917338: C68.1 C69.1 C70.1 R93.2
N34917376: C349.1 C350.1 C351.1 R544.2
N34917412: C383.1 C384.1 C385.1 R580.2
N34917448: C362.1 C363.1 C364.1 R556.2
N34917484: C241.1 C242.1 C244.1 R323.2
N35193628: R1208.2 U260.5(EN)
N35193714: C1196.1 U260.7(SS)
N35201087: C399.1 U125.7(SS)
N35210314: R133.1 U25.37(RT)
N35214365: R816.1 U25.6(VCCX)
N35215938: C88.1 R117.1
N35218154: C103.1 U25.38(DITH)
N35327993: R1157.2 R1161.1 U249.6(C)
N35328046: R588.2 R593.1 U124.6(C)
N35592192: R154.1 U30.4(G)
N35592194: R78.1 R80.2
N35592423: R154.2 U68.52(OVPGDRV)
N35593340: LD10.1 R433.1
N35595852: C154.2 C155.2 C156.2 C158.2 U35.1(COMP) U36.1(COMP) U37.1(COMP)
N35595856: R907.1 R908.2 U35.10(PG) U36.10(PG) U37.10(PG)
N35596954: C155.1 R186.2
N35600802: C189.2 C198.2 C226.2 U42.1(COMP) U48.1(COMP)
N35600892: R213.1 R220.2 U42.10(PG) U48.10(PG)
N35601446: C189.1 R247.2
N35603723: R417.2 U69.3(D) U70.5(G2) U70.6(D1)
N35603798: C274.2 R406.1 R410.2 U66.2(FB)
N35603915: C192.2 R235.1 R237.2 U41.2(FB)
N35604551: C297.1 U75.6(CT)
N35604832: C255.1 U62.6(CT)
N35605554: C334.2 R505.1 R521.2 U85.2(FB)
N36263992: R863.2 U186.5(EN)
N36264078: C686.1 U186.7(SS)
N36834242: R982.2 U216.1(G) U217.3(D)
N36841285: R1111.2 R1122.2 R1123.2 U234.1(OE)
N37510034: R487.2 R547.1 U87.13(NINQ)
N37510108: R512.2 U89.13(NINQ)
N37512355: R653.1 SW16.8
N37512529: R661.1 SW16.7
N37513072: R664.1 SW16.6
N37514843: R673.1 SW16.5
N37858028: R49.1 U10.2(DIR)
N37858624: C115.2 R1303.1 R1304.1 U29.14(VCC)
N37948258: TP5.1(TP) U170.75(PM3)
N39003104: R249.1 SW4.4
N39003106: R222.1 SW4.3
N39039668: R1295.1 R1297.2 U63.2(FB)
N40063454: R1301.1 R1302.2 U278.2(A)
N40559760: R1309.2 U279.3(IN0)
N41254916: Q3.5(G2) Q3.6(D1) Q4.6(D1) R1310.2
N262945201: LD8.2 R207.2
N262947361: LD9.2 R215.2
