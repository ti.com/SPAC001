# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MIC1L_A: length 5.1
  TOP w0.254: R625.1 35.29,27.16 C434.2 33.46,27.16 32.34,26.04 31.95,26.04 31.69,26.3 U135.1
MIC1L_AC: length 13.1
  TOP w0.381: C432.1 25.67,27.67 27.68,29.68 R617.1
MIC1L_B: length 7.7
  TOP w0.254: U135.2 31.04,26 31.67,25.36 C434.1 33.77,25.36 34.52,26.11 R632.1
  TOP w0.381: R617.2 31.17,28.32 31.04,28.18 U135.2
MIC1L_BIAS: length 3.5
  TOP w0.381: C459.2 21.34,21.76 20.62,21.04 19.94,21.04 R657.2 R656.2
MIC1L_BIAS_AC: length 8.3
  TOP w0.381: C440.1 26.99,24.54 R640.2 26.95,23.96 26.87,23.87 U141.6 26.87,21.91 26,21.04 23.88,21.04 23.14,21.79 C459.1
MIC1L_C: length 7.3
  TOP w0.254: R636.1 35.3,25.07 34.59,24.36 R642.1 33.47,23.94 C452.1 32.85,23.88 32.19,24.54 31.02,24.54 30.39,23.91 U135.6
MIC1L_D: length 5.1
  TOP w0.254: U135.7 31.04,23.68 31.35,23.98 31.99,23.98 33.01,22.96 C452.2 33.57,22.8 R651.1
MIC1L_PRE: length 4.6
  TOP w0.381: U141.7 26.22,23.86 26.11,23.96 R640.1 26.07,24.54 C440.2 25.29,25.64 24.99,25.34 R634.1
MIC1L_PRE_BP: length 3.7
  TOP w0.381: R644.1 18.88,24.68 C432.2 20.02,25.87 R633.2
MIC1L_PREAMP: length 2.1
  TOP w0.381: R633.1 R637.2 R634.2
MIC1R_A: length 7.2
  TOP w0.254: R691.1 35.27,15.35 C506.2 32.41,15.35 32.1,15.66 30.4,15.66 29.74,15.01 U146.1
MIC1R_AC: length 11.2
  TOP w0.381: R700.1 27.26,12.17 25.65,13.77 C503.1
MIC1R_B: length 8.7
  TOP w0.254: R700.2 30.27,12.72 30.39,12.84 U146.2 30.39,14.87 30.65,15.12 31.85,15.12 33.43,13.55 C506.1 34.53,13.55 R692.1
MIC1R_BIAS: length 3.5
  TOP w0.381: C479.2 21.34,19.65 20.6,20.4 19.94,20.4 R666.2 R665.2
MIC1R_BIAS_AC: length 7.9
  TOP w0.381: C499.1 26.33,16.96 R678.2 26.29,17.45 26.22,17.53 U141.2 26.22,20.02 25.84,20.4 23.86,20.4 23.14,19.68 C479.1
MIC1R_C: length 7.5
  TOP w0.254: U146.6 31.04,17.24 31.3,16.98 32.13,16.98 32.92,17.77 C488.1 34.04,17.77 34.21,17.93 R674.1 34.59,18.47 34.97,18.85 R672.1
MIC1R_D: length 5.7
  TOP w0.254: R685.1 34.6,16.85 C488.2 32.84,16.85 32.47,16.48 30.99,16.48 30.39,17.08 U146.7
MIC1R_PRE: length 3.9
  TOP w0.381: R690.1 24.58,15.86 C499.2 25.41,16.96 R678.1 25.45,17.45 25.57,17.57 U141.1
MIC1R_PRE_BP: length 3.7
  TOP w0.381: R675.1 18.88,16.76 C503.2 20.02,15.57 R689.2
MIC1R_PREAMP: length 2.1
  TOP w0.381: R690.2 R686.2 R689.1
MIPI_DETECT: length 2.6
  TOP w0.127: J23.58 R290.2
MIPI_EMU0: length 2.7
  TOP w0.127: J23.38 8.08,92.42 R321.1
MIPI_EMU1: length 2.7
  TOP w0.127: J23.40 8.14,92.92 R314.1
MIPI_NTRSTPU: length 4.9
  TOP w0.127: J23.9 19.12,85.42 19.19,85.35 R360.2 R371.2
MIPI_RTCK: length 6.6
  TOP w0.127: R372.2 21.36,83.64 19.53,83.64 18.24,84.92 J23.7
MIPI_TCK: length 8.4
  TOP w0.127: R372.1 22.77,83.76 22.63,83.62 22.08,83.62 21.93,83.47 R375.2 21.36,82.5 19.27,82.5 17.85,83.92 J23.3
MIPI_TDI: length 4.3
  TOP w0.127: R374.2 19.4,83.07 18.04,84.42 J23.5
MIPI_TDO: length 4.7
  TOP w0.127: R383.1 8.34,81.35 8.81,81.82 8.81,83.63 9.1,83.92 J23.4
MIPI_TGTDET#: length 3.9
  TOP w0.127: R354.1 18.92,86.49 18.49,86.92 16.12,86.92 J23.15
MIPI_TGTRST#: length 4
  TOP w0.127: J23.6 8.76,84.42 8.44,84.11 8.44,83.15 R376.2
MIPI_TMS: length 5.4
  TOP w0.127: R389.1 8.64,80.21 9.11,80.67 9.11,83.14 9.39,83.42 J23.2
MIPI_TRC_CLK[0]: length 6.2
  TOP w0.127: J23.13 16.12,86.42 18.16,86.42 18.66,85.93 21.36,85.93 R355.2
MIPI_TRC_DATA_00: length 6.2
  TOP w0.127: R348.2 21.36,87.07 19.06,87.07 18.71,87.42 16.12,87.42 J23.17
MIPI_TRC_DATA_01: length 3.8
  TOP w0.127: J23.19 16.12,87.92 18.81,87.92 19.1,87.64 R347.2
MIPI_TRC_DATA_02: length 6.1
  TOP w0.127: R341.2 21.36,88.21 19.14,88.21 18.93,88.42 16.12,88.42 J23.21
MIPI_TRC_DATA_03: length 3.8
  TOP w0.127: R340.2 19.18,88.78 19.04,88.92 J23.23
MIPI_TRC_DATA_04: length 6.1
  TOP w0.127: J23.25 19.26,89.42 19.33,89.36 21.36,89.36 R330.2
MIPI_TRC_DATA_05: length 3.7
  TOP w0.127: J23.27 R329.2
MIPI_TRC_DATA_06: length 6.1
  TOP w0.127: R326.2 21.36,90.5 19.32,90.5 19.25,90.42 J23.29
MIPI_TRC_DATA_07: length 3.8
  TOP w0.127: J23.31 19.21,90.92 19.36,91.07 R325.2
MIPI_TRC_DATA_08: length 6.1
  TOP w0.127: R320.2 21.36,91.64 19.23,91.64 19.01,91.42 J23.33
MIPI_TRC_DATA_09: length 3.8
  TOP w0.127: R319.2 19.19,92.21 18.9,91.92 J23.35
MIPI_TRC_DATA_10: length 2.7
  TOP w0.127: J23.18 10.38,87.42 8.49,87.42 8.22,87.15 R350.1
MIPI_TRC_DATA_11: length 2.8
  TOP w0.127: R343.1 8.16,87.92 10.38,87.92 J23.20
MIPI_TRC_DATA_30: length 6.2
  TOP w0.127: R313.2 21.36,92.78 19.12,92.78 18.76,92.42 J23.37
MIPI_TRC_DATA_31: length 3.9
  TOP w0.127: R312.2 19.07,93.35 18.64,92.92 J23.39
MIPI_TRC_DATA_32: length 6.2
  TOP w0.127: J23.41 18.6,93.42 19.1,93.93 21.36,93.93 R306.2
MIPI_TRC_DATA_33: length 3.9
  TOP w0.127: J23.43 18.59,93.92 19.16,94.5 R305.2
MIPI_TRC_DATA_34: length 6.3
  TOP w0.127: R301.2 21.36,95.07 19.03,95.07 18.38,94.42 J23.45
MIPI_TRC_DATA_35: length 4
  TOP w0.127: J23.47 18.2,94.92 18.92,95.64 R300.2
MIPI_TRC_DATA_36: length 6.4
  TOP w0.127: R296.2 21.36,96.21 18.86,96.21 18.07,95.42 J23.49
MIPI_TRC_DATA_37: length 4.1
  TOP w0.127: J23.51 17.94,95.92 18.8,96.78 R295.2
MIPI_TRC_DATA_38: length 6.4
  TOP w0.127: J23.53 17.86,96.42 18.8,97.36 21.36,97.36 R286.2
MIPI_TRC_DATA_39: length 4.1
  TOP w0.127: J23.55 17.53,96.92 18.53,97.92 R285.2
MIPI_TRST_PD: length 3.8
  TOP w0.127: R373.2 R361.1 8.53,84.78 8.68,84.92 J23.8
MIPI_VREF_DEBUG: length 5.5
  TOP w0.305: R387.2 R380.2 19.19,81.92 17.69,83.42 J23.1
MIPI_VREF_TRACE: length 2.6
  TOP w0.305: J23.12 10.38,85.92 R356.2
MMC0_CALPAD: length 36.9
  TOP w0.127: v2(133.12,90.63) 132.72,90.23 U59.AH2
  L10-SIGNAL4 w0.109: v2(133.12,90.63) 133.52,91.04 133.52,94.02 133.76,94.26 136.41,94.26 137.65,95.51 137.65,98.3 142.25,102.9 159.23,102.9 v2(160.45,104.12)
MMC0_CLK: length 65.2
  TOP w0.127: U59.AJ2 132.72,91.03 v2(133.12,91.43)
  L3-SIGNAL1 w0.089: v3(169.07,91.68) v5(169.41,91.68) ; v3(177.44,97.81) v5(177.78,97.81)
  L4-GND2 w0.102: v5(177.78,97.81) v6(178.12,97.81) ; v5(169.41,91.68) v6(169.75,91.68)
  L5-SIGNAL2 w0.102: v6(178.12,97.81) 178.12,96.32 176.18,94.39 174.86,94.39 172.15,91.68 171.23,91.68 171.09,91.82 171.09,92.44 170.95,92.58 170.75,92.58 170.61,92.44 170.61,91.82 170.47,91.68 v6(169.75,91.68) 169.75,90.9 169.3,90.45 162.9,90.45 161.96,91.39 161.96,97.33 159.21,100.08 144.49,100.08 143.06,98.65 140.78,98.65 139.15,97.03 139.15,94.74 137.3,92.89 135.29,92.89 134.2,91.8 133.76,91.8 133.4,91.43 v2(133.12,91.43)
MMC0_CMD: length 66.3
  TOP w0.127: U59.AL2 132.72,92.63 v2(133.12,93.03) ; v2(176.94,97.56) 177.19,97.31 U52.M5
  L5-SIGNAL2 w0.102: v2(176.94,97.56) 176.94,97.56 176.19,97.56 175.91,97.28 173.44,97.28 168.51,92.35 167.42,92.35 167.11,92.66 167.11,93.24 168.35,94.48 168.35,96.25 167.75,96.85 167.75,98.17 168.91,99.33 168.91,100.17 168.51,100.56 165.59,100.56 164.97,101.18 161.11,101.18 160.1,102.18 159.19,102.18 158.71,102.67 142.2,102.67 138.21,98.68 135.8,98.68 135.2,98.08 134.62,98.08 133.92,97.38 133.92,94.64 133.7,94.41 133.22,93.94 133.22,93.7 133.12,93.6 v2(133.12,93.03)
  BOTTOM w0.127: TP291.1 176.15,97.32 176.44,97.61 R961.2 v2(176.94,97.56)
MMC0_DAT0: length 65.4
  TOP w0.102: 171.18,96.04 171.44,96.31 U52.A3
  TOP w0.127: v2(133.92,93.83) 133.52,93.43 U59.AM1 ; 171.18,96.04 170.67,95.54 169.48,95.54 168.36,94.42 TP94.1 v3(166.9,94.42)
  L3-SIGNAL1 w0.089: v3(166.9,94.42) v5(167.23,94.42)
  L4-GND2 w0.102: v5(167.23,94.42) v6(167.56,94.42)
  L5-SIGNAL2 w0.102: v6(167.56,94.42) 167.95,94.81 167.95,96.14 167.42,96.67 167.42,98.37 168.56,99.52 168.56,100 168.31,100.25 167.9,100.25 166.66,99.01 166.66,97.13 166.3,96.77 166.01,96.77 165.87,96.92 165.87,98.49 165.72,98.63 165.52,98.63 165.38,98.49 165.38,96.92 165.24,96.77 165.04,96.77 164.9,96.92 164.9,98.49 164.76,98.63 164.56,98.63 164.42,98.49 164.42,96.92 164.28,96.77 163.84,96.77 163.51,97.1 163.51,97.76 161.67,99.6 161.67,99.8 161.87,99.99 161.87,100.19 161.73,100.33 161.53,100.33 161.33,100.14 161.13,100.14 159.8,101.47 158.81,101.47 158.22,102.06 147.91,102.06 147.3,101.45 141.84,101.45 137.65,97.26 137.65,95.38 136.74,94.46 134.55,94.46 v2(133.92,93.83)
MMC0_DAT1: length 64.4
  TOP w0.102: 170.86,96.72 170.95,96.81 U52.A4
  TOP w0.127: 170.86,96.72 170.77,96.63 169.63,96.63 169.1,97.16 TP83.1 v3(166.9,97.16) ; v2(132.32,92.23) 131.92,91.83 U59.AK3
  L3-SIGNAL1 w0.089: v3(166.9,97.16) v5(168.12,97.16)
  L4-GND2 w0.102: v5(168.12,97.16) v6(168.45,97.16)
  L5-SIGNAL2 w0.102: v2(132.32,92.23) 132.32,92.88 132.55,93.12 132.55,93.6 132.81,93.87 132.81,94.98 133.26,95.43 133.26,97.74 134.23,98.72 134.97,98.72 135.55,99.29 137.95,99.29 141.97,103.3 158.96,103.3 159.42,102.85 160.41,102.85 161.37,101.88 166.75,101.88 166.9,101.74 166.9,101.31 167.04,101.17 167.24,101.17 167.38,101.31 167.38,101.74 167.52,101.88 167.72,101.88 167.86,101.74 167.86,101.31 168,101.17 168.2,101.17 168.34,101.31 168.34,101.74 168.48,101.88 168.68,101.88 168.83,101.74 168.83,101.31 168.97,101.17 169.17,101.17 169.31,101.31 169.31,101.74 169.45,101.88 170.39,101.88 171.08,101.19 171.08,100.48 170.94,100.33 170.61,100.33 170.47,100.19 170.47,99.99 170.61,99.85 170.94,99.85 171.08,99.71 171.08,99.09 170.47,98.48 169.15,98.48 168.45,97.78 v6(168.45,97.16)
MMC0_DAT2: length 64.3
  TOP w0.102: U52.A5 170.98,97.31 170.8,97.49
  TOP w0.127: 170.8,97.49 170.29,98 170.29,98.76 169.15,99.91 TP79.1 v3(166.9,99.91) ; U59.AL1 133.52,92.63 v2(133.92,93.03)
  L3-SIGNAL1 w0.089: v3(166.9,99.91) v5(167.81,99.91)
  L4-GND2 w0.102: v5(167.81,99.91) v6(168.14,99.91)
  L5-SIGNAL2 w0.102: v2(133.92,93.03) 134.91,94.03 137.02,94.03 138.01,95.02 138.01,97.18 141.92,101.09 147.38,101.09 148.04,101.75 158.02,101.75 158.66,101.12 159.67,101.12 163.18,97.61 163.18,96.67 163.56,96.29 165.16,96.29 165.54,95.91 165.54,91.87 165.74,91.67 166.07,91.67 166.18,91.77 166.18,93.85 166.32,93.99 166.67,93.99 166.81,94.14 166.81,94.34 166.67,94.48 166.32,94.48 166.18,94.62 166.18,94.82 166.32,94.96 166.85,94.96 166.99,95.1 166.99,95.3 166.85,95.44 166.27,95.44 166.1,95.61 166.1,95.99 166.28,96.16 166.91,96.16 167.06,96.32 167.06,98.83 v6(168.14,99.91)
MMC0_DAT3: length 64.6
  TOP w0.102: U52.B2 172.19,95.56 171.7,95.56
  TOP w0.127: U59.AK1 133.52,91.83 v2(133.92,92.23) ; 171.7,95.56 TP100.1 v3(166.9,91.68)
  L3-SIGNAL1 w0.089: v3(166.9,91.68) v5(167.23,91.68)
  L4-GND2 w0.102: v5(167.23,91.68) v6(167.56,91.68)
  L5-SIGNAL2 w0.102: v2(133.92,92.23) 134.2,92.23 135.19,93.22 137.17,93.22 138.74,94.79 138.74,97.05 141.29,99.59 143.09,99.59 143.88,100.39 159.34,100.39 162.38,97.35 162.38,91.5 162.59,91.3 162.75,91.3 162.95,91.49 162.95,95.1 163.08,95.23 163.33,95.23 163.43,95.12 163.43,91.06 163.61,90.88 164.14,90.88 164.29,91.02 164.29,91.93 164.43,92.08 164.63,92.08 164.77,91.93 164.77,91.02 164.91,90.88 167.22,90.88 167.56,91.22 v6(167.56,91.68)
MMC0_DAT4: length 64.3
  TOP w0.102: U52.B3 172.19,96.06 171.69,96.06 171.38,95.75
  TOP w0.127: 171.38,95.75 170.76,95.13 170.4,95.13 168.32,93.05 TP97.1 v3(166.9,93.05) ; v2(132.32,91.43) 131.92,91.03 U59.AJ3
  L3-SIGNAL1 w0.089: v3(166.9,93.05) v5(167.23,93.05)
  L4-GND2 w0.102: v5(167.23,93.05) v6(167.56,93.05)
  L5-SIGNAL2 w0.102: v6(167.56,93.05) 168.11,93.05 168.66,93.6 168.66,94.08 168.81,94.23 169.13,94.23 169.27,94.37 169.27,94.57 169.13,94.71 168.81,94.71 168.66,94.85 168.66,95.05 168.81,95.19 169.13,95.19 169.27,95.33 169.27,95.53 169.13,95.67 168.81,95.67 168.66,95.81 168.66,96.39 168.05,97 168.05,97.92 169.25,99.11 169.25,100.31 168.69,100.86 165.74,100.86 165.1,101.51 161.26,101.51 160.26,102.51 159.32,102.51 158.86,102.97 142.07,102.97 138.08,98.98 135.67,98.98 135.09,98.4 134.5,98.4 133.61,97.51 133.61,94.62 133.02,94.02 133.02,93.78 132.75,93.52 132.75,92.16 132.32,91.72 v2(132.32,91.43)
MMC0_DAT5: length 65.1
  TOP w0.102: U52.B4 172.19,96.56 171.2,96.56 171.08,96.43
  TOP w0.127: v2(132.32,90.63) 131.92,90.23 U59.AH3 ; 171.08,96.43 170.69,96.04 168.77,96.04 168.51,95.79 TP87.1 v3(166.9,95.79)
  L3-SIGNAL1 w0.089: v3(166.9,95.79) v5(167.23,95.79)
  L4-GND2 w0.102: v5(167.23,95.79) v6(167.56,95.79)
  L5-SIGNAL2 w0.102: v6(167.56,95.79) 167.56,94.91 167.14,94.49 167.14,93.75 166.78,93.4 166.78,91.57 166.51,91.29 165.57,91.29 165.21,91.64 165.21,95.71 165.02,95.9 164.69,95.9 164.52,95.73 164.52,92.76 164.35,92.58 164.04,92.58 163.76,92.86 163.76,95.3 162.76,96.3 162.76,97.42 159.44,100.74 141.99,100.74 138.39,97.13 138.39,94.95 137.12,93.68 135.14,93.68 134.13,92.67 133.84,92.67 133.55,92.38 133.55,92.12 133.23,91.8 132.97,91.8 132.75,91.58 132.75,91.24 132.32,90.8 v2(132.32,90.63)
MMC0_DAT6: length 64.4
  TOP w0.102: 170.85,97.06 172.19,97.06 U52.B5
  TOP w0.127: 170.85,97.06 170.67,97.06 169.2,98.53 TP80.1 v3(166.9,98.53) ; U59.AJ4 131.12,91.03 v2(131.52,91.43)
  L3-SIGNAL1 w0.089: v5(169.06,98.03) 168.55,98.53 v3(166.9,98.53)
  L4-GND2 w0.102: v5(169.06,98.03) v6(169.39,98.03)
  L5-SIGNAL2 w0.102: v2(131.52,91.43) 131.52,92.37 132.25,93.11 132.25,93.7 132.09,93.87 132.09,94.97 132.95,95.83 132.95,97.87 134.12,99.04 134.86,99.04 135.42,99.59 137.83,99.59 141.84,103.61 147.94,103.61 148.95,104.62 156.19,104.62 157.16,103.66 159.04,103.66 159.55,103.15 160.56,103.15 161.53,102.18 170.85,102.18 171.43,101.6 171.43,98.8 170.66,98.03 v6(169.39,98.03)
MMC0_DAT7: length 64.3
  TOP w0.102: U52.B6 172.19,97.56 171.29,97.56 171.03,97.82
  TOP w0.127: v2(133.12,92.23) 132.72,91.83 U59.AK2 ; 171.03,97.82 170.72,98.13 170.72,100.12 169.57,101.28 TP76.1 R274.2 166.9,100.73 166.81,100.64 165.46,100.64 v2(164.4,99.58)
  L5-SIGNAL2 w0.102: v2(133.12,92.23) 133.12,92.52 133.55,92.96 133.55,93.98 133.8,94.23 134.34,94.77 136.51,94.77 137.27,95.53 137.27,97.31 142.32,102.36 142.54,102.36 142.68,102.22 142.68,101.92 142.83,101.78 143.03,101.78 143.17,101.92 143.17,102.22 143.31,102.36 143.51,102.36 143.65,102.22 143.65,101.92 143.79,101.78 143.99,101.78 144.13,101.92 144.13,102.22 144.27,102.36 144.47,102.36 144.61,102.22 144.61,101.92 144.76,101.78 144.96,101.78 145.1,101.92 145.1,102.22 145.24,102.36 145.44,102.36 145.58,102.22 145.58,101.92 145.72,101.78 145.92,101.78 146.06,101.92 146.06,102.22 146.2,102.36 146.43,102.36 146.57,102.22 146.57,101.92 146.72,101.78 146.91,101.78 147.06,101.92 147.06,102.22 147.2,102.36 158.5,102.36 159.04,101.83 159.88,101.83 160.87,100.84 162.26,100.84 162.4,100.7 162.4,99.68 162.54,99.54 162.74,99.54 162.88,99.68 162.88,100.7 163.03,100.84 163.23,100.84 163.37,100.7 163.37,98.95 163.51,98.81 163.71,98.81 163.85,98.95 163.85,100.7 163.99,100.84 164.78,100.84 165.57,100.05 165.57,99.31 165.29,99.04 164.94,99.04 v2(164.4,99.58)
MMC0_DS: length 56.4
  TOP w0.127: v2(133.92,91.43) 133.52,91.03 U59.AJ1
  L5-SIGNAL2 w0.102: v2(174.81,93.58) 171.26,90.03 162.74,90.03 161.55,91.21 161.55,97.16 158.96,99.75 144.58,99.75 143.19,98.35 140.9,98.35 139.45,96.9 139.45,94.62 137.3,92.46 135.31,92.46 134.29,91.43 v2(133.92,91.43)
  BOTTOM w0.127: R967.1 v2(174.81,93.58)
MMC0_DS_R: length 2.2
  TOP w0.127: v2(175.19,96.81) 175.44,97.06 U52.H5
  BOTTOM w0.127: R967.2 174.81,96.18 174.71,96.28 TP292.1 174.82,96.81 v2(175.19,96.81)
MMC1_CLK: length 119.8
  L3-SIGNAL1 w0.089: v2(26.61,117.16) 31.22,112.54 31.22,111.34 31.33,111.24 32.19,111.24 32.29,111.14 32.29,111 32.19,110.9 31.33,110.9 31.22,110.8 31.22,110.66 31.33,110.56 32.19,110.56 32.29,110.46 32.29,110.32 32.19,110.22 31.33,110.22 31.22,110.12 31.22,109.97 31.33,109.87 32.19,109.87 32.29,109.77 32.29,109.63 32.19,109.53 31.33,109.53 31.22,109.43 31.22,109.29 31.33,109.19 32.19,109.19 32.29,109.09 32.29,108.94 32.19,108.84 31.33,108.84 31.22,108.74 31.22,108.6 31.33,108.5 32.19,108.5 32.29,108.4 32.29,108.26 32.19,108.16 31.33,108.16 31.22,108.06 31.22,107.92 31.33,107.82 32.19,107.82 32.29,107.71 32.29,107.57 32.19,107.47 31.33,107.47 31.22,107.37 31.22,107.23 31.33,107.13 32.19,107.13 32.29,107.03 32.29,106.89 32.19,106.79 31.33,106.79 31.22,106.69 31.22,105.84 43.82,93.24 48.9,93.24 52.84,89.31 57.91,89.31 59.57,87.65 70.64,87.65 73.35,84.94 73.35,84.19 75.65,81.89 78.9,81.89 79.33,81.46 82.25,81.46 83.45,80.26 83.45,79.99 83.85,79.58 84.36,79.58 85.61,78.33 85.61,77.14 87.99,74.76 87.99,72.42 88.74,71.67 92.88,71.67 95.31,69.24 96.83,69.24 98.15,67.92 100.27,67.92 v3(100.78,68.44)
  BOTTOM w0.127: v2(26.61,117.16) U200.5 26.06,116.6 25.59,117.08 23.68,117.08 23.51,116.9 J53.5
MMC1_CLK_R: length 7.4
  TOP w0.127: R368.1 v3(102.57,68.44)
  L3-SIGNAL1 w0.089: v3(102.57,68.44) 102.99,68.44 105.58,71.03 v3(107.92,71.03)
  vias: v1(107.92,71.03)
MMC1_CMD: length 127.5
  L3-SIGNAL1 w0.089: v2(27.64,110.44) 27.64,107.79 27.83,107.6 27.83,107.27 27.64,107.08 27.64,101.55 30.54,98.65 30.95,98.65 33.64,95.96 33.64,95 37.25,91.38 38.2,91.38 38.3,91.28 38.3,90.65 38.4,90.55 38.54,90.55 38.64,90.65 38.64,91.28 38.74,91.38 38.88,91.38 38.98,91.28 38.98,90.65 39.08,90.55 39.22,90.55 39.32,90.65 39.32,91.28 39.43,91.38 39.57,91.38 39.67,91.28 39.67,90.65 39.77,90.55 39.91,90.55 40.01,90.65 40.01,91.28 40.11,91.38 40.25,91.38 40.35,91.28 40.35,90.65 40.45,90.55 40.6,90.55 40.7,90.65 40.7,91.28 40.8,91.38 47.57,91.38 52.37,86.58 70.13,86.58 72.28,84.43 72.28,83.71 77.66,78.33 77.66,77.5 78.36,76.8 81.19,76.8 86.61,71.37 92.31,71.37 95.28,68.4 95.28,68.08 95.91,67.45 102.41,67.45 105.65,70.69 108,70.69 108.72,71.41 v3(108.72,71.83)
  L5-SIGNAL2 w0.102: v2(27.64,110.44) 29.38,112.18 v2(29.38,115.6)
  BOTTOM w0.127: v2(29.38,115.6) U200.3 28.09,115.11 27.42,114.43 23.58,114.43 23.31,114.7 J53.3
  vias: v1(108.72,71.83)
MMC1_DAT0: length 127.5
  L3-SIGNAL1 w0.089: v2(27.22,118.22) 26.61,118.22 25.43,117.04 25.43,115.29 26.6,114.12 26.6,113.54 28.2,111.94 28.2,103.13 29.24,102.09 29.24,101.32 30.26,100.31 30.77,100.31 39.35,91.72 48.62,91.72 52.81,87.53 54.26,87.53 54.95,86.85 70.31,86.85 72.55,84.61 72.55,83.83 77.96,78.41 77.96,77.57 78.42,77.11 81.69,77.11 82.41,76.4 85.33,76.4 v5(85.99,75.74) ; v3(111.92,72.63) v5(111.69,72.35)
  L4-GND2 w0.102: v5(111.69,72.35) v6(111.38,72.05) ; v6(86.23,75.52) 86.22,75.51 v5(85.99,75.74)
  L5-SIGNAL2 w0.102: v6(111.38,72.05) 110.28,70.94 102.07,70.94 101.97,70.84 101.97,70.13 101.87,70.03 101.72,70.03 101.61,70.13 101.61,70.84 101.51,70.94 101.36,70.94 101.26,70.84 101.26,70.13 101.16,70.03 101.01,70.03 100.9,70.13 100.9,70.84 100.8,70.94 100.65,70.94 100.55,70.84 100.55,70.13 100.44,70.03 100.3,70.03 100.19,70.13 100.19,70.84 100.09,70.94 97.72,70.94 96.1,72.57 96.1,73.3 95.44,73.96 87.32,73.96 86.23,75.05 v6(86.23,75.52)
  BOTTOM w0.127: v2(27.22,118.22) 24.93,118.22 24.73,118.42 U197.3 23.95,118.91 23.76,119.1 J53.7
  vias: v1(111.92,72.63)
MMC1_DAT1: length 127
  L3-SIGNAL1 w0.089: v3(111.12,72.63) v5(110.89,72.35) ; v2(27.22,120.39) 30.55,120.39 30.92,120.02 30.92,118.46 30.57,118.11 28.13,118.11 27.6,117.58 26.44,117.58 26.12,117.27 26.12,116.21 26.91,115.42 26.91,113.61 30.01,110.52 30.01,105.87 31.33,104.55 31.33,103.84 43.01,92.15 48.6,92.15 52.89,87.86 54.62,87.86 55.36,87.11 70.42,87.11 72.81,84.72 72.81,83.96 75.57,81.2 77.17,81.2 78.06,80.32 78.06,80.09 78.49,79.65 79.99,79.65 80.98,78.66 v5(83.24,78.66)
  L4-GND2 w0.102: v6(83.48,78.44) 83.48,78.43 v5(83.24,78.66) ; v5(110.89,72.35) v6(110.58,72.05)
  L5-SIGNAL2 w0.102: v6(83.48,78.44) 83.73,78.2 83.73,77.47 85.12,76.07 86.22,76.07 87.18,75.11 90.71,75.11 90.99,74.83 91.09,74.73 95.36,74.73 96.43,73.66 96.43,73.05 97.85,71.64 99.66,71.64 99.98,71.96 109.45,71.96 109.66,71.75 110.28,71.75 v6(110.58,72.05)
  BOTTOM w0.127: J53.8 23.45,120.2 23.86,119.79 25.6,119.79 25.73,119.92 U197.5 v2(27.22,120.39)
  vias: v1(111.12,72.63)
MMC1_DAT2: length 127.4
  L3-SIGNAL1 w0.089: v2(27.6,111.91) 27,111.31 27,101.01 26.88,100.89 26.88,99.62 40.92,85.58 48,85.58 48.1,85.68 48.1,87.07 48.2,87.17 48.35,87.17 48.45,87.07 48.45,85.68 48.55,85.58 48.69,85.58 48.79,85.68 48.79,87.07 48.89,87.17 49.03,87.17 49.13,87.07 49.13,85.68 49.23,85.58 49.38,85.58 49.48,85.68 49.48,87.07 49.58,87.17 49.72,87.17 49.82,87.07 49.82,85.68 49.92,85.58 59.92,85.58 60.19,85.85 66.07,85.85 66.31,85.6 70.69,85.6 71.92,84.38 71.92,83.7 77.35,78.26 77.35,77.43 78.44,76.34 80.84,76.34 83.19,73.99 83.19,73.33 86.72,69.8 91.59,69.8 93.1,68.29 93.1,68.11 94.02,67.18 102.52,67.18 105.57,70.23 107.91,70.23 109.51,71.83 v3(110.32,71.83)
  BOTTOM w0.127: v2(27.6,111.91) U202.3 25.74,111.91 25.16,112.5 J53.1
  vias: v1(110.32,71.83)
MMC1_DAT3: length 128
  L3-SIGNAL1 w0.089: v2(27.6,113.53) 27.96,113.18 28.71,113.18 30.67,111.22 30.67,106 32.44,104.24 32.44,104.1 32.04,103.7 32.04,103.56 32.14,103.46 32.28,103.46 32.68,103.85 32.82,103.85 32.92,103.75 32.92,103.61 32.52,103.21 32.52,103.07 32.62,102.97 32.77,102.97 33.16,103.37 33.31,103.37 33.41,103.27 33.41,103.13 33.01,102.73 33.01,102.59 33.11,102.49 33.25,102.49 33.65,102.89 33.79,102.89 33.89,102.78 33.89,102.64 33.49,102.24 33.49,102.1 33.59,102 33.74,102 34.13,102.4 34.28,102.4 34.38,102.3 34.38,102.16 33.98,101.76 33.98,101.62 34.08,101.52 34.22,101.52 34.62,101.92 34.76,101.92 34.86,101.81 34.86,101.67 34.46,101.27 34.46,101.13 34.56,101.03 34.71,101.03 35.1,101.43 35.25,101.43 35.35,101.33 35.35,101.19 34.95,100.79 34.95,100.65 35.05,100.55 35.19,100.55 35.59,100.95 35.73,100.95 35.83,100.84 35.83,100.7 35.43,100.3 35.43,100.16 35.53,100.06 35.67,100.06 36.07,100.46 36.22,100.46 36.32,100.36 36.32,100.22 35.92,99.82 35.92,99.68 36.02,99.58 36.16,99.58 36.56,99.98 36.7,99.98 36.8,99.88 36.8,99.73 36.4,99.33 36.4,99.19 36.5,99.09 36.64,99.09 37.04,99.49 37.19,99.49 38.02,98.66 38.02,98.52 37.76,98.26 37.76,98.12 37.86,98.02 38,98.02 38.26,98.28 38.4,98.28 38.5,98.18 38.5,98.03 38.24,97.77 38.24,97.63 38.34,97.53 38.48,97.53 38.74,97.79 38.89,97.79 38.99,97.69 38.99,97.55 38.73,97.29 38.73,97.15 38.83,97.05 38.97,97.05 39.23,97.31 39.37,97.31 39.47,97.21 39.47,97.06 39.21,96.8 39.21,96.66 39.31,96.56 39.45,96.56 39.71,96.82 39.86,96.82 39.96,96.72 39.96,96.58 39.7,96.32 39.7,96.18 39.8,96.08 39.94,96.08 40.2,96.34 40.34,96.34 43.97,92.71 48.65,92.71 53.09,88.27 58.5,88.27 59.39,87.38 70.53,87.38 73.08,84.83 73.08,84.08 73.24,83.92 75.67,81.48 77.83,81.48 78.47,80.85 79.23,80.85 80.98,79.1 v5(84.03,79.1) ; v3(110.32,72.63) v5(110.09,72.35)
  L4-GND2 w0.102: v5(110.09,72.35) v6(109.78,72.05) ; v5(84.03,79.1) 84.26,78.86 v6(84.27,78.87)
  L5-SIGNAL2 w0.102: v6(109.78,72.05) 109.44,72.39 99.78,72.39 99.4,72.77 97.9,72.77 95.64,75.03 91.3,75.03 90.91,75.41 87.36,75.41 86.29,76.48 85.3,76.48 84.62,77.17 84.62,78.53 v6(84.27,78.87)
  BOTTOM w0.127: J53.2 23.38,113.6 24.06,112.91 U202.5 24.83,113.35 25.02,113.53 v2(27.6,113.53)
  vias: v1(110.32,72.63)
MMCO_VCTRL_TP: length 41.6
  TOP w0.127: U59.AH4 131.11,90.24 v2(130.72,90.63)
  L10-SIGNAL4 w0.109: v2(162.9,102.83) 162.67,102.6 142.28,102.6 137.88,98.21 137.88,95.41 136.4,93.93 134.76,93.93 134.33,93.5 134.33,90.46 134.09,90.22 131.13,90.22 v2(130.72,90.63)
MON1_ER_VSYS: length 21.2
  TOP w0.127: U59.G26 113.51,73.43 v2(113.12,73.03)
  L5-SIGNAL2 w0.102: v2(104.17,67.41) 104.17,68.91 105.46,70.2 108.93,70.2 109.69,69.44 111.36,69.44 112.66,70.74 112.66,72.57 v2(113.12,73.03)
  BOTTOM w0.127: v2(104.17,67.41) 101.95,65.18 R1105.2 R1100.1
MON3_IR_VEXT1V8: length 18.5
  TOP w0.127: v2(109.92,75.43) 110.31,75.83 U59.K30
  L10-SIGNAL4 w0.305: v2(109.92,75.43) 108.97,75.43 107.35,73.81 101.99,73.81 97.6,69.42 97.6,67.34 v2(96.89,66.63)
MON4_IR_VEXT1V8: length 18.1
  TOP w0.127: U59.M26 113.51,77.43 v2(113.12,77.03)
  L10-SIGNAL4 w0.152: 111.95,76.61 111.97,76.63 112.72,76.63 v2(113.12,77.03)
  L10-SIGNAL4 w0.254: 111.95,76.61 111.84,76.5 108.97,76.5 107.81,75.34 102,75.34 100.36,73.69 v2(99.61,73.69)
  BOTTOM w0.127: C970.1 110.99,76.63 112.71,76.63 v2(113.12,77.03)
MON5_IR_VEXT1V8: length 12.9
  TOP w0.127: U59.M29 111.11,77.43 v2(110.72,77.03)
  L12-SIGNAL5 w0.254: v2(99.58,74.75) 99.91,74.42 101.14,74.42 101.67,74.94 107.94,74.94 109.57,76.56 110.25,76.56 v2(110.72,77.03)
MUX_USB0_DATA_N: length 2
  TOP w0.114: R56.1 138.18,166.8 138.18,167.54 138.06,167.66 U12.7
MUX_USB0_DATA_P: length 2
  TOP w0.114: R57.1 138.44,166.8 138.44,167.54 138.56,167.66 U12.8
ONAND_RST#: length 57.4
  TOP w0.127: v2(69.33,49.49) 69.33,49.48 U86.4 ; U245.A4 v2(118.85,35.4)
  L3-SIGNAL1 w0.089: v2(69.33,49.49) 69.84,48.97 74.46,48.97 78.35,45.08 93.69,45.08 99.2,39.57 109.66,39.57 114.49,34.75 118.2,34.75 v2(118.85,35.4)
OSC0: length 5.7
  BOTTOM w0.127: U170.88 20.06,179.27 C554.2 19.68,179.73 20.02,180.07 20.02,182 19.16,182.87 Y9.1
OSC0_REFCLK: length 160.7
  L3-SIGNAL1 w0.089: v3(115.34,60.7) 112.4,57.76 107.53,57.76 106.71,58.57 81.25,58.57 74.18,65.64 74.18,68.22 v2(71.31,71.1) ; v3(98.62,151.16) v5(98.97,151.16)
  L4-GND2 w0.102: v5(98.97,151.16) v7(99.37,151.16)
  L7-SIGNAL3 w0.109: v2(71.31,71.1) 74.33,74.12 74.33,75.16 73.95,75.54 72.58,75.54 69.64,78.47 69.64,85.92 66.05,89.52 66.05,89.58 66,89.63 66,97.79 68.14,99.93 68.14,119.11 68.43,119.4 68.43,134.34 77.05,142.95 91.16,142.95 v7(99.37,151.16)
OSC1: length 3.6
  BOTTOM w0.127: U170.89 20.46,179.32 C553.2 20.8,180.85 Y9.3
OSC1_XI: length 8.9
  L3-SIGNAL1 w0.089: v3(115.92,69.43) 115.91,69.43 115.91,62.38 116.24,62.05 v3(116.24,60.72)
  vias: v1(115.92,69.43)
OSC1_XO: length 7.9
  TOP w0.127: v3(116.85,61.49) R402.1
  L3-SIGNAL1 w0.089: v3(116.72,68.63) 116.72,61.62 v3(116.85,61.49)
  vias: v1(116.72,68.63)
OSPI0_INT#/ECC_FAIL: length 65.3
  TOP w0.127: U246.A5 v2(125.6,35.4)
  L3-SIGNAL1 w0.089: v3(125.52,71.83) v5(125.79,71.6) ; v2(125.6,35.4) 126.14,35.94 140.95,35.94 145.78,40.77 145.78,47.47 141.44,51.81 141.44,52.9 139.58,54.76 134.88,54.76 v2(129.35,60.3)
  L4-GND2 w0.102: v5(125.79,71.6) v7(126.1,71.3)
  L7-SIGNAL3 w0.109: v7(126.1,71.3) 126.1,63.55 v2(129.35,60.3)
  vias: v1(125.52,71.83)
OSPI/ONAND_MUX_SEL: length 302.1
  TOP w0.127: U241.9 v3(124.29,48.51) 123.92,48.51 123.79,48.38 U241.10 ; SW2.1 v2(154.16,170.25)
  L3-SIGNAL1 w0.089: v2(64.22,55.04) 70.98,55.04 73.31,52.71 99.88,52.71 107.07,45.52 111.06,45.52 117.36,51.82 121.75,51.82 123.05,50.52 123.05,49.75 v3(124.29,48.51) 124.29,49.94 124.11,50.11 124.11,50.47 123.76,50.83 123.15,50.83 122.51,51.46 122.51,68.4 122.62,68.51 122.62,68.81 122.32,69.11 v3(122.32,69.43)
  L7-SIGNAL3 w0.109: v2(154.16,170.25) 154.16,169.33 152.93,168.09 133.26,168.09 132.34,169.01 103.54,169.01 102.58,169.98 84.36,169.98 56.89,142.5 56.89,133.15 52.14,128.4 52.14,120.63 50.66,119.16 50.66,116.79 49.84,115.97 49.84,114.78 49.79,114.73 49.79,114.11 50.78,113.12 50.78,112.46 52.44,110.8 52.44,95.99 64.22,84.21 v2(64.22,55.04)
  vias: v1(122.32,69.43)
OSPI_DQS_R: length 0.7
  TOP w0.127: U246.C3 v2(128.6,37.4)
OSPI_RST#: length 64.7
  TOP w0.127: v2(69.99,43.49) 70.1,43.61 U97.4 ; U246.A4 v2(126.6,35.4)
  L7-SIGNAL3 w0.109: v2(69.99,43.49) 70.64,44.15 74.68,44.15 76.79,46.25 83.68,46.25 85.02,44.91 92.06,44.91 100.82,36.14 116.75,36.14 118.3,34.6 125.79,34.6 v2(126.6,35.4)
PB_CAN_WAKEN: length 149.9
  TOP w0.127: v2(236.09,27.97) SW15.3
  L3-SIGNAL1 w0.089: v2(114.23,5.71) 119.32,10.79 125.61,10.79 126.45,11.63 126.45,15.75 v2(127.34,16.64) 128.79,15.19 152.41,15.19 153.17,15.95 153.17,18.06 154.07,18.96 173.96,18.96 175.36,20.35 183.76,20.35 186.27,22.86 204.43,22.86 205.52,23.95 205.52,26.19 208.09,28.75 210.4,28.75 211.54,29.9 234.17,29.9 v2(236.09,27.97)
  BOTTOM w0.127: R1302.1 127.34,21.54 v2(127.34,16.64)
PB_EXTINTN: length 175.8
  TOP w0.127: v2(220.83,46.27) 221.48,45.62 U98.15 ; U92.1 67.98,50.94 v2(67.98,49.84)
  L3-SIGNAL1 w0.089: v2(220.83,46.27) 209.25,46.27 206.29,49.24 198.62,49.24 197.34,47.96 197.34,45.06 195.45,43.17 185.85,43.17 184.86,44.16 174.73,44.16 169.41,38.83 168.78,38.83 164.73,34.78 162.05,34.78 160.88,33.61 114.41,33.61 109.16,38.86 98.87,38.86 93.63,44.11 87.64,44.11 86.31,42.78 83.8,42.78 82.97,41.95 78.35,41.95 72.75,47.55 69.45,47.55 68.51,48.49 68.51,49.31 v2(67.98,49.84)
PB_MCU_PORZ: length 64.7
  TOP w0.127: U98.19 v2(221.84,43.02)
  L3-SIGNAL1 w0.089: v2(221.84,43.02) 221.65,42.83 207.86,42.83 207.19,42.16 205.67,40.64 204.78,40.64 203.05,38.91 203.05,38.02 194.93,29.9 182.25,29.9 181.72,29.37 170.7,29.37 v2(169.96,28.63)
  BOTTOM w0.127: v2(169.96,28.63) 169.84,28.52 U258.6
PB_MCU_RESETZ: length 154.6
  TOP w0.127: U98.18 221.22,43.67 v2(220.84,43.29)
  L3-SIGNAL1 w0.089: v2(220.84,43.29) 221.2,43.65 221.96,43.65 222.46,44.16 222.46,46.26 222.02,46.7 221.67,46.7 221.34,46.37 221.34,46.18 220.79,45.63 209.59,45.63 206.2,49.02 199.07,49.02 197.72,47.68 197.72,45.14 197.56,44.97 195.54,42.95 185.63,42.95 185.1,43.49 174.37,43.49 169.5,38.62 168.87,38.62 164.77,34.52 162.21,34.52 161.1,33.4 114.23,33.4 109.81,37.82 99.61,37.82 94.7,42.73 v2(88.84,42.73)
PB_PORZ: length 228.9
  TOP w0.127: U98.17 v2(221.84,44.32)
  L3-SIGNAL1 w0.089: v2(18.41,47.31) 18.41,46.31 20.86,43.87 22.41,43.87 23.96,45.42 31.7,45.42 32.4,44.71 43.05,44.71 45.15,42.61 46.68,42.61 48.06,41.23 54.07,41.23 56.43,38.86 77.63,38.86 78.62,37.87 80.5,37.87 81.49,38.86 91.63,38.86 95.79,34.7 108.01,34.7 113.85,28.85 129.8,28.85 129.84,28.9 130.38,28.9 130.95,29.46 155.05,29.46 156.07,30.48 162.42,30.48 162.74,30.16 164.76,30.16 166.19,28.73 169.05,28.73 169.26,28.94 169.26,29.63 168.74,30.15 168.74,32.58 177.9,41.75 189.28,41.75 189.75,41.27 196.45,41.27 196.92,41.75 198.95,41.75 199.22,41.48 199.22,41.12 199.67,40.67 201.58,40.67 205.88,44.96 221.21,44.96 v2(221.84,44.32)
  BOTTOM w0.127: U247.2 v2(18.41,47.31)
PB_RESETZ: length 220.5
  TOP w0.127: U98.16 221.48,44.97 v2(220.83,44.32)
  L3-SIGNAL1 w0.089: v2(220.83,44.32) 205.59,44.32 201.71,40.44 199.37,40.44 198.97,40.84 196.63,40.84 196.42,41.06 189.74,41.06 189.25,40.56 178.14,40.56 169.65,32.08 169.65,28.96 169.21,28.51 166.1,28.51 164.66,29.95 162.65,29.95 162.4,30.2 156.47,30.2 155.41,29.13 136.63,29.13 135.49,27.99 128.53,27.99 128.04,28.47 125.33,28.47 124.37,27.51 111.18,27.51 109.9,28.79 109.9,29.93 105.47,34.37 93.92,34.37 93.1,35.19 88.35,35.19 86.26,37.28 76.6,37.28 75.44,38.43 63.71,38.43 62.36,37.08 51.5,37.08 48.87,39.72 46.25,39.72 44.95,38.42 29.73,38.42 28.69,39.47 28.69,42.51 v2(26.71,44.49)
  BOTTOM w0.127: U249.1 v2(26.71,44.49)
PB_SYS_IRQZ: length 182.5
  TOP w0.127: U98.14 v2(221.84,46.27) ; U123.3 v2(222.76,35.25)
  L3-SIGNAL1 w0.089: v2(64.97,41.05) 66.18,42.25 75.4,42.25 75.92,41.73 76.58,41.07 79.84,41.07 80.44,40.48 81.89,40.48 82.33,40.92 89.9,40.92 90.31,40.51 94.99,40.51 95,40.5 99.61,35.89 111.35,35.89 114.09,33.15 161.2,33.15 162.24,34.19 164.75,34.19 168.96,38.4 169.59,38.4 173.35,42.16 198.97,42.16 199.5,41.63 202.09,41.63 205.72,45.26 220.84,45.26 v2(221.84,46.27)
  L14-SIGNAL6 w0.089: v2(221.84,46.27) 222.76,45.36 v2(222.76,35.25)
PCIE0_4L_EP_RST_EN: length 60.7
  TOP w0.127: U43.8 42.37,114.16 41.92,114.61 v2(41.82,114.61) ; U14.2 33.58,165.17 33.84,164.92 v2(35.65,164.92) R54.2
  L7-SIGNAL3 w0.109: v2(35.65,164.92) 37.93,162.64 37.93,158.16 37.04,157.27 37.04,153.97 36.03,152.96 36.03,138.03 37.01,137.05 37.01,133.71 38.01,132.71 38.01,128.18 40.94,125.24 40.94,121 41.96,119.97 41.96,114.76 v2(41.82,114.61)
PCIE0_4L_MODE_SEL: length 239.9
  TOP w0.127: U43.5 v2(44.88,116.25) ; U15.1 31.13,166.01 v2(32.11,166.01) U14.1 ; SW2.5 R37.2 149.59,170.25 149.71,170.38 149.71,171.66 150.72,172.67 v2(150.72,174.35)
  L3-SIGNAL1 w0.089: v2(150.72,174.35) 150.72,173.49 150.38,173.15 141.39,173.15 139.09,170.85 130.12,170.85 126.99,173.98 124.9,173.98 123.72,175.16 110.51,175.16 109.52,174.17 103.03,174.17 102.8,174.39 86.79,174.39 73.71,161.3 57.06,161.3 52.35,166.01 v2(32.11,166.01)
  L12-SIGNAL5 w0.102: v2(32.11,166.01) 30.67,167.45 30.67,169.52 30.31,169.87 28.7,169.87 27.16,168.34 25.06,168.34 24.4,168.99 13,168.99 11.29,167.28 11.29,133.16 19.46,124.99 22.97,124.99 26.05,121.91 37.76,121.91 43.43,116.25 v2(44.88,116.25)
PCIE0_4L_PERSTZ: length 112.5
  TOP w0.127: v2(44.88,117.16) 44.38,116.66 U43.6 ; v2(30.25,169.24) 29.97,168.96 29.97,168.15 29.73,167.91 U15.4
  L12-SIGNAL5 w0.102: J14.A11 30.25,157.2 v2(30.25,169.24) 29.84,169.65 28.81,169.65 27.26,168.1 24.85,168.1 24.18,168.77 13.22,168.77 11.52,167.06 11.52,133.28 19.47,125.32 24.09,125.32 27.28,122.14 37.91,122.14 42.88,117.16 v2(44.88,117.16)
  BOTTOM w0.127: U176.2 v2(30.25,169.24)
PCIE0_4L_PRSNT#: length 48.5
  TOP w0.127: U43.11 v2(42.79,112.66)
  L7-SIGNAL3 w0.109: v2(42.79,112.66) 42.35,113.09 42.35,119.92 41.36,120.92 41.36,125.32 39.98,126.7 39.98,132.77 39,133.75 39,137.23 38.09,138.14 38.09,140.1 40.57,142.58 42.66,142.58 v2(50.26,150.18)
  BOTTOM w0.127: R818.2 50.58,149.87 v2(50.26,150.18)
PCIE0_4L_RC_RSTZ: length 101.9
  TOP w0.127: U43.7 v2(42.79,114.66)
  L12-SIGNAL5 w0.102: v2(32.23,170.92) 29.43,170.92 27.07,168.56 25.23,168.56 24.57,169.21 12.91,169.21 10.98,167.29 10.98,166.1 10.22,165.33 10.22,159.44 11.07,158.59 11.07,133.03 19.39,124.72 22.73,124.72 25.76,121.69 35.62,121.69 40.88,116.43 40.88,115.54 41.39,115.04 42.41,115.04 v2(42.79,114.66)
  BOTTOM w0.127: v2(32.23,170.92) 32.93,170.22 R782.1 U175.1
PCIE0_4L_SCL: length 8.2
  TOP w0.127: R147.2 23,148.66 v2(22.77,148.89)
  L14-SIGNAL6 w0.089: J14.B5 24.02,150.14 v2(22.77,148.89)
  BOTTOM w0.127: U181.6 22.5,148.62 v2(22.77,148.89)
PCIE0_4L_SDA: length 9.6
  TOP w0.127: R146.2 v2(21.85,148.89)
  L14-SIGNAL6 w0.089: J14.B6 25.02,149 24.04,148.01 22.28,148.01 21.85,148.44 v2(21.85,148.89)
  BOTTOM w0.127: U181.5 v2(21.85,148.89)
PCIE0_AND_OUT: length 4.6
  TOP w0.127: U15.2 v2(32.11,166.96)
  BOTTOM w0.127: U175.4 33.95,165.61 33.77,165.79 33.77,166.4 33.21,166.96 v2(32.11,166.96)
PCIE0_CLKREQ#: length 2.1
  BOTTOM w0.127: R823.2 J14.B12
PCIE0_INT#: length 18.6
  TOP w0.127: R145.1 20.71,148.66 v2(20.94,148.89)
  L14-SIGNAL6 w0.089: v2(20.94,148.89) 20.68,149.14 20.68,150.86 19.95,151.59 19.95,152.94 20.94,153.93 20.94,154.8 21.6,155.46 29.04,155.46 J14.B11
  BOTTOM w0.127: v2(20.94,148.89) 21.2,148.62 U181.4
PCIE0_NAND_OUT: length 8.8
  TOP w0.127: v2(29.3,169.24) 30.52,170.47 34.11,170.47 34.36,170.22 34.36,169.22 34.23,169.09 U14.4
  BOTTOM w0.127: U176.1 v2(29.3,169.24)
PCIE0_PORZ: length 154.3
  L5-SIGNAL2 w0.102: v7(6.36,156.73) 6.36,160.34 10.21,164.19 22.22,164.19 22.88,163.53 30.8,163.53 v2(31.43,164.16)
  L12-SIGNAL5 w0.102: v7(6.36,156.73) 6.36,147.98 6,147.63 6,129.54 13.27,122.28 13.27,101.79 12.85,101.37 12.85,76.45 15.87,73.43 15.87,60.52 16.4,59.99 16.4,48.33 21.58,43.14 v2(22.13,43.14)
  BOTTOM w0.127: v2(31.43,164.16) 31.43,164.68 31.2,164.91 U176.4 ; v2(22.13,43.14) 23.04,43.14 U251.3
PCIE0_PRSNT1#: length 4.5
  BOTTOM w0.127: J14.A1 R813.2 R814.2 R815.2
PCIE0_PRSNT2#_1: length 24.9
  L3-SIGNAL1 w0.089: v2(18.55,159.04) 18.55,154.41 19.48,153.47 37.02,153.47 J14.B17
PCIE0_PRSNT2#_2: length 45.7
  L3-SIGNAL1 w0.089: v2(16.45,158.17) 16.45,158.33 18.73,160.6 30.58,160.6 31.74,161.77 47.66,161.77 49.96,159.48 49.96,158.53 50.93,157.55 50.93,155.56 J14.B31
  BOTTOM w0.127: R818.1 J14.B31
PCIE0_RX0_N: length 186.6
  L3-SIGNAL1 w0.104: v3(126.32,92.63) v5(126.54,92.91)
  L4-GND2 w0.121: v5(126.54,92.91) v7(126.85,93.22)
  L12-SIGNAL5 w0.121: v8(148.8,126.62) 148.75,126.57 arc(148.67,126.44) 148.64,126.3 148.64,126.04 arc(148.57,125.72) 148.4,125.46 144.53,121.59 132.94,110 arc(132.76,109.73) 132.7,109.42 132.7,105.61 arc(132.11,104.19) 130.69,103.61 130.15,103.61 arc(129.9,103.56) 129.69,103.42 127.79,101.52 arc(127.55,101.16) 127.47,100.74 127.47,98.33 arc(127.42,98.11) 127.3,97.93 126.93,97.56 arc(126.77,97.32) 126.71,97.03 126.71,94.62 arc(126.68,94.44) 126.57,94.28 126.5,94.21 arc(126.47,94.17) 126.46,94.13 126.46,93.73 arc(126.49,93.61) 126.56,93.51 v7(126.85,93.22)
  L13-GND5 w0.121: v9(148.8,126.95) v8(148.8,126.62)
  L14-SIGNAL6 w0.104: J14.A17 38.02,157.35 arc(37.9,157.64) 37.62,157.76 36.92,157.76 arc(36.62,157.82) 36.36,157.99 36.2,158.15 arc(35.99,158.47) 35.91,158.84 35.91,159.86 arc(36.04,160.5) 36.4,161.05 38.35,162.99 arc(39.5,163.76) 40.87,164.03 55.72,164.03 arc(56.29,163.92) 56.77,163.6 58.07,162.3 arc(58.85,161.78) 59.77,161.59 125.4,161.59 arc(126.62,161.35) 127.66,160.66 144.81,143.5 arc(145.23,143.23) 145.72,143.13 145.98,143.13 arc(146.53,143.02) 146.99,142.71 147.67,142.03 arc(148.43,140.89) 148.7,139.55 148.7,127.2 arc(148.73,127.06) v9(148.8,126.95)
  vias: v1(126.32,92.63)
PCIE0_RX0_P: length 186.6
  L3-SIGNAL1 w0.104: v3(125.52,92.63) v5(125.74,92.91)
  L4-GND2 w0.121: v5(125.74,92.91) v7(126.05,93.22)
  L12-SIGNAL5 w0.121: v7(126.05,93.22) 126.09,93.25 arc(126.18,93.4) 126.22,93.57 126.22,94.13 arc(126.25,94.27) 126.33,94.39 126.4,94.46 arc(126.45,94.53) 126.46,94.62 126.46,97.03 arc(126.54,97.41) 126.76,97.74 127.12,98.1 arc(127.19,98.21) 127.22,98.33 127.22,100.74 arc(127.32,101.25) 127.61,101.69 129.51,103.59 arc(129.8,103.79) 130.15,103.85 130.69,103.85 arc(131.94,104.37) 132.45,105.61 132.45,109.42 arc(132.53,109.83) 132.76,110.18 144.43,121.84 148.22,125.64 arc(148.35,125.82) 148.39,126.04 148.39,126.3 arc(148.36,126.44) 148.28,126.57 v8(148.22,126.62)
  L13-GND5 w0.121: v9(148.22,126.95) v8(148.22,126.62)
  L14-SIGNAL6 w0.104: J14.A16 37.79,158.97 arc(37.92,158.92) 37.97,158.79 37.97,158.28 arc(37.88,158.07) 37.67,157.99 36.92,157.99 arc(36.71,158.03) 36.52,158.15 36.37,158.31 arc(36.2,158.55) 36.14,158.84 36.14,159.86 arc(36.25,160.41) 36.57,160.88 38.51,162.83 arc(39.59,163.55) 40.87,163.8 55.72,163.8 arc(56.2,163.71) 56.61,163.44 57.91,162.13 arc(58.76,161.56) 59.77,161.36 125.4,161.36 arc(126.53,161.14) 127.49,160.49 144.65,143.34 arc(145.14,143.01) 145.72,142.9 145.98,142.9 arc(146.44,142.81) 146.83,142.55 147.51,141.86 arc(148.22,140.8) 148.47,139.55 148.47,127.19 arc(148.4,127.02) v9(148.22,126.95)
  vias: v1(125.52,92.63)
PCIE0_RX1_N: length 173.6
  L3-SIGNAL1 w0.104: v3(127.92,94.23) v5(128.14,94.51)
  L4-GND2 w0.121: v5(128.14,94.51) v7(128.45,94.82)
  L12-SIGNAL5 w0.121: v7(128.45,94.82) 128.21,95.06 arc(128.18,95.1) 128.17,95.14 128.17,100.43 arc(128.24,100.78) 128.44,101.08 129.51,102.15 arc(129.92,102.42) 130.4,102.51 132.16,102.51 arc(132.56,102.59) 132.9,102.82 133.71,103.63 arc(133.86,103.85) 133.91,104.11 133.91,105.97 arc(134.03,106.56) 134.36,107.06 134.66,107.36 135.87,108.57 arc(136.24,109.12) 136.37,109.78 136.37,110.31 arc(136.46,110.74) 136.7,111.11 147.11,121.52 arc(147.37,121.9) 147.46,122.35 147.46,122.46 arc(147.48,122.59) 147.56,122.7 v8(147.62,122.77)
  L13-GND5 w0.121: v9(147.62,123.1) v8(147.62,122.77)
  L14-SIGNAL6 w0.104: J14.A22 42.59,158.54 arc(42.51,158.34) 42.59,158.14 42.66,158.07 arc(43.05,157.91) 43.44,158.07 43.72,158.35 arc(43.85,158.55) 43.89,158.78 43.89,161.2 arc(44.37,162.34) 45.51,162.82 54.51,162.82 arc(55.44,162.63) 56.22,162.1 57.13,161.19 arc(58.04,160.59) 59.12,160.37 124.78,160.37 arc(126.1,160.11) 127.21,159.37 144.59,141.99 146.3,140.28 arc(147.1,139.08) 147.38,137.68 147.38,123.34 arc(147.45,123.17) v9(147.62,123.1)
  vias: v1(127.92,94.23)
PCIE0_RX1_P: length 173.6
  L3-SIGNAL1 w0.104: v3(127.12,94.23) v5(127.34,94.51)
  L4-GND2 w0.121: v5(127.34,94.51) v7(127.65,94.82)
  L12-SIGNAL5 w0.121: v7(127.65,94.82) 127.89,95.06 arc(127.92,95.1) 127.93,95.14 127.93,100.43 arc(128.01,100.88) 128.26,101.25 129.34,102.32 arc(129.82,102.65) 130.4,102.76 132.16,102.76 arc(132.47,102.82) 132.73,103 133.54,103.81 arc(133.63,103.95) 133.66,104.11 133.66,105.97 arc(133.8,106.66) 134.19,107.24 134.55,107.6 135.69,108.74 arc(136.01,109.22) 136.12,109.78 136.12,110.31 arc(136.23,110.84) 136.53,111.29 146.94,121.7 arc(147.14,122) 147.21,122.35 147.21,122.46 arc(147.18,122.59) 147.11,122.7 v8(147.04,122.77)
  L13-GND5 w0.121: v9(147.04,123.1) v8(147.04,122.77)
  L14-SIGNAL6 w0.104: v9(147.04,123.1) 147.09,123.15 arc(147.14,123.21) 147.15,123.28 147.15,137.68 arc(146.89,139) 146.14,140.11 127.05,159.2 arc(126.01,159.9) 124.78,160.14 59.12,160.14 arc(57.96,160.37) 56.97,161.03 56.06,161.94 arc(55.35,162.42) 54.51,162.58 45.51,162.58 arc(44.53,162.18) 44.13,161.2 44.13,158.78 arc(44.06,158.46) 43.88,158.19 43.6,157.91 arc(43.05,157.68) 42.49,157.91 arc(42.43,157.96) 42.35,157.97 42.23,157.97 arc(42.08,157.91) 42.02,157.76 J14.A21
  vias: v1(127.12,94.23)
PCIE0_RX2_N: length 166.8
  L3-SIGNAL1 w0.104: v3(129.52,93.43) v5(129.74,93.71)
  L4-GND2 w0.121: v5(129.74,93.71) v7(130.05,94.02)
  L12-SIGNAL5 w0.121: v7(130.05,94.02) 129.76,94.31 arc(129.69,94.41) 129.66,94.53 129.66,94.93 arc(129.67,94.97) 129.7,95.01 130.1,95.41 arc(130.18,95.53) 130.21,95.67 130.21,97.66 arc(130.24,97.79) 130.31,97.91 132.34,99.94 arc(132.48,100.03) 132.65,100.07 132.94,100.07 arc(133.21,100.12) 133.44,100.27 134.17,101 arc(134.36,101.13) 134.59,101.18 136.87,101.18 arc(137.33,101.27) 137.73,101.53 138.74,102.54 arc(139.21,103.24) 139.37,104.07 139.37,108.08 arc(139.53,108.85) 139.96,109.51 146.02,115.56 arc(146.16,115.77) 146.2,116.01 146.2,116.21 arc(146.24,116.38) v8(146.34,116.53)
  L13-GND5 w0.121: v9(146.34,116.86) v8(146.34,116.53)
  L14-SIGNAL6 w0.104: J14.A26 46.58,158.53 arc(46.49,158.32) 46.58,158.1 46.65,158.03 arc(46.68,158) 46.72,157.97 arc(47.07,157.88) 47.39,158.03 47.72,158.35 arc(47.85,158.55) 47.89,158.78 47.89,160.37 arc(48.25,161.24) 49.12,161.6 53.62,161.6 arc(54.68,161.38) 55.59,160.78 56.36,160.01 arc(57.31,159.38) 58.43,159.15 124.35,159.15 arc(125.61,158.91) 126.67,158.2 144.97,139.89 arc(145.91,138.49) 146.24,136.84 146.24,128.95 146.24,117.1 arc(146.26,116.97) v9(146.34,116.86)
  vias: v1(129.52,93.43)
PCIE0_RX2_P: length 166.8
  L3-SIGNAL1 w0.104: v3(128.72,93.43) v5(128.94,93.71)
  L4-GND2 w0.121: v5(128.94,93.71) v7(129.25,94.02)
  L12-SIGNAL5 w0.121: v7(129.25,94.02) 129.29,94.05 arc(129.38,94.2) 129.42,94.37 129.42,94.93 arc(129.45,95.07) 129.53,95.19 129.93,95.59 arc(129.95,95.63) 129.96,95.67 129.96,97.66 arc(130.01,97.89) 130.14,98.08 132.17,100.12 arc(132.39,100.26) 132.65,100.31 132.94,100.31 arc(133.12,100.35) 133.26,100.44 133.99,101.18 arc(134.27,101.36) 134.59,101.42 136.87,101.42 arc(137.24,101.5) 137.55,101.71 138.57,102.72 arc(138.98,103.34) 139.12,104.07 139.12,108.08 arc(139.3,108.95) 139.79,109.68 145.84,115.74 arc(145.93,115.86) 145.96,116.01 145.96,116.22 arc(145.94,116.32) 145.88,116.41 v8(145.76,116.53)
  L13-GND5 w0.121: v9(145.76,116.86) v8(145.76,116.53)
  L14-SIGNAL6 w0.104: J14.A25 46.02,157.67 arc(46.1,157.85) 46.28,157.93 46.34,157.93 arc(46.42,157.91) 46.48,157.87 arc(46.53,157.82) 46.59,157.78 arc(47.09,157.65) 47.56,157.87 47.88,158.19 arc(48.06,158.46) 48.13,158.78 48.13,160.37 arc(48.42,161.07) 49.12,161.36 53.62,161.36 arc(54.6,161.17) 55.43,160.61 56.19,159.85 arc(57.22,159.16) 58.43,158.92 124.35,158.92 arc(125.52,158.69) 126.51,158.03 144.81,139.73 arc(145.69,138.4) 146.01,136.84 146.01,128.95 146,117.11 arc(145.93,116.93) v9(145.76,116.86)
  vias: v1(128.72,93.43)
PCIE0_RX3_N: length 160.2
  L3-SIGNAL1 w0.104: v3(128.72,92.63) v5(128.94,92.91)
  L4-GND2 w0.121: v5(128.94,92.91) v7(129.25,93.22)
  L12-SIGNAL5 w0.121: v8(145.08,117.94) 145.04,117.89 arc(144.95,117.76) 144.92,117.61 144.92,117.3 arc(144.83,116.84) 144.57,116.45 137.8,109.68 arc(137.57,109.34) 137.49,108.94 137.49,104.01 arc(137.21,103.34) 136.53,103.05 134.69,103.05 arc(134.31,102.98) 133.99,102.77 131.57,100.34 arc(131.26,100.14) 130.9,100.07 130.43,100.07 arc(130.22,100.02) 130.03,99.9 129.64,99.51 arc(129.46,99.24) 129.4,98.93 129.4,95.56 arc(129.37,95.42) 129.29,95.3 129.21,95.22 arc(129.18,95.18) 129.17,95.13 129.17,94.63 arc(129.14,94.49) 129.06,94.37 128.91,94.22 arc(128.88,94.17) 128.86,94.12 128.86,93.73 arc(128.89,93.61) 128.96,93.51 v7(129.25,93.22)
  L13-GND5 w0.121: v9(145.08,118.26) v8(145.08,117.94)
  L14-SIGNAL6 w0.104: J14.A30 50.57,158.53 arc(50.5,158.34) 50.57,158.16 50.66,158.07 arc(51.05,157.91) 51.44,158.07 51.72,158.35 arc(51.85,158.55) 51.89,158.78 51.89,159.6 arc(52.11,160.13) 52.64,160.35 53.5,160.35 arc(53.92,160.26) 54.28,160.02 55.25,159.05 arc(56.49,158.23) 57.95,157.94 124.03,157.94 124.03,157.94 124.43,157.94 arc(125.15,157.79) 125.76,157.39 126.1,157.04 142.56,140.58 arc(144.36,137.89) 144.99,134.71 144.99,118.49 arc(145.02,118.37) v9(145.08,118.26)
  vias: v1(128.72,92.63)
PCIE0_RX3_P: length 160.2
  L3-SIGNAL1 w0.104: v3(127.92,92.63) v5(128.14,92.91)
  L4-GND2 w0.121: v5(128.14,92.91) v7(128.45,93.22)
  L12-SIGNAL5 w0.121: v8(144.51,117.94) 144.55,117.89 arc(144.64,117.76) 144.67,117.61 144.67,117.3 arc(144.6,116.93) 144.39,116.62 137.63,109.86 arc(137.34,109.43) 137.24,108.94 137.24,104.01 arc(137.04,103.51) 136.53,103.3 134.69,103.3 arc(134.22,103.21) 133.82,102.94 131.4,100.52 arc(131.17,100.37) 130.9,100.31 130.43,100.31 arc(130.12,100.25) 129.86,100.08 129.46,99.68 arc(129.23,99.34) 129.15,98.93 129.15,95.56 arc(129.14,95.52) 129.12,95.48 129.03,95.39 arc(128.95,95.27) 128.92,95.13 128.92,94.63 arc(128.91,94.59) 128.89,94.55 128.73,94.39 arc(128.65,94.27) 128.62,94.12 128.62,93.57 arc(128.58,93.4) 128.49,93.25 v7(128.45,93.22)
  L13-GND5 w0.121: v9(144.51,118.26) v8(144.51,117.94)
  L14-SIGNAL6 w0.104: J14.A29 50.02,157.65 arc(50.12,157.88) 50.35,157.97 arc(50.43,157.96) 50.49,157.91 arc(51.05,157.68) 51.6,157.91 51.88,158.19 arc(52.06,158.46) 52.13,158.78 52.13,159.6 arc(52.28,159.96) 52.64,160.11 53.5,160.11 arc(53.83,160.05) 54.12,159.86 55.09,158.89 arc(56.4,158.01) 57.95,157.7 124.03,157.7 124.03,157.7 124.43,157.7 arc(125.06,157.58) 125.59,157.22 125.93,156.88 142.4,140.41 arc(144.15,137.8) 144.76,134.71 144.76,118.52 arc(144.69,118.34) 144.51,118.26 v9(144.51,118.26)
  vias: v1(127.92,92.63)
PCIE0_TCK: length 4.5
  TOP w0.127: R84.2 23.73,160.13 24.02,159.84 J14.A5
PCIE0_TDI: length 2.4
  TOP w0.127: R85.1 24.88,159.11 J14.A6
PCIE0_TDO: length 4.4
  TOP w0.127: J14.A7 R86.1
PCIE0_TMS: length 2.4
  TOP w0.127: J14.A8 27.16,159.11 R87.1
PCIE0_TRST#: length 5.4
  BOTTOM w0.127: J14.B9 28.79,153.7 29.32,153.7 30.29,152.73 R824.1
PCIE0_TX0_N: length 4.2
  BOTTOM w0.122: 36.16,152 36.16,152.03 36.15,152.05 36.15,152.76 arc(36.08,153.09) 35.9,153.36 35.62,153.64 arc(35.53,153.86) 35.62,154.07 J14.B15
  BOTTOM w0.132: 36.16,152 36.16,151.09 arc(36.18,150.96) 36.26,150.85 C627.2
PCIE0_TX0_P: length 4.2
  BOTTOM w0.122: 35.88,152 35.88,152.03 35.89,152.05 35.89,152.76 arc(35.85,152.99) 35.72,153.18 35.52,153.38 arc(35.35,153.46) 35.17,153.38 35.09,153.3 arc(35.04,153.22) 35.02,153.13 J14.B14
  BOTTOM w0.132: 35.88,152 35.88,151.09 arc(35.85,150.96) 35.78,150.85 C628.2
PCIE0_TX1_N: length 4.2
  BOTTOM w0.122: 40.16,152 40.16,152.03 40.15,152.05 40.15,152.76 arc(40.19,152.99) 40.32,153.18 40.52,153.38 arc(40.69,153.46) 40.87,153.38 40.95,153.3 arc(41,153.22) 41.02,153.13 J14.B20
  BOTTOM w0.132: 40.16,152 40.16,151.09 arc(40.18,150.96) 40.26,150.85 C625.2
PCIE0_TX1_P: length 4.2
  BOTTOM w0.122: J14.B19 40.42,154.07 arc(40.51,153.86) 40.42,153.64 40.14,153.36 arc(39.96,153.09) 39.89,152.76 39.89,152.05 39.88,152.03 39.88,152
  BOTTOM w0.132: C626.2 39.78,150.85 arc(39.85,150.96) 39.88,151.09 39.88,152
PCIE0_TX2_N: length 4.2
  BOTTOM w0.122: J14.B24 45.02,153.13 arc(45,153.22) 44.95,153.3 44.87,153.38 arc(44.69,153.46) 44.52,153.38 44.32,153.18 arc(44.19,152.99) 44.15,152.76 44.15,152.05 44.16,152.03 44.16,152
  BOTTOM w0.132: 44.16,152 44.16,151.09 arc(44.18,150.96) 44.26,150.85 C623.2
PCIE0_TX2_P: length 4.2
  BOTTOM w0.122: 43.88,152 43.88,152.03 43.89,152.05 43.89,152.76 arc(43.96,153.09) 44.14,153.36 44.42,153.64 arc(44.51,153.86) 44.42,154.07 J14.B23
  BOTTOM w0.132: C624.2 43.78,150.85 arc(43.85,150.96) 43.88,151.09 43.88,152
PCIE0_TX3_N: length 4.2
  BOTTOM w0.122: J14.B28 49.02,153.13 arc(49,153.22) 48.95,153.3 48.87,153.38 arc(48.69,153.46) 48.52,153.38 48.32,153.18 arc(48.19,152.99) 48.15,152.76 48.15,152.05 48.16,152.03 48.16,152
  BOTTOM w0.132: 48.16,152 48.16,151.09 arc(48.18,150.96) 48.26,150.85 C621.2
PCIE0_TX3_P: length 4.2
  BOTTOM w0.122: 47.88,152 47.88,152.03 47.89,152.05 47.89,152.76 arc(47.96,153.09) 48.14,153.36 48.42,153.64 arc(48.51,153.86) 48.42,154.07 J14.B27
  BOTTOM w0.132: C622.2 47.78,150.85 arc(47.85,150.96) 47.88,151.09 47.88,152
PCIE1/HYP0_RX0_N: length 165.5
  L3-SIGNAL1 w0.104: v3(124.72,93.43) v5(124.94,93.71)
  L4-GND2 w0.121: v5(124.94,93.71) v7(125.25,94.02)
  L13-GND5 w0.121: v9(125.54,93.73) 125.46,93.8 v7(125.25,94.02)
  L14-SIGNAL6 w0.104: J17.A17 38.02,137.03 arc(37.9,137.32) 37.62,137.44 36.9,137.44 arc(36.62,137.49) 36.37,137.66 36.16,137.87 arc(35.97,138.15) 35.9,138.49 35.9,139.97 arc(36.05,140.72) 36.47,141.35 38.32,143.19 arc(38.9,143.58) 39.58,143.71 52.01,143.71 arc(53.48,144.01) 54.73,144.84 59.23,149.33 arc(60.67,150.3) 62.38,150.64 122.31,150.64 arc(123.04,150.5) 123.66,150.09 133.31,140.43 arc(134.66,138.41) 135.14,136.02 135.14,104.78 arc(134.9,104.22) 134.34,103.99 133.29,103.99 arc(133.05,103.94) 132.84,103.8 130.47,101.43 arc(130.29,101.17) 130.23,100.85 130.23,97.98 arc(130.15,97.55) 129.91,97.19 129.21,96.49 arc(128.96,96.32) 128.66,96.26 126.81,96.26 arc(126.64,96.23) 126.49,96.13 125.35,94.99 arc(125.28,94.89) 125.26,94.77 125.26,93.83 arc(125.29,93.76) 125.36,93.73 v9(125.54,93.73)
  vias: v1(124.72,93.43)
PCIE1/HYP0_RX0_P: length 165.5
  L3-SIGNAL1 w0.104: v3(123.92,93.43) v5(124.14,93.71)
  L4-GND2 w0.121: v5(124.14,93.71) v7(124.45,94.02)
  L13-GND5 w0.121: v7(124.45,94.02) 124.66,93.8 v9(124.74,93.73)
  L14-SIGNAL6 w0.104: v9(124.74,93.73) 124.92,93.73 arc(124.99,93.76) 125.02,93.83 125.02,94.77 arc(125.07,94.98) 125.18,95.15 126.33,96.3 arc(126.55,96.44) 126.81,96.5 128.66,96.5 arc(128.87,96.54) 129.05,96.66 129.74,97.35 arc(129.93,97.64) 130,97.98 130,100.85 arc(130.08,101.26) 130.31,101.6 132.67,103.96 arc(132.96,104.15) 133.29,104.22 134.34,104.22 arc(134.74,104.38) 134.91,104.78 134.91,136.02 arc(134.45,138.32) 133.15,140.26 123.49,149.92 arc(122.95,150.28) 122.31,150.41 62.38,150.41 arc(60.76,150.09) 59.39,149.17 54.9,144.68 arc(53.57,143.79) 52.01,143.48 39.58,143.48 arc(38.99,143.36) 38.48,143.03 36.64,141.18 arc(36.27,140.63) 36.14,139.97 36.14,138.49 arc(36.18,138.24) 36.32,138.03 36.54,137.82 arc(36.7,137.71) 36.9,137.67 37.71,137.67 arc(37.9,137.74) 37.97,137.93 37.97,138.46 arc(37.92,138.6) 37.79,138.65 J17.A16
  vias: v1(123.92,93.43)
PCIE1/HYP0_RX1_N: length 153.8
  L3-SIGNAL1 w0.104: v3(123.92,92.63) v5(124.14,92.91)
  L4-GND2 w0.121: v5(124.14,92.91) v7(124.45,93.22)
  L13-GND5 w0.121: v9(124.74,92.93) 124.66,93 v7(124.45,93.22)
  L14-SIGNAL6 w0.104: J17.A22 42.57,138.2 arc(42.5,138.02) 42.57,137.84 42.66,137.75 arc(43.05,137.59) 43.44,137.75 43.71,138.03 arc(43.85,138.24) 43.9,138.5 43.9,140.87 arc(44.38,142.02) 45.53,142.5 52.37,142.5 arc(53.99,142.82) 55.36,143.73 59.82,148.2 arc(61.18,149.11) 62.78,149.42 121.71,149.42 arc(122.38,149.29) 122.95,148.91 132.52,139.34 arc(133.55,137.81) 133.91,136 133.91,108.15 arc(133.76,107.44) 133.36,106.84 132.81,106.29 arc(132.69,106.11) 132.65,105.9 132.65,105.13 arc(132.57,104.74) 132.35,104.4 129.77,101.83 arc(129.61,101.58) 129.55,101.29 129.55,99.51 arc(129.48,99.17) 129.29,98.88 127.96,97.55 arc(127.61,97.31) 127.19,97.23 126.71,97.23 arc(126.53,97.19) 126.38,97.09 124.85,95.56 arc(124.76,95.42) 124.72,95.25 124.72,94.75 arc(124.7,94.63) 124.62,94.52 124.46,94.35 arc(124.44,94.32) 124.43,94.28 124.43,93.28 arc(124.44,93.24) 124.46,93.21 v9(124.74,92.93)
  vias: v1(123.92,92.63)
