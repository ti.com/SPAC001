# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD_DDR_1V1_IN+: length 4.8
  TOP w0.127: U84.D3 191.69,51.29 191.09,50.69 U83.10 190.27,50.7 189.36,50.7 189.15,50.48 C337.2 188.07,50.48 187.96,50.37 R520.1
VDD_DDR_1V1_IN-: length 6.3
  TOP w0.127: 189.1,51.4 C337.1 188.03,51.4 187.92,51.51 R509.1 ; 189.1,51.4 189.31,51.19 U83.9 ; 189.1,51.4 189.39,51.69 U83.8 191.24,51.69 191.44,51.89 191.68,51.89 ; 191.68,51.89 191.88,52.09 U84.D1 ; 191.68,51.89 U84.D2
VDD_DDR_1V1_N: length 1.4
  TOP w0.127: TP172.1 185.83,51.65 185.96,51.51 R509.2
VDD_DDR_1V1_P: length 1.4
  TOP w0.127: TP174.1 185.85,50.23 185.99,50.37 R520.2
VDD_DDR_SOC_1V1_IN+: length 4.8
  TOP w0.127: R555.1 187.96,45.61 188.07,45.72 C358.2 189.03,45.72 189.24,45.93 U94.10 191.28,45.93 U93.D3
VDD_DDR_SOC_1V1_IN-: length 6.3
  TOP w0.127: R551.1 187.92,46.75 188.03,46.64 C358.1 189.1,46.64 ; 189.1,46.64 189.31,46.43 U94.9 ; 189.1,46.64 189.39,46.93 U94.8 191.26,46.93 191.46,47.13 191.68,47.13 ; 191.68,47.13 U93.D2 ; 191.68,47.13 U93.D1
VDD_DDR_SOC_1V1_N: length 1.4
  TOP w0.127: TP178.1 185.84,46.89 185.98,46.75 R551.2
VDD_DDR_SOC_1V1_P: length 1.4
  TOP w0.127: TP181.1 185.85,45.47 185.99,45.61 R555.2
VDD_GPIORET_IO_3V3: length 113.4
  TOP w0.254: v2(85.88,65.56) 85.88,66.07 86.21,66.4 R438.1 TP152.1 ; v2(168.79,44.3) 168.79,46.73 169.05,46.98 C359.1 169.36,47.48 169.58,47.71 U89.2 ; v2(122.77,25.65) 123.23,26.11 C427.1 124.12,26.35 U134.5
  L7-SIGNAL3 w0.381: v2(122.77,25.65) 124.34,25.65 126.2,23.8 v2(126.2,22.8)
  L12-SIGNAL5 w0.381: 87.1,38.26 89.85,38.26 92.13,35.97 92.13,34.67 92.77,34.04 92.77,32.89 94.14,31.52 94.14,30.76 94.81,30.09 96.72,30.09 98.26,28.55 105.93,28.55 107.15,27.33 112.1,27.33 114.18,25.25 122.36,25.25 v2(122.77,25.65)
  L14-SIGNAL6 w0.381: v2(122.77,25.65) 123.43,25.65 125.7,27.93 125.7,29.02 130.05,33.37 156.59,33.37 165.81,42.6 167.09,42.6 v2(168.79,44.3)
VDD_GPIORET_IO_3V3_IN+: length 4.8
  BOTTOM w0.127: U235.D3 65.3,63.27 U236.10 67.27,63.27 67.48,63.06 C1073.2 68.51,63.06 68.62,62.94 R1110.1
VDD_GPIORET_IO_3V3_IN-: length 6.3
  BOTTOM w0.127: 67.48,63.98 67.19,64.27 U236.8 65.32,64.27 65.12,64.47 64.9,64.47 ; 67.48,63.98 67.27,63.77 U236.9 ; 67.48,63.98 C1073.1 68.55,63.98 68.66,64.09 R1106.1 ; 64.9,64.47 U235.D2 ; 64.9,64.47 U235.D1
VDD_GPIORET_IO_3V3_LS:
  vias: v4(83.83,68.87) v4(84.47,68.87)
VDD_GPIORET_IO_3V3_N: length 20.5
  L7-SIGNAL3 w0.109: v2(71.36,64.26) 71.36,63.87 71.47,63.76 81.8,63.76 83.52,65.49 83.52,67.13 84.54,68.15 85.38,68.15 85.72,67.8 85.72,67.52 86.03,67.22 v2(86.04,67.22)
  BOTTOM w0.127: R1106.2 70.42,63.67 71.24,63.67 71.36,63.8 v2(71.36,64.26)
VDD_GPIORET_IO_3V3_P: length 20.2
  L7-SIGNAL3 w0.109: v2(85.28,67.22) 85.48,67.42 85.48,67.7 85.28,67.9 84.64,67.9 83.83,67.09 83.83,65.34 81.95,63.46 71.47,63.46 71.36,63.35 v2(71.36,62.85)
  BOTTOM w0.127: R1110.2 70.42,63.37 71.24,63.37 71.36,63.24 v2(71.36,62.85)
VDD_GPIORET_WK_0V8: length 130.6
  TOP w0.254: v2(170.53,52.54) 170.08,52.09 170.08,51.39 U89.10
  TOP w0.381: v4(84.08,73.18) 84.26,73.37 TP139.1
  L5-SIGNAL2 w0.127: v2(80.81,47.32) 81.61,48.12 96.35,48.12 100.1,44.37 130.78,44.37 131.48,43.67 143.29,43.67 146.86,47.25 162.06,47.25 167.01,52.21 167.01,52.86 168.1,53.95 171.31,53.95 171.83,53.43 171.83,52.91 171.45,52.54 v2(170.53,52.54)
  L14-SIGNAL6 w0.127: v4(84.08,73.18) 84.08,72.52 85.38,71.22 85.38,68.87 84.21,67.7 84.21,66.7 81.09,63.58 81.09,47.6 v2(80.81,47.32)
VDD_GPIORET_WK_0V8_IN+: length 4.8
  BOTTOM w0.127: U231.D3 65.3,68.09 U232.10 67.27,68.09 67.48,67.88 C1052.2 68.51,67.88 68.62,67.77 R1091.1
VDD_GPIORET_WK_0V8_IN-: length 6.3
  BOTTOM w0.127: R1084.1 68.66,68.91 68.55,68.8 C1052.1 67.48,68.8 ; 64.9,69.29 U231.D1 ; 64.9,69.29 65.12,69.29 65.32,69.09 U232.8 67.19,69.09 67.48,68.8 ; 64.9,69.29 U231.D2 ; U232.9 67.27,68.59 67.48,68.8
VDD_GPIORET_WK_0V8_N: length 16.2
  L7-SIGNAL3 w0.109: v2(71.36,69.04) 71.36,68.73 71.47,68.62 72.27,68.62 74.88,71.22 78.34,71.22 80.12,73.01 82.17,73.01 82.49,72.68 82.49,72.39 v4(82.78,72.11)
  BOTTOM w0.127: v2(71.36,69.04) 71.36,68.62 71.24,68.49 70.42,68.49 R1084.2
VDD_GPIORET_WK_0V8_P: length 16.1
  L7-SIGNAL3 w0.109: v4(82.01,72.11) 82.26,72.36 82.26,72.59 82.07,72.77 80.22,72.77 78.43,70.99 74.98,70.99 72.37,68.38 71.51,68.38 71.36,68.24 v2(71.36,67.63)
  BOTTOM w0.127: R1091.2 70.42,68.19 71.24,68.19 71.36,68.06 v2(71.36,67.63)
VDD_GPIORET_WK_0V8_PG: length 6.2
  TOP w0.127: U66.5 76.55,75.22 R413.1 75.92,74.99 75.72,75.19 74.46,75.19 TP137.1 R1299.2
VDD_GPIORET_WK_0V8_REG: length 3.3
  TOP w0.127: v2(81.82,74.58) 81.95,74.45 82.95,74.45
  TOP w0.254: 82.95,74.45 83.23,74.74 C274.1 83.19,75.36 R406.2
  vias: v2(75.08,74.58)
VDD_IO_1V8: length 274
  TOP w0.229: U68.50 v2(175.83,78.98)
  TOP w0.254: U63.4 84.66,78.3 v2(84.16,77.8) ; v2(109.71,117.59) 109.85,117.45 U41.4
  TOP w0.305: v2(128.32,88.23) 127.92,87.83 U59.AE8 ; U59.AF7 128.72,88.63 v2(129.12,89.03)
  TOP w0.381: Q3.2 v2(157.69,46.08)
  L9-PWR2 w0.381: v2(109.71,117.59) 111.63,117.59 112.58,118.54 150.13,118.54 153.35,115.32 153.35,112.03 153.91,111.48 153.91,110.37 ; 153.87,104.76 155.46,103.17 159.93,103.17 165.53,97.57 v4(165.53,85.48)
  L10-SIGNAL4 w0.203: v2(109.71,117.59) 109.71,118.69 108.39,120.01 104.89,120.01 99.13,114.26 99.13,113.19 97.77,111.82 96.7,111.82 95.45,110.58 95.45,103.61 95.45,101.27 94.71,100.53 91.9,100.53 90.81,99.43 85.71,99.43 74.84,88.56 74.84,81.11 76.49,79.46 83.01,79.46 84.16,78.31 v2(84.16,77.8)
  L12-SIGNAL5 w0.127: 162.37,100.61 160.84,102.14 146.27,102.14 144.56,100.43 144.56,93.5 140.06,89 132.55,89 132.16,88.62 130.78,88.62 130.37,89.03 v2(129.12,89.03)
  L12-SIGNAL5 w0.305: v2(175.83,78.98) 175.22,78.37 171.21,78.37 168.95,80.63
  L12-SIGNAL5 w0.381: v2(157.69,46.08) 158.15,46.08 164.02,51.94 164.02,83.96 v4(165.53,85.48) ; 168.95,80.63 168.95,86.23 165.38,89.79 165.38,97.6 162.37,100.61
  vias: v2(141.89,99.09) v4(166.5,85.48)
VDD_IO_1V8_IN+: length 4.8
  TOP w0.127: U57.D3 194.86,82.43 U56.10 192.82,82.43 192.61,82.22 C251.2 191.65,82.22 191.54,82.11 R370.1
VDD_IO_1V8_IN-: length 6.3
  TOP w0.127: U56.9 192.9,82.93 192.69,83.14 ; 192.69,83.14 C251.1 191.61,83.14 191.5,83.26 R359.1 ; 192.69,83.14 192.98,83.43 U56.8 194.89,83.43 195.09,83.63 195.26,83.63 ; 195.26,83.63 U57.D1 ; 195.26,83.63 U57.D2
VDD_IO_1V8_N: length 29.2
  TOP w0.127: R359.2 189.74,82.83 188.93,82.83 188.8,82.96 v3(188.8,83.39)
  L3-SIGNAL1 w0.089: v3(188.8,83.39) 188.8,82.95 188.88,82.87 189.8,82.87 190.25,82.41 190.25,82.1 189.31,81.16 181.44,81.16 180.71,81.89 168.71,81.89 167.5,83.11 167.5,83.45 v2(167.21,83.74)
VDD_IO_1V8_P: length 28.1
  TOP w0.127: v3(188.8,81.98) 188.8,82.4 188.93,82.53 189.75,82.53 R370.2
  L3-SIGNAL1 w0.089: v2(167.93,83.74) 167.72,83.53 167.72,83.19 168.8,82.11 180.8,82.11 181.53,81.38 189.22,81.38 190.03,82.19 190.03,82.32 189.71,82.64 188.88,82.64 188.8,82.56 v3(188.8,81.98)
VDD_IO_1V8_REG:
  vias: v4(171.13,85.38) v4(171.13,84.23) v4(171.13,83.09) v4(172.02,85.38) v4(172.02,84.23) v4(172.02,83.09)
VDD_IO_3V3: length 168
  TOP w0.254: v2(176.4,51.2) 176.72,50.88 U87.2 ; C1271.1 68.49,92.66 69.27,93.45 71.97,93.45 73.03,92.38 74.41,92.38 76.06,94.03 78.62,94.03 79.05,93.6 79.05,92.46 78.42,91.82 78.42,88.62 78.04,88.24 78.04,86.13 78.01,86.1 78.01,84.68 v2(78.12,84.57) ; C1271.1 R316.2 ; C1271.1 67.29,92.66 66.86,93.09 U281.5
  TOP w0.305: v2(111.52,80.23) 111.91,80.63 U59.T28
  L5-SIGNAL2 w0.203: v2(93.79,47.45) 98.43,42.8 123.35,42.8 123.45,42.9 129.98,42.9 130.58,42.3 156.07,42.3 157.18,43.41 168.55,43.41 173.87,48.73 173.87,49.27 175.8,51.2 v2(176.4,51.2)
  L7-SIGNAL3 w0.381: v2(89.44,70.67) 88.36,70.67 87.46,69.77 87.46,64.75 88.58,63.63 88.58,57.79 91.02,55.35 91.02,50.22 v2(93.79,47.45)
  L8-PWR1 w0.203: v2(77.51,84.57) v2(78.12,84.57)
  L8-PWR1 w0.508: v2(77.51,84.57) 76.59,83.65 76.59,82.07 77.61,81.04 77.61,80.5 77.48,80.37 77.48,77.67 78.57,76.58 80.78,76.58 82.32,75.04 84.35,75.04 84.54,75.23 85.87,75.23 86.77,74.33 86.77,72.58 87.57,71.78 88.33,71.78 v2(89.44,70.67)
  vias: v2(101.87,81.69)
VDD_IO_3V3_IN+: length 4.8
  BOTTOM w0.127: U219.D3 65.3,88.28 U218.10 67.27,88.28 67.48,88.07 C858.2 68.51,88.07 68.62,87.96 R991.1
VDD_IO_3V3_IN-: length 6.4
  BOTTOM w0.127: 67.48,88.99 C858.1 68.55,88.99 68.61,88.93 68.99,88.93 R983.1 ; 67.48,88.99 67.27,88.78 U218.9 ; 67.48,88.99 67.19,89.28 U218.8 65.32,89.28 65.12,89.48 64.9,89.48 ; 64.9,89.48 U219.D1 ; 64.9,89.48 U219.D2
VDD_IO_3V3_LS: length 74
  L10-SIGNAL4 w0.381: v2(120.22,114.93) 120.22,116.19 119.67,116.74 109.19,116.74 107.93,117.99 107.93,118.93 107.51,119.35 105.22,119.35 99.97,114.1 99.97,112.55 97.67,110.25 96.53,110.25 96.05,109.77 96.05,101.01 94.85,99.81 92.48,99.81 91.13,98.46 85.67,98.46 75.4,88.2 75.4,84.77 v2(77.41,82.76)
  BOTTOM w0.254: R930.2 120.53,115.24 v2(120.22,114.93)
  vias: v2(78.43,82.76)
VDD_IO_3V3_N: length 11.4
  BOTTOM w0.127: R983.2 70.42,88.69 70.81,88.69 TP303.1 71.36,88.77 71.49,88.63 72.06,88.63 72.5,88.19 72.5,85.26 73.94,83.82 76.47,83.82 R1014.1
VDD_IO_3V3_P: length 11.3
  BOTTOM w0.127: R1014.4 76.48,83.57 73.73,83.57 72.2,85.1 72.2,88.05 71.93,88.32 71.49,88.32 71.36,88.19 TP304.1 70.8,88.38 70.42,88.38 R991.2
VDD_MCU_0V85: length 400.2
  TOP w0.254: U69.1 v2(77.42,70.48) ; U89.12 169.08,52.09 168.99,52.19 C328.1 168.99,53.02 v2(168.85,53.17)
  TOP w0.305: v2(115.52,77.03) 115.91,77.43 U59.M23 ; v2(115.52,75.43) 115.91,75.83 U59.K23 ; U59.J22 116.71,75.03 v2(116.32,74.63) ; U59.K21 117.51,75.83 v2(117.12,75.43) ; U59.L24 115.11,76.63 v2(114.73,76.25) ; U68.37 180.81,74.82 v2(180.94,74.7) ; v2(113.92,77.03) 114.31,77.43 U59.M25 ; v2(117.12,77.03) 117.51,77.43 U59.M21
  TOP w0.381: R580.1 158.7,40.38 TP204.1
  L10-SIGNAL4 w0.127: v2(116.32,74.63) 116.73,74.22 116.73,70.94 117.18,70.49 117.18,65.94 136.29,46.83 141.55,46.83 146.57,41.8 168.41,41.8 170.77,44.17 180.91,44.17 184.62,47.88 184.62,55.6 182.89,57.33 175.45,57.33 172.12,54 169.17,54 168.85,53.68 v2(168.85,53.17)
  L10-SIGNAL4 w0.305: v2(77.42,70.48) 77.93,69.96 81.51,69.96 v2(82.22,70.67) 83.01,69.88 84.95,69.88 86.6,68.23 v4(88.03,68.23)
  L12-SIGNAL5 w0.127: TP204.1 160.18,41.86 160.18,42.18 159.98,42.39 158.15,42.39 156.35,40.59 139.45,40.59 132.52,33.66 118.17,33.66 109.58,42.24 102.8,42.24 97.85,47.19 97.85,51.13 110.96,64.24 114.49,64.24 115.4,65.15 115.4,69.67 116.7,70.97 116.7,74.25 v2(116.32,74.63) ; v2(180.94,74.7) 179.83,73.59 173.62,73.59 173.29,73.26 173.05,73.26 173.04,73.27 172.67,73.27 172.66,73.26 172.32,73.26 171.99,72.93 171.99,72.32 167.83,68.16 167.83,54.91 154.69,41.78 139.63,41.78 132.09,34.24 118.47,34.24 109.84,42.88 102.95,42.88 98.41,47.42 98.41,50.67 111.36,63.63 114.66,63.63 115.93,64.89 115.93,69.13 118.3,71.5 118.3,74.79 118.08,75.02 117.53,75.02 v2(117.12,75.43)
  vias: v2(93.54,68.23) v2(94.79,68.23) v2(95.7,68.23) v2(96.95,68.23) v4(89.63,68.23) v4(90.95,68.23) v4(92.55,68.23) v4(188.62,72.7) v4(188.62,71.74) v4(188.62,70.77) v4(188.62,69.81) v4(189.59,72.7) v4(189.59,71.74) v4(189.59,70.77) v4(189.59,69.81) v4(190.55,72.7) v4(190.55,71.74) v4(190.55,70.77) v4(190.55,69.81)
VDD_MCU_0V85_N: length 15.8
  TOP w0.127: R388.2 189.74,78.8 188.93,78.8 188.8,78.93 v3(188.8,79.36) ; v2(187.97,69.01) 187.87,69.1 R427.1
  L3-SIGNAL1 w0.089: v2(187.97,69.01) 187.61,69.36 187.61,75.52 188.25,76.16 189.34,76.16 190.03,76.85 190.03,78.34 189.55,78.83 189.04,78.83 188.8,79.07 v3(188.8,79.36)
VDD_MCU_0V85_P: length 15.5
  TOP w0.127: R393.2 189.75,78.5 188.93,78.5 188.8,78.37 v3(188.8,77.95) ; R427.4 187.15,69.1 v2(187.05,69.01)
  L3-SIGNAL1 w0.089: v3(188.8,77.95) 188.8,78.36 189.04,78.6 189.46,78.6 189.8,78.25 189.8,76.94 189.25,76.39 188.15,76.39 187.38,75.62 187.38,69.34 v2(187.05,69.01)
VDD_MCU_0V85_REG:
  vias: v4(184.46,74.43) v4(184.46,73.54) v4(185.61,74.43) v4(185.61,73.54) v4(186.75,74.43) v4(186.75,73.54)
VDD_MCU_2V5: length 4.7
  TOP w0.254: R643.1 111.4,22.87 v2(111.95,22.32)
  BOTTOM w0.254: U261.3 101.11,21.52 v2(101.11,20.66) C1221.1 ; U261.9 v2(98.11,20.66) C1223.1
  vias: v2(110.75,22.74) v2(110.75,21.83) v2(120.16,23.2)
VDD_MCU_RAM_0V85: length 147.1
  L8-PWR1 w0.152: v4(183.29,69.63) 183.29,56.49 179.21,52.41 178.56,52.41 177.29,51.13 177.29,49.58 176.43,48.72 175.53,48.72 164.4,37.59 130.39,37.59 130.08,37.9 117.76,37.9 117.46,37.59 115.53,37.59 113.9,39.22 96.55,39.22 95.65,40.12 95.65,63.69 97.87,65.91 97.87,69.02 v2(95.99,70.9)
  BOTTOM w0.254: v4(183.29,69.63) 183.29,70.92 183.77,71.4 R1057.2
VDD_MCU_RAM_0V85_IN+: length 4.8
  TOP w0.127: R412.1 191.54,74.05 191.65,74.16 C272.2 192.61,74.16 192.82,74.37 U65.10 194.86,74.37 U64.D3
VDD_MCU_RAM_0V85_IN-: length 6.3
  TOP w0.127: 192.69,75.08 192.98,75.37 U65.8 194.84,75.37 195.04,75.57 195.26,75.57 ; 192.69,75.08 192.9,74.87 U65.9 ; 192.69,75.08 C272.1 191.61,75.08 191.5,75.19 R408.1 ; 195.26,75.57 U64.D2 ; 195.26,75.57 U64.D1
VDD_MCU_RAM_0V85_N: length 9.2
  TOP w0.127: R408.2 189.74,74.77 188.93,74.77 188.8,74.9 v2(188.8,75.33)
  BOTTOM w0.127: R1057.1 186.99,71.66 187.77,71.66 188.07,71.96 188.07,72.8 188.41,73.15 189.51,73.15 189.87,73.52 189.87,74.48 189.59,74.76 188.93,74.76 188.8,74.89 v2(188.8,75.33)
VDD_MCU_RAM_0V85_P: length 8.2
  TOP w0.127: R412.2 189.75,74.46 188.93,74.46 188.8,74.34 v2(188.8,73.91)
  BOTTOM w0.127: R1057.4 186.89,71.98 187.65,71.98 187.79,72.12 187.79,72.92 188.3,73.43 189.37,73.43 189.62,73.68 189.62,74.38 189.49,74.51 188.93,74.51 188.8,74.37 v2(188.8,73.91)
VDD_MCU_WAKE1: length 3.2
  TOP w0.305: v2(113.12,74.63) 113.51,75.03 U59.J26
  BOTTOM w0.127: C1012.1 111.14,74.24 112.72,74.24 v2(113.12,74.63)
  vias: v2(83.06,70.67)
VDD_MCUIO_1V8: length 85
  TOP w0.254: U89.4 170.58,48.39 170.58,47.78 v3(171.39,46.98) ; v2(168.21,46.98) 168.46,47.23 168.46,47.55 169.08,48.17 U89.1 ; v3(170.37,46.98) 170.37,47.32 170.08,47.6 170.08,48.39 U89.3
  TOP w0.305: v2(116.32,73.03) 116.71,73.43 U59.G22 ; U59.H23 115.91,74.23 v2(115.52,73.83)
  TOP w0.381: v2(165.38,64.2) 164.95,63.77 TP159.1
  L3-SIGNAL1 w0.305: v3(171.39,46.98) v3(170.37,46.98) v2(168.21,46.98)
  L10-SIGNAL4 w0.127: v2(115.52,73.83) 115.52,73.83 115.93,74.24 115.93,76.39 116.16,76.62 123.68,76.62 123.93,76.37 123.93,72 122.59,70.66 122.59,69.42 122.94,69.06 122.94,66.75 128.71,60.99 129.26,60.99 134.77,55.47 139.81,55.47 147.76,47.52 167.67,47.52 v2(168.21,46.98)
  vias: v2(116.31,63.88) v2(165.38,64.81)
VDD_MCUIO_1V8_N: length 44.7
  TOP w0.127: v2(185.22,38.5) 185.83,38.5 185.96,38.37 R579.2
  L7-SIGNAL3 w0.109: v2(167.25,65.59) 167.06,65.79 165.76,65.79 163.7,63.73 163.7,55.54 166.78,52.46 166.78,50.53 172.46,44.86 177.32,44.86 184.34,37.84 185.11,37.84 185.22,37.94 v2(185.22,38.5)
VDD_MCUIO_1V8_P: length 45.4
  TOP w0.127: R583.2 185.99,37.23 185.85,37.09 v2(185.22,37.09)
  L7-SIGNAL3 w0.109: v2(185.22,37.09) 185.22,37.49 185.11,37.6 184.24,37.6 177.26,44.58 172.29,44.58 166.48,50.39 166.48,52.44 163.47,55.45 163.47,63.83 165.66,66.02 166.92,66.02 v2(167.25,66.35)
VDD_MCUIO_1V8_REG: length 1
  TOP w0.305: 171.07,71.32 U68.13
VDD_MCUIO_3V3: length 17.7
  TOP w0.254: v2(76.89,67.22) 76.89,66.29 77.21,65.98 77.86,65.98 U279.1 ; v2(165.27,67.59) 165.07,67.59 TP151.1 165.07,66.98 v2(165.27,66.98)
  TOP w0.305: v2(114.72,73.03) 115.11,73.43 U59.G24 ; v2(113.92,73.83) 114.31,74.23 U59.H25
  L10-SIGNAL4 w0.508: v2(86.9,63.75) 86.67,63.75 84.34,66.08 84.34,67.15 83.64,67.85 81.31,67.85 79.86,66.41 77.7,66.41 v2(76.89,67.22)
  vias: v2(110.63,59.72) v2(174.8,49.56) v10(110.65,59.72) v11(110.65,59.72)
VDD_MCUIO_3V3_N: length 48.5
  TOP w0.127: v2(185.22,34.31) 185.82,34.31 185.96,34.18 R592.2
  L7-SIGNAL3 w0.109: v2(165.78,63.19) 164.79,63.19 163.94,62.34 163.94,55.8 168.5,51.24 170.48,51.24 176.25,45.47 179.14,45.47 186.14,38.47 186.14,34.21 185.74,33.81 185.33,33.81 185.22,33.92 v2(185.22,34.31)
  BOTTOM w0.127: R1096.1 166,65.96 166,63.41 v2(165.78,63.19)
VDD_MCUIO_3V3_P: length 49.4
  TOP w0.127: v2(185.22,32.9) 185.79,32.9 185.93,33.04 R601.2
  L7-SIGNAL3 w0.109: v2(185.22,32.9) 185.22,33.45 185.34,33.58 185.9,33.58 186.37,34.06 186.37,38.57 186.24,38.71 179.23,45.71 176.37,45.71 170.6,51.48 168.62,51.48 164.18,55.92 164.18,62.21 164.68,62.72 166.01,62.72 v2(166.5,63.21)
  BOTTOM w0.127: v2(166.5,63.21) 166.3,63.41 166.3,65.98 R1096.4
VDD_MCUIO_3V3_REG: length 1.8
  TOP w0.305: U68.11 170.64,72.32 v4(170.36,72.04)
VDD_MMC1: length 3.3
  BOTTOM w0.381: C721.1 v2(24.1,116.54) ; C721.1 v2(24.1,115.06) ; C721.1 J53.4
  vias: v2(28.85,117.48) v2(28.85,116.72)
VDD_PHYCORE_0V8: length 6.8
  BOTTOM w0.254: FL66.1 v4(126.04,114.88)
  BOTTOM w0.305: FL94.1 v2(149.04,104.04)
  BOTTOM w0.381: FL83.1 v2(135.57,109.61) ; FL89.1 110.32,108.43 110.27,108.48 v4(109.79,108.48) ; FL86.2 v2(121.34,109.61) ; FL84.1 v2(128.46,109.61) ; FL87.1 v2(117.79,109.61)
  vias: v2(105.85,114.98) v2(105.85,114.07) v2(105.85,113.15) v2(111.72,113.75) v2(152.5,103.91)
VDD_PHYCORE_0V8_IN+: length 4.8
  BOTTOM w0.127: R929.1 91.54,116.25 91.43,116.36 C720.2 90.39,116.36 90.18,116.57 U199.10 88.22,116.57 U198.D3
VDD_PHYCORE_0V8_IN-: length 6.3
  BOTTOM w0.127: 87.82,117.77 88.03,117.77 88.23,117.57 U199.8 90.1,117.57 90.39,117.28 ; 87.82,117.77 U198.D1 ; 87.82,117.77 U198.D2 ; 90.39,117.28 90.18,117.07 U199.9 ; 90.39,117.28 C720.1 91.47,117.28 91.58,117.39 R925.1
VDD_PHYCORE_0V8_N: length 8
  TOP w0.127: v2(97.75,114.08) 97.67,114.15 R226.1
  BOTTOM w0.127: 94.26,117.19 94.26,117.16 94.39,117.03 95.28,117.03 96.66,115.65 96.66,115.17 v2(97.75,114.08) ; 94.26,117.19 TP280.1 ; 94.26,117.19 94.04,116.97 93.33,116.97 R925.2
VDD_PHYCORE_0V8_P: length 7.4
  TOP w0.127: R226.4 v2(96.11,113.52)
  BOTTOM w0.127: v2(96.11,113.52) 96.35,113.76 96.35,115.58 95.21,116.72 94.39,116.72 94.26,116.58 94.26,116.55 ; 94.26,116.55 94.08,116.73 93.4,116.73 R929.2 ; 94.26,116.55 TP283.1
VDD_PMIC_BUCK_SW5: length 1.6
  TOP w0.229: 181.67,73.32 U68.34
VDD_RAM_0V85: length 166.8
  TOP w0.254: v2(176.82,78.93) 176.59,78.93 176.33,78.68 U68.49
  L8-PWR1 w0.152: v4(91.44,73.31) 92.41,72.34 95.21,72.34 95.44,72.11 95.44,70.7 97.44,68.69 97.44,67.92 96.17,66.64 96.17,65.24 95.18,64.26 95.18,39.78 97.04,37.92 114.49,37.92 115.49,36.91 164.36,36.91 175.63,48.19 176.54,48.19 177.78,49.44 177.78,51.06 178.61,51.88 179.26,51.88 179.38,52 183.7,56.32 183.7,56.34 183.83,56.46 183.83,76.69 183.42,77.11 180.38,77.11 179.33,78.16 177.6,78.16 v2(176.82,78.93)
  vias: v4(89.57,73.33) v4(90.17,73.31) v4(90.25,70.94) v4(90.8,73.31) v4(184.74,84.84) v4(184.74,83.88) v4(184.74,82.91) v4(185.71,84.84) v4(185.71,83.88) v4(185.71,82.91)
VDD_RAM_0V85_N: length 27
  L3-SIGNAL1 w0.089: v2(197.84,92.81) 197.37,92.81 197.21,92.97 197.21,93.47 196.9,93.78 194.86,93.78 190.97,89.9 190.28,89.9 188.65,88.26 188.65,87.57 186.65,85.57 186.65,82.48 186.32,82.15 184.21,82.15 183.79,82.57 183.79,85.22 v3(184.04,85.46)
  BOTTOM w0.127: R968.2 197.29,93.76 197.29,92.94 197.42,92.81 v2(197.84,92.81)
VDD_RAM_0V85_P: length 26.9
  L3-SIGNAL1 w0.089: v2(196.43,92.81) 196.83,92.81 196.99,92.97 196.99,93.38 196.81,93.56 194.95,93.56 191.02,89.62 190.33,89.62 188.93,88.22 188.93,87.54 186.88,85.48 186.88,82.39 186.41,81.92 184.11,81.92 183.56,82.48 183.56,85.22 v3(183.31,85.46)
  BOTTOM w0.127: v2(196.43,92.81) 196.86,92.81 196.99,92.94 196.99,93.75 R969.2
VDD_RAM_0V85_REG:
  vias: v4(180.17,85.38) v4(180.17,84.23) v4(180.17,83.09) v4(181.06,85.38) v4(181.06,84.23) v4(181.06,83.09)
VDD_SD_DV: length 8.7
  TOP w0.254: TP65.1 v2(28.44,112.71)
  TOP w0.305: v2(112.32,77.83) 112.71,78.23 U59.N27
  L8-PWR1 w0.203: 37.96,113.01 38.01,113.01 v2(38.24,112.78)
  BOTTOM w0.127: v2(112.32,77.83) 111.92,78.23 111.05,78.23 C966.1
  BOTTOM w0.254: v2(27.22,119.06) 27.81,119.06 28.06,119.31 28.06,119.97 R916.1 ; R937.1 v2(28.44,112.71) R936.1 28.44,113.82 R934.1
  vias: v2(38.24,112) v2(76.72,86.11) v2(77.53,86.08) v2(100.19,77.11) v2(101.87,77.12)
VDD_SD_DV_1V8: length 1.8
  TOP w0.305: R324.1 75.88,91.24 U53.5
VDD_SD_DV_3V3: length 2
  TOP w0.305: U53.6 74.82,91.74 75.37,92.29 R318.1
VDD_SD_DV_IN+: length 4.8
  BOTTOM w0.127: R977.1 68.62,93.01 68.51,93.12 C812.2 67.48,93.12 67.27,93.33 U215.10 65.3,93.33 U214.D3
VDD_SD_DV_IN-: length 6.3
  BOTTOM w0.127: R975.1 68.66,94.15 68.55,94.04 C812.1 67.48,94.04 ; 67.48,94.04 67.19,94.33 U215.8 65.32,94.33 65.12,94.53 64.9,94.53 ; 67.48,94.04 67.27,93.83 U215.9 ; U214.D1 64.9,94.53 ; 64.9,94.53 U214.D2
VDD_SD_DV_N: length 13.6
  L7-SIGNAL3 w0.109: v2(76.06,86.79) 76.49,87.23 76.49,91.89 74.51,93.87 71.47,93.87 71.36,93.98 v2(71.36,94.28)
  BOTTOM w0.127: v2(71.36,94.28) 71.36,93.86 71.24,93.73 70.42,93.73 R975.2
VDD_SD_DV_P: length 12.6
  L7-SIGNAL3 w0.109: v2(71.36,92.87) 71.36,93.48 71.52,93.64 74.35,93.64 76.16,91.83 76.16,87.61 v2(76.06,87.51)
  BOTTOM w0.127: v2(71.36,92.87) 71.36,93.3 71.24,93.43 70.42,93.43 R977.2
VDD_TUSB321: length 53.3
  TOP w0.254: v2(160.21,181.17) 159.9,180.87 R8.2
  L5-SIGNAL2 w0.508: v2(182.16,179.13) 183.22,179.13 185.26,181.17 v2(185.26,182.91) 185.26,184.75 183.42,186.6 v2(182.7,186.6) 182.69,186.61 182.69,187.41 181.35,188.74 169.59,188.74 v2(167.7,186.85)
  L7-SIGNAL3 w0.381: v2(167.7,186.85) 165.89,186.85 v2(160.21,181.17)
  BOTTOM w0.254: R753.1 181.99,180.04 R744.1 ; U158.12 180.27,184.48 179.84,184.9 C548.2 179.36,185.43 179.64,185.71 179.64,186.57 178.12,188.1 176.34,188.1
  BOTTOM w0.381: U166.2 185.6,178.12 184.84,178.87 182.42,178.87 v2(182.16,179.13) R753.1
VDD_WAKE0: length 30.1
  TOP w0.305: v2(112.32,79.43) 112.71,79.83 U59.R27
  L12-SIGNAL5 w0.152: 111.26,79.02 111.28,79.03 111.92,79.03 v2(112.32,79.43)
  L12-SIGNAL5 w0.254: 93.16,73.78 97.09,73.78 98.8,75.48 103.18,75.48 103.64,75.95 108.26,75.95 109.18,76.86 109.18,77.09 109.56,77.47 109.99,77.47 110.26,77.75 110.26,78.02 110.53,78.28 110.8,78.28 111.06,78.55 111.06,78.82 111.26,79.02
  L12-SIGNAL5 w0.305: 90.2,73.87 86.27,73.87 85.56,74.58 v2(85.15,74.58)
  BOTTOM w0.381: v2(85.15,74.58) 84.72,75.01 R1045.2 R1051.2
VDDA_LM5140: length 5
  TOP w0.254: C221.2 v2(212.23,104.54) U46.36 ; U46.28 v2(214.81,108.67) ; U46.33 212.47,106.04 v2(212.23,105.8) 212.49,105.54 U46.34 ; U46.3 v2(214.81,100.96)
VDDA_LM5141: length 6.9
  TOP w0.254: U81.2 206.01,54.56 v2(205.51,54.06) U81.1 ; U81.5 v2(207.51,54.97)
  L14-SIGNAL6 w0.305: v2(205.51,54.06) 206.6,54.06 v2(207.51,54.97)
VDDA_LM5143: length 12.9
  TOP w0.254: 207.58,149.33 207.31,149.6 U25.34 ; 207.58,149.33 208.01,149.33 208.26,149.59 v2(208.26,150.38) 207.91,150.38 207.68,150.6 U25.36 ; 207.58,149.33 207.34,149.1 U25.33
  L3-SIGNAL1 w0.305: v2(208.26,150.38) 208.26,144.99 207.3,144.03 206.38,144.03 v2(206.3,144.1)
VDDAR_CORE_0V85: length 83.7
  TOP w0.254: R556.1 78.55,43.43 TP191.1
  TOP w0.305: U59.AD19 119.12,87.04 v2(118.72,87.43) ; v2(113.12,88.23) 113.52,87.84 U59.AE26 ; U59.AA22 116.72,84.64 v2(116.32,85.03) ; v2(113.92,84.23) 114.32,83.84 U59.Y25 ; v2(121.92,87.43) 121.52,87.03 U59.AD16 ; U59.AD13 123.92,87.03 v2(124.32,87.43) ; v2(127.52,88.23) 127.12,87.83 U59.AE9 ; U59.P23 115.91,79.03 v2(115.52,78.63)
  L10-SIGNAL4 w0.127: v2(124.32,87.43) 124.7,87.82 127.1,87.82 v2(127.52,88.23)
  L14-SIGNAL6 w0.127: TP191.1 80.08,44.15 80.08,45.13 80.61,45.67 86.75,45.67 88.5,47.42 88.5,66.05 86.76,67.79 86.76,71.62 88.14,73 88.14,73.48 89.89,75.24 90.71,75.24 91.37,75.9 91.37,77.22 92.35,78.19 92.35,82.97 93.14,83.76 101.19,83.76 102.09,84.66 108.94,84.66 108.96,84.65 113.5,84.65 v2(113.92,84.23)
  vias: v2(100.91,79.53) v2(101.91,79.53)
VDDAR_CPU_0V85: length 91.6
  TOP w0.254: TP99.1 194.72,86.8 R323.1
  TOP w0.305: U59.AA18 119.92,84.64 v2(119.52,85.03) ; U59.AC10 126.32,86.23 v2(126.72,86.63) ; U59.U12 124.72,81.43 v2(125.12,81.03) ; v2(124.32,78.63) 123.92,79.03 U59.P13 ; U59.V9 127.12,82.23 v2(127.52,82.63) ; U59.AA14 123.12,84.63 v2(123.52,85.03) ; v2(117.12,76.23) 117.51,76.63 U59.L21 ; v2(118.72,75.43) 119.11,75.83 U59.K19 ; U59.AA16 v2(121.92,85.03) ; v2(125.92,84.23) 125.52,83.83 U59.Y11 ; v2(119.52,79.43) 119.91,79.83 U59.R18 ; v2(118.72,81.03) 119.11,81.43 U59.U19 ; v2(120.32,82.63) 120.72,82.24 U59.V17
  L10-SIGNAL4 w0.127: TP99.1 192.71,88.81 189.52,88.81 188.98,88.27 187,88.27 186.01,89.26 186.01,91.09 184.1,93 177.63,93 176.31,91.69 176.31,82.92 175.52,82.13 173.31,82.13 172.07,80.89 166.05,80.89 165.51,81.43 164.65,81.43 163.91,80.7 131.71,80.7 130.97,81.43 128.72,81.43 v2(127.52,82.63)
  vias: v2(98.49,72.04) v2(99.49,72.04) v10(93.65,72.3) v10(93.65,71.79) v10(96.87,72.42) v10(96.87,71.66) v10(101.87,72.68) v10(118.7,82.04) v10(120.35,81.56) v10(121.93,83.95) v10(123.53,83.95) v11(93.65,72.3) v11(93.65,71.79) v11(96.87,72.42) v11(96.87,71.66) v11(101.87,72.68) v11(118.7,82.04) v11(120.35,81.56) v11(121.93,83.95) v11(123.53,83.95)
VDDAR_MCU_0V85: length 1.1
  TOP w0.305: U59.L22 116.71,76.63 v2(116.32,76.23) ; U59.K25 114.31,75.83 v2(113.93,75.45)
  vias: v2(96.87,73.18) v2(96.91,70.9) v2(101.87,71.53)
VDDC_1V2_XDS: length 17.9
  TOP w0.254: C17.1 20.09,177.38 v2(19.46,176.76) 19.46,176.85 C16.1
  L3-SIGNAL1 w0.305: v2(19.46,176.76) 20.02,176.2 20.02,172.73 20.77,171.98 22.55,171.98 25.56,168.97 v2(26.75,168.97)
  BOTTOM w0.203: U170.87 19.66,176.96 v2(19.46,176.76)
  BOTTOM w0.254: v2(26.75,168.97) 26.3,168.97 26.01,169.26 U170.115
VDDI_UFS: length 4.5
  TOP w0.203: U26.A9 141.64,150.82
  TOP w0.254: C107.1 138.2,150.82 141.64,150.82
VDDIM: length 3.7
  TOP w0.102: 172.69,95 v2(172.94,94.75) 173.19,95 173.19,95.56 U52.C2 172.69,95.56 172.69,95
  BOTTOM w0.254: C807.1 v2(172.94,94.75) C808.1
VDDIQ2_UFS: length 4.5
  TOP w0.203: 141.64,150.32 U26.A8
  TOP w0.254: 141.64,150.32 138.25,150.32 C113.1
VDDIQ_UFS: length 4.4
  TOP w0.203: U26.A3 141.64,147.82
  TOP w0.254: 141.64,147.82 C119.1
VDDOUT_1V8_CDCEL: length 32.5
  TOP w0.254: U23.13 97.06,152.84 97.47,152.43 C105.1 97.77,152.01 98.02,151.75 v2(100.64,151.75)
  TOP w0.381: U23.10 88.78,151.54 88.4,151.16 C110.1 C109.1 86.98,151.16 86.43,151.71 v2(85.51,151.71) 85.51,153.07 86.97,154.52 C96.1 C97.1 88.71,154.14 U23.6
  L5-SIGNAL2 w0.305: v2(100.64,151.75) 97.98,151.75 97.62,151.39 85.83,151.39 v2(85.51,151.71)
VDDSHV0_MCU: length 1.4
  TOP w0.305: v2(112.32,73.83) 112.71,74.23 U59.H27
  BOTTOM w0.127: C1067.1 v2(97.39,64.32)
  vias: v2(86.88,65.56)
VDDSHV2_DV: length 1.1
  TOP w0.305: v2(111.52,77.83) 111.91,78.23 U59.N28 ; v2(111.52,78.63) 111.91,79.03 U59.P28
  vias: v2(87.55,70.67) v2(104.68,79.61)
VIN_MON_PORZ: length 3.6
  TOP w0.127: v2(159.15,34.45) 158.13,34.45 157.92,34.24 R600.1
  BOTTOM w0.127: v2(159.15,34.45) 159.94,33.66 U255.1
VINPUT: length 152.6
  TOP w0.254: U25.25 203.49,147.33 203.49,146.21 203.31,146.03 v2(203.31,145.68) ; U81.15 207.01,60.89 207.47,61.35 v2(207.47,61.42) ; v2(216.31,109.99) U46.25
  L3-SIGNAL1 w0.305: v2(214.76,66.05) 214.76,64.54 217.22,62.09 217.22,54.2 223,48.41 223,42.62 219.53,39.15 214.48,39.15 212.61,37.27 203.54,37.27 194.83,28.56 176.06,28.56 175.41,27.91 163.69,27.91 162.18,29.42 161.41,29.42 159.42,27.43 v2(158.47,27.43)
  L12-SIGNAL5 w0.381: v2(191.49,189.04) 187.38,184.94 187.38,167.01 190.58,163.81 190.58,158.1 186.9,154.41 v2(183.8,154.41) v2(182.38,154.41)
  BOTTOM w0.254: v2(209.86,146.4) 210.84,146.4 211.13,146.11 R829.1 ; U237.5 213.8,65.09 v2(214.76,66.05)
  vias: v2(182.38,153.4) v2(182.38,152.38) v2(182.38,151.37) v2(182.38,149.33) v2(182.38,148.32) v2(182.38,147.3) v2(182.38,146.29) v2(183.8,153.4) v2(183.8,152.38) v2(183.8,151.37) v2(183.8,149.33) v2(183.8,148.32) v2(183.8,147.3) v2(183.8,146.29) v2(197.5,152.84) v2(197.5,151.83) v2(197.5,148.87) v2(197.5,147.86) v2(198.51,152.84) v2(198.51,147.86) v2(208.09,153.92) v2(209.14,147.18) v2(209.1,72.42) v2(209.1,71.41) v2(209.2,149.46) v2(210.12,72.42) v2(210.12,71.41) v2(211.13,72.42) v2(211.13,71.41) v2(212.15,72.42) v2(212.15,71.41) v2(222.13,103.28) v2(237.4,108.55) v2(237.4,107.53) v2(237.4,106.51) v2(237.4,105.5) v2(237.4,103.76) v2(237.4,102.75) v2(237.4,101.73) v2(237.4,100.71) v2(238.92,108.55) v2(238.92,107.53) v2(238.92,106.51) v2(238.92,105.5) v2(238.92,103.76) v2(238.92,102.75) v2(238.92,101.73) v2(238.92,100.71) v12(224.09,135.16) v12(224.09,133.38) v12(224.09,131.6) v12(224.09,129.83) v12(225.87,135.16) v12(225.87,133.38) v12(225.87,131.6) v12(225.87,129.83) v12(227.64,135.16) v12(227.64,133.38) v12(227.64,131.6) v12(227.64,129.83) v12(229.42,131.6) v12(229.42,129.83)
VINT_PMIC_1V8: length 6.6
  TOP w0.254: TP308.1 167.6,78.2 168.35,78.96 170.09,78.96 170.36,78.69 C267.1 170.36,78.11 171.64,76.82 U68.2
2P_FTDI_RXR_OE#: length 134.3
  L3-SIGNAL1 w0.089: v2(58.78,28.88) 62.28,32.38 91.63,32.38 93,33.76 103.18,33.76 110.65,26.29 134.4,26.29 135.67,27.56 137.3,27.56 143.21,27.56 144.99,25.78 169.81,25.78 170.29,26.27 v2(183.57,26.27)
  BOTTOM w0.127: U259.15 v2(183.57,26.27) ; U257.4 v2(58.78,28.88)
AMUXOUT_A: length 5.6
  TOP w0.127: TP130.1 167.9,79.27 170.45,79.27 171.03,78.69 171.03,77.89 171.6,77.32 U68.1
AOUT1_A: length 5.6
  BOTTOM w0.381: R1276.1 26.53,15.11 26.76,15.35 R1272.2 27.27,14.81 27.38,14.7 C1242.1 27.42,14.13 R1279.1 27.42,12.56 27.55,12.43 27.55,11.63 R1283.1
AOUT1_B: length 5.6
  BOTTOM w0.381: R1282.1 28.14,11.63 28.14,12.44 28.26,12.57 R1279.2 28.3,13.06 C1242.2 28.3,14.73 28.41,14.84 R1271.2 28.95,15.35 29.18,15.11 R1275.1
AOUT1_C: length 3.1
  BOTTOM w0.381: U267.6 27.22,16.84 27.27,16.79 R1272.1 27.27,16.19 26.72,16.19 26.65,16.26 C1234.2
AOUT1_D: length 3.1
  BOTTOM w0.381: C1233.1 29.16,16.26 29.09,16.19 28.41,16.19 R1271.1 28.41,16.89 28.49,16.96 U267.5
AOUT1_E: length 3.5
  BOTTOM w0.381: C1233.2 30.53,15.63 30.49,15.59 R1275.2 R1274.1 R1273.2
AOUT1_N: length 31.9
  TOP w0.254: U154.32 50.49,5.52 50.49,4.57 51.18,3.88 51.18,3.33 v2(51.31,3.2)
  BOTTOM w0.254: C1263.2 26.9,6.24 27.61,5.52 27.61,3.56 29.88,1.29 50.6,1.29 51.18,1.87 51.18,3.08 v2(51.31,3.2)
AOUT1_O: length 10.8
  BOTTOM w0.381: C1229.1 20.83,19.09 22.17,20.43 24.61,20.43 25.95,19.08 U267.7 25.95,17.5 25.16,16.71 C1234.1 25.16,15.15 R1276.2
AOUT1_P: length 30.4
  TOP w0.254: U154.31 50.04,5.52 50.04,4.38 50.72,3.69 50.72,3.33 v2(50.59,3.2)
  BOTTOM w0.254: v2(50.59,3.2) 50.72,3.08 50.72,2.06 50.41,1.75 30.07,1.75 28.07,3.75 28.07,5.49 28.82,6.24 C1262.2
AOUT1N: length 3
  BOTTOM w0.381: R1283.2 27.55,10.23 27.55,8.73 26.86,8.04 C1263.1
AOUT1P: length 3
  BOTTOM w0.381: R1282.2 28.14,10.23 28.14,8.65 28.75,8.04 C1262.1
AOUT2_A: length 8
  BOTTOM w0.381: R1237.1 25.43,26.31 25.59,26.14 R1239.2 26.08,26.64 26.19,26.75 C1193.1 26.23,27.37 R1226.1 26.23,28.96 26.36,29.09 26.36,29.76 27.09,30.48 28.81,30.48 R1219.1
AOUT2_B: length 7.4
  BOTTOM w0.381: R1236.1 28.13,26.38 27.9,26.14 R1238.2 27.22,26.68 27.11,26.79 C1193.2 27.07,27.37 R1226.2 27.07,28.95 26.94,29.08 26.94,29.51 27.33,29.9 28.81,29.9 R1222.1
AOUT2_C: length 3.1
  BOTTOM w0.381: C1202.2 25.48,25.16 25.61,25.3 R1239.1 26.08,24.69 25.95,24.56 U267.2
AOUT2_D: length 3.3
  BOTTOM w0.381: C1201.1 28.02,25.23 27.95,25.3 R1238.1 U267.3
AOUT2_E: length 3.5
  BOTTOM w0.381: C1201.2 29.53,26.34 R1236.2 R1230.2 R1229.1
AOUT2_N: length 38
  TOP w0.254: U154.30 49.49,5.52 49.49,3.33 v2(49.62,3.2)
  BOTTOM w0.254: C1194.2 35.77,25.71 35.05,24.99 35.05,7.23 37.6,4.68 48.97,4.68 49.49,4.16 49.49,3.33 v2(49.62,3.2)
AOUT2_O: length 10.7
  BOTTOM w0.381: R1237.2 24.09,26.27 C1202.1 24.09,24.49 24.68,23.9 U267.1 24.68,22.35 25.13,21.9 25.13,21.28 24.86,21.01 22.17,21.01 20.83,22.35 C1215.1
AOUT2_P: length 38
  TOP w0.254: U154.29 49.04,5.52 49.04,3.33 v2(48.91,3.2)
  BOTTOM w0.254: C1195.2 33.87,25.71 34.59,24.99 34.59,7.04 37.41,4.22 48.78,4.22 49.04,3.97 49.04,3.33 v2(48.91,3.2)
AOUT2N: length 8.1
  BOTTOM w0.381: R1219.2 30.21,30.48 34.06,30.48 35.11,29.43 35.11,28.12 35.73,27.51 C1194.1
AOUT2P: length 7.1
  BOTTOM w0.381: C1195.1 33.84,27.51 34.53,28.2 34.53,29.19 33.82,29.9 30.21,29.9 R1222.2
ATEST0: length 43.8
  TOP w0.127: TP149.1 71.56,66.32 71.91,66.67 72.17,66.67 73.22,67.72 v2(73.67,67.72)
  L3-SIGNAL1 w0.089: v3(110.32,77.43) v5(110.17,77.11)
  L4-GND2 w0.102: v5(110.17,77.11) v7(109.76,77.01)
  L7-SIGNAL3 w0.109: v7(109.76,77.01) 109.3,77.01 107.78,75.49 96.58,75.49 92.92,71.83 87.31,71.83 85.71,70.23 79.26,70.23 77.38,68.35 74.3,68.35 v2(73.67,67.72)
  vias: v1(110.32,77.43)
ATEST1: length 43.5
  TOP w0.127: v2(80.22,72.01) 80.22,71.59 80.12,71.49 TP144.1
  L3-SIGNAL1 w0.089: v3(111.12,75.03) v5(110.89,74.75)
  L4-GND2 w0.102: v5(110.89,74.75) v6(110.58,74.45)
  L5-SIGNAL2 w0.102: v6(110.58,74.45) 110.13,74.91 103.92,74.91 102.12,76.71 92.87,76.71 91.04,78.54 89.31,78.54 88.27,79.58 87.61,79.58 87.4,79.79 87.04,79.79 86.6,80.23 86.6,80.7 85.89,81.41 82.94,81.41 81.97,80.44 81.97,78.61 81.39,78.03 81.39,75.24 80.22,74.07 v2(80.22,72.01)
  vias: v1(111.12,75.03)
AUDIO_EXT_REFCLK1: length 28.8
  TOP w0.127: v2(52.96,34.92) 53.29,35.25 U112.5 ; v2(53.83,11.01) 53.83,11.29 53.63,11.49 U154.41
  L14-SIGNAL6 w0.089: v2(53.83,11.01) 51.86,12.97 51.86,20.45 51.42,20.9 51.42,33.38 v2(52.96,34.92)
AUDIO_EXT_REFCLK1/UART3_TXD: length 52.6
  TOP w0.127: v2(52.96,36.22) 53.29,36.55 U112.7 ; U58.46 43.56,82.23 v2(43.31,81.98)
  L12-SIGNAL5 w0.102: v2(52.96,36.22) 52.44,36.75 52.44,47.7 46.98,53.16 46.98,78.31 v2(43.31,81.98)
AUDIO_MUX1_OE#: length 4.3
  TOP w0.127: U112.15 49.9,33.3 50.12,33.08 R608.1 C406.2
AUDIO_MUX2_OE#: length 3.1
  TOP w0.127: C369.2 59.25,43.4 R560.1 58.85,41.8 U108.15
AUDIO_MUX_SEL: length 122.6
  TOP w0.127: U108.1 58.2,35.9 v2(58.53,36.23) ; v2(45.38,109.66) 44.88,110.16 U43.14 ; v2(53.93,31.31) R609.1 52.95,32.37 53.22,32.65 U112.1
  L7-SIGNAL3 w0.109: v2(53.93,31.31) 54.31,31.69 54.31,36.71 52.76,38.26 32.92,38.26 31.67,39.51 31.67,44.28 30.26,45.69 30.26,49.31 29.37,50.2 29.37,63.06 29.83,63.52 29.83,86.11 45.09,101.37 45.09,109.37 v2(45.38,109.66)
  L14-SIGNAL6 w0.089: v2(58.53,36.23) 58.1,35.8 55.52,35.8 55.51,35.8 55.14,35.8 53.93,34.59 v2(53.93,31.31)
BOARDID_EEPROM_A0: length 8.3
  TOP w0.127: U72.1 20.7,71.29 v2(21.59,72.18) 21.59,72.51 21.82,72.74 23.98,72.74 24.38,72.35 U73.1
  BOTTOM w0.127: R1056.2 R1055.1
BOARDID_EEPROM_A1: length 5.9
  TOP w0.127: v2(23.95,68.54) 23.29,68.54 23.11,68.71 U72.2 ; U73.2 23.73,69.9 v2(23.95,69.68)
  BOTTOM w0.127: v2(23.95,68.54) v2(23.95,69.68)
BOARDID_EEPROM_A2: length 5.9
  TOP w0.127: v2(22.92,69.68) 23.08,69.83 U73.3 ; U72.3 21.61,67.44 21.76,67.29 22.71,67.29 22.92,67.51 v2(22.92,67.87)
  BOTTOM w0.127: v2(22.92,69.68) R1088.2 v2(22.92,67.87)
BOARDID_EEPROM_WP: length 242
  TOP w0.127: U73.7 v2(23.73,66.93) 23.73,67.48 24.96,68.71 U72.7 ; SW2.9 v2(144,170.25)
  L3-SIGNAL1 w0.089: v2(133.5,156.43) 132.39,155.32 101.19,155.32 90.84,144.97 90.84,140.87 88.69,138.73 80.24,138.73 75.86,134.35 70.86,134.35 66.14,129.63 66.14,126.61 60.62,121.09 57.48,121.09 56.2,119.82 52.39,119.82 51.73,119.16 51.73,118.88 51.19,118.34 51.19,113.98 49.9,112.69 49.38,112.69 48.03,111.35 43.48,111.35 42.47,110.33 42.47,104.76 41.67,103.96 35.83,103.96 v2(34.86,104.94)
  L12-SIGNAL5 w0.102: v2(23.73,66.93) 27.89,66.93 31.27,70.31 31.27,77.75 33.18,79.66 33.18,102.17 34.86,103.85 v2(34.86,104.94)
  L14-SIGNAL6 w0.089: v2(32.66,42.13) 31.3,42.13 31.05,41.87 30.45,41.87 22.39,49.94 22.39,51.36 21.86,51.89 21.86,52.76 22.39,53.28 22.39,53.9 21.86,54.43 21.86,55.98 21.76,56.07 21.76,62.9 22.56,63.7 22.56,65.76 v2(23.73,66.93) ; v2(144,170.25) 143.57,170.68 133.97,170.68 133.07,169.77 133.07,156.85 v2(133.5,156.43)
  BOTTOM w0.127: J56.25 v2(32.66,42.13)
BOOT_EEPROM_A1: length 3
  BOTTOM w0.127: R1178.2 R1182.2 192.95,40.42 192.76,40.6 U250.2
BOOT_EEPROM_A2: length 3
  BOTTOM w0.127: U250.3 192.11,40.65 191.8,40.34 R1183.2 R1179.2
BOOT_EEPROM_WP: length 287.4
  L3-SIGNAL1 w0.089: v3(121.52,71.03) 121.52,70.81 121.02,70.31 121.02,57.21 110.7,46.89 109.2,46.89 108.9,47.19 107.47,47.19 100.4,54.27 95.37,54.27 95.03,53.92 93.28,53.92 v5(93.28,53.92)
  L4-GND2 w0.102: v6(92.95,53.95) 92.97,53.92 v5(93.28,53.92)
  L5-SIGNAL2 w0.102: v6(92.95,53.95) 92.95,54.18 81.36,65.76 72.17,65.76 70.39,67.54 62.44,67.54 60.94,69.04 57.92,69.04 57.48,69.48 56.41,69.48 55.81,70.08 54.47,70.08 v2(53.52,71.03) 49.1,66.6 49.1,60.72 49.1,60.72 49.1,59.34 47.8,58.04 47.8,42.73 53.48,37.05 63.31,37.05 66.23,34.14 85.18,34.14 85.87,33.45 94.13,33.45 96.8,36.11 116.26,36.11 116.98,36.84 131.51,36.84 132.74,38.07 173.68,38.07 185.09,49.47 v2(189.33,49.47)
  BOTTOM w0.127: U250.7 192.76,48.74 R1151.2 192.64,49.24 192.87,49.48 192.87,50.57 192.68,50.76 189.76,50.76 189.57,50.58 189.57,49.72 v2(189.33,49.47)
  vias: v1(121.52,71.03)
BOOTBUF_ADDR: length 2.9
  BOTTOM w0.127: R1132.2 57.36,58.55 57.21,58.7 U243.26
BOOTMODEON: length 73.5
  L7-SIGNAL3 w0.109: v2(55.58,69.45) 55.48,69.35 51.14,69.35 48.01,66.23 48.01,60.89 44.74,57.61 44.74,40.67 45.56,39.85 v2(45.61,39.85)
  L14-SIGNAL6 w0.089: v2(55.58,69.45) 56.17,68.87 56.17,58.98 55.56,58.38 55.56,54.35 59.19,50.72 v2(60.98,50.72) 60.21,49.95 60.21,46.54 60.78,45.97 v2(60.99,45.97)
  BOTTOM w0.127: U233.22 54.24,69.02 54.67,69.45 v2(55.58,69.45) ; U248.15 61.19,45.77 v2(60.99,45.97) 61.19,46.17 U248.14 ; U244.15 61.18,50.52 v2(60.98,50.72) 61.18,50.92 U244.14 ; v2(45.61,39.85) R1184.2
BOOTMODEON_IN1: length 53.4
  L3-SIGNAL1 w0.089: v2(48.56,42.98) 48.1,43.43 46.14,43.43 43.59,45.98 43.59,46.88 42.09,48.38 32.92,48.38 32.46,48.83 25.66,48.83 24.86,48.03 20.63,48.03 19.93,48.73 15.69,48.73 10.59,43.63 TP190.1
  BOTTOM w0.127: v2(48.56,42.98) 49.09,43.51 52.03,43.51 52.52,43.02 R1170.1 51.9,42.07 51.58,41.75 U253.1
BUF_1V8_BOOTMODE0: length 77.6
  L5-SIGNAL2 w0.102: v7(117.15,50.32) 117.15,49.91 116.44,49.2 108.96,49.2 108.71,49.45 107.53,49.45 106.41,50.57 78.18,50.57 73.08,55.68 63.22,55.68 61.7,54.16 61.7,47.49 v2(60.99,46.77)
  L7-SIGNAL3 w0.109: v2(125.63,50.39) 124.82,51.21 118.04,51.21 v7(117.15,50.32)
  BOTTOM w0.127: U248.13 61.19,46.57 v2(60.99,46.77)
BUF_1V8_BOOTMODE1: length 81.9
  L3-SIGNAL1 w0.089: v5(117.82,49.84) 119.31,51.33 121.09,51.33 122.26,50.16 122.26,48.99 123.12,48.13 125.54,48.13 126.37,48.97 126.37,50.17 v3(126.6,50.39)
  L4-GND2 w0.102: v5(117.82,49.84) v6(117.58,49.61)
  L5-SIGNAL2 w0.102: v2(63.35,46.77) 62.04,48.08 62.04,54.17 63.31,55.45 68.05,55.45 69.73,53.77 74.46,53.77 78.37,49.86 106.61,49.86 107.9,48.57 116.55,48.57 v6(117.58,49.61)
  BOTTOM w0.127: v2(63.35,46.77) 63.15,46.97 U248.12
BUF_1V8_BOOTMODE2: length 73.9
  L5-SIGNAL2 w0.102: v2(60.99,47.57) 61.43,48.01 61.43,54.21 63.13,55.91 73.18,55.91 77.25,51.84 97.8,51.84 98.51,51.13 107.35,51.13 108.06,51.84 113.5,51.84 115.73,49.61 v7(116.21,49.61)
  L7-SIGNAL3 w0.109: v7(116.21,49.61) 118.09,49.61 119.01,50.52 120,50.52 120.54,49.98 122.19,49.98 v2(122.6,50.39)
  BOTTOM w0.127: v2(60.99,47.57) 61.19,47.37 U248.11
BUF_1V8_BOOTMODE3: length 79.3
  TOP w0.127: R1114.2 v2(121,50.39)
  L5-SIGNAL2 w0.102: v7(115.77,50.28) 113.93,52.12 77.53,52.12 73.52,56.13 63.03,56.13 60.44,53.54 60.44,45.94 60.82,45.56 62.72,45.56 63.75,46.6 63.75,47.16 v2(63.35,47.57)
  L7-SIGNAL3 w0.109: v2(121,50.39) 120.59,50.8 118.78,50.8 117.86,49.89 116.92,49.89 116.53,50.28 v7(115.77,50.28)
  BOTTOM w0.127: U248.10 63.15,47.77 v2(63.35,47.57)
BUF_3V3_BOOTMODE4: length 1.9
  BOTTOM w0.127: U244.13 63.39,51.32 R1145.2
BUF_3V3_BOOTMODE5: length 1.7
  BOTTOM w0.127: R1142.2 63.87,51.72 U244.12
BUF_3V3_BOOTMODE6: length 2
  BOTTOM w0.127: R1138.2 63.88,52.69 63.31,52.12 U244.11
BUF_3V3_BOOTMODE7: length 2.4
  BOTTOM w0.127: U244.10 63.18,52.52 63.36,52.7 63.36,53.09 R1137.2
BUF_MCU_BOOTMODE2: length 5.4
  BOTTOM w0.127: U233.21 53.74,69.06 54.52,69.83 55.23,69.83 R1073.2 R1072.1 R1074.2
BUF_MCU_BOOTMODE3: length 2.5
  BOTTOM w0.127: R1065.2 53.24,69.2 U233.20
BUF_MCU_BOOTMODE4: length 2.4
  BOTTOM w0.127: R1066.2 52.74,69.59 U233.19
BUF_MCU_BOOTMODE5: length 2.2
  BOTTOM w0.127: R1067.2 52.24,69.98 U233.18
BUF_MCU_BOOTMODE6: length 2.1
  BOTTOM w0.127: U233.17 R1068.2
BUF_MCU_BOOTMODE7: length 2.2
  BOTTOM w0.127: R1069.2 51.24,69.98 U233.16
BUF_MCU_BOOTMODE8: length 2.4
  BOTTOM w0.127: R1070.2 50.74,69.59 U233.15
BUF_MCU_BOOTMODE9: length 2.5
  BOTTOM w0.127: R1071.2 50.24,69.2 U233.14
C_DP0_AUX_N: length 99.6
  TOP w0.094: C52.1 125.39,164.84 125.23,164.68 arc(125.17,164.59) 125.15,164.48 125.15,163.82 arc(125.17,163.73) 125.22,163.66 v3(125.39,163.49)
  L3-SIGNAL1 w0.079: v3(114.32,91.03) v5(114.04,91.26) ; v5(125.39,163.16) v3(125.39,163.49)
  L4-GND2 w0.089: v5(114.04,91.26) v7(113.73,91.57) ; v7(125.39,162.76) v5(125.39,163.16)
  L12-SIGNAL5 w0.089: v8(115.14,101.42) 114.95,101.61 arc(114.91,101.68) 114.89,101.76 114.89,115.53 arc(114.77,116.13) 114.44,116.64 114.2,116.87 arc(113.87,117.37) 113.75,117.96 113.75,126.95 arc(113.88,127.63) 114.27,128.21 115.2,129.14 arc(115.35,129.36) 115.4,129.62 115.4,129.96 arc(115.51,130.49) 115.81,130.94 122.49,137.62 arc(122.78,138.06) 122.88,138.57 122.88,144.14 arc(122.98,144.38) 123.21,144.47 123.77,144.47 arc(124.32,145.02) 123.77,145.57 123.21,145.57 arc(122.88,145.9) 123.21,146.23 123.77,146.23 arc(124.32,146.77) 123.77,147.32 123.21,147.32 arc(122.88,147.65) 123.21,147.98 123.77,147.98 arc(124.32,148.53) 123.77,149.07 123.21,149.07 arc(122.88,149.4) 123.21,149.73 123.77,149.73 arc(124.32,150.28) 123.77,150.82 123.21,150.82 arc(122.88,151.15) 123.21,151.48 123.77,151.48 arc(124.32,152.03) 123.77,152.58 123.21,152.58 arc(122.88,152.91) 123.21,153.24 123.77,153.24 arc(124.32,153.78) 123.77,154.33 123.21,154.33 arc(122.88,154.66) 123.21,154.99 123.77,154.99 arc(124.32,155.54) 123.77,156.08 123.21,156.08 arc(122.98,156.18) 122.88,156.41 122.88,157.29 arc(123.1,158.42) 123.74,159.37 123.8,159.43 124.8,160.43 arc(125.04,160.78) 125.12,161.21 125.12,162.39 arc(125.14,162.48) 125.19,162.56 v7(125.39,162.76)
  L13-GND5 w0.089: v8(115.14,101.42) 114.93,101.64 v9(114.85,101.71) ; v7(113.73,91.57) 113.52,91.78 v9(113.44,91.85)
  L14-SIGNAL6 w0.079: v9(114.85,101.71) 114.74,101.6 arc(114.65,101.46) 114.61,101.3 114.61,99.89 arc(114.68,99.57) 114.86,99.3 115.97,98.19 arc(116.2,97.84) 116.28,97.43 116.28,91.9 arc(115.95,91.1) 115.15,90.76 114.22,90.76 arc(113.86,90.91) 113.72,91.26 113.72,91.51 arc(113.71,91.57) 113.67,91.62 v9(113.44,91.85)
  vias: v1(114.31,91.03)
C_DP0_AUX_P: length 99.5
  TOP w0.094: v3(124.63,163.49) 124.81,163.66 arc(124.86,163.73) 124.87,163.82 124.87,164.48 arc(124.85,164.59) 124.79,164.68 124.63,164.84 C51.1
  L3-SIGNAL1 w0.079: v3(115.12,91.03) v5(114.84,91.26) ; v5(124.63,163.16) v3(124.63,163.49)
  L4-GND2 w0.089: v7(124.63,162.76) v5(124.63,163.16) ; v5(114.84,91.26) v7(114.53,91.57)
  L12-SIGNAL5 w0.089: v8(114.43,101.42) 114.62,101.61 arc(114.66,101.68) 114.68,101.76 114.68,115.53 arc(114.57,116.05) 114.28,116.48 114.05,116.72 arc(113.67,117.29) 113.53,117.96 113.53,126.95 arc(113.69,127.71) 114.12,128.36 115.05,129.29 arc(115.15,129.44) 115.18,129.62 115.18,129.96 arc(115.31,130.57) 115.65,131.09 122.33,137.77 arc(122.58,138.14) 122.66,138.57 122.66,144.14 arc(122.82,144.53) 123.21,144.69 123.77,144.69 arc(124.1,145.02) 123.77,145.35 123.21,145.35 arc(122.66,145.9) 123.21,146.44 123.77,146.44 arc(124.1,146.77) 123.77,147.1 123.21,147.1 arc(122.66,147.65) 123.21,148.2 123.77,148.2 arc(124.1,148.53) 123.77,148.86 123.21,148.86 arc(122.66,149.4) 123.21,149.95 123.77,149.95 arc(124.1,150.28) 123.77,150.61 123.21,150.61 arc(122.66,151.15) 123.21,151.7 123.77,151.7 arc(124.1,152.03) 123.77,152.36 123.21,152.36 arc(122.66,152.91) 123.21,153.45 123.77,153.45 arc(124.1,153.78) 123.77,154.11 123.21,154.11 arc(122.66,154.66) 123.21,155.21 123.77,155.21 arc(124.1,155.54) 123.77,155.87 123.21,155.87 arc(122.82,156.03) 122.66,156.41 122.66,157.29 arc(122.9,158.5) 123.59,159.52 124.65,160.58 arc(124.84,160.87) 124.91,161.21 124.91,162.39 arc(124.89,162.48) 124.83,162.56 v7(124.63,162.76)
  L13-GND5 w0.089: v9(114.24,91.85) 114.32,91.78 v7(114.53,91.57) ; v9(114.14,101.71) 114.21,101.64 v8(114.43,101.42)
  L14-SIGNAL6 w0.079: v9(114.14,101.71) 114.24,101.61 arc(114.34,101.46) 114.37,101.3 114.37,99.89 arc(114.45,99.48) 114.69,99.13 115.79,98.02 arc(115.97,97.75) 116.04,97.43 116.04,91.9 arc(115.78,91.27) 115.15,91.01 114.22,91.01 arc(114.04,91.08) 113.96,91.26 113.96,92.05 arc(114.1,92.19) 114.24,92.05 v9(114.24,91.85)
  vias: v1(115.11,91.03)
C_DP0_TX0_N: length 100.1
  TOP w0.094: v3(113.48,166.24) C45.1
  L3-SIGNAL1 w0.079: v3(117.52,91.03) v5(117.24,91.26) ; v3(113.48,166.24) v5(113.48,165.92)
  L4-GND2 w0.089: v5(117.24,91.26) v7(116.93,91.57) ; v5(113.48,165.92) v7(113.48,165.52)
  L12-SIGNAL5 w0.089: v7(116.93,91.57) 116.59,91.9 arc(116.51,92.03) 116.48,92.18 116.48,92.31 arc(116.53,92.57) 116.68,92.8 118.04,94.16 arc(118.33,94.59) 118.44,95.11 118.44,102.02 arc(118.52,102.47) 118.78,102.85 119.46,103.53 arc(119.6,103.73) 119.64,103.96 119.64,125.67 arc(119.77,126.34) 120.15,126.9 121.56,128.31 arc(121.85,128.74) 121.95,129.26 arc(122.09,129.97) 122.49,130.56 122.81,130.88 129.44,137.51 arc(130.15,138.56) 130.39,139.81 130.39,162.29 arc(130.17,163.39) 129.55,164.32 126.49,167.38 arc(125.62,167.96) 124.6,168.16 121.57,168.16 arc(120.77,168) 120.09,167.55 117.93,165.4 arc(117.34,165) 116.65,164.86 113.39,164.86 arc(113.26,164.92) 113.2,165.05 113.2,165.14 arc(113.22,165.24) 113.28,165.32 v7(113.48,165.52)
  vias: v1(117.51,91.03)
C_DP0_TX0_P: length 100.1
  TOP w0.094: C44.1 v3(112.71,166.24)
  L3-SIGNAL1 w0.079: v3(116.72,91.03) v5(116.44,91.26) ; v3(112.71,166.24) v5(112.71,165.92)
  L4-GND2 w0.089: v5(116.44,91.26) v7(116.13,91.57) ; v5(112.71,165.92) v7(112.71,165.52)
  L12-SIGNAL5 w0.089: v7(112.71,165.52) 112.81,165.52 arc(112.94,165.47) 112.99,165.34 112.99,165.05 arc(113.11,164.76) 113.39,164.65 116.65,164.65 arc(117.43,164.8) 118.09,165.24 120.24,167.39 arc(120.85,167.8) 121.57,167.95 124.6,167.95 arc(125.54,167.76) 126.34,167.23 129.4,164.16 arc(129.98,163.3) 130.18,162.29 130.18,139.81 arc(129.95,138.65) 129.29,137.66 122.66,131.03 122.34,130.71 arc(121.89,130.05) 121.74,129.26 arc(121.65,128.83) 121.41,128.46 120,127.05 arc(119.57,126.42) 119.43,125.67 119.43,103.96 arc(119.4,103.81) 119.31,103.68 118.63,103 arc(118.33,102.55) 118.22,102.02 118.22,95.11 arc(118.13,94.68) 117.89,94.31 116.53,92.95 arc(116.33,92.66) 116.26,92.31 116.26,91.89 arc(116.23,91.71) v7(116.13,91.57)
  vias: v1(116.71,91.03)
C_DP0_TX1_N: length 100
  TOP w0.094: v3(116.4,167.64) C38.1
  L3-SIGNAL1 w0.079: v3(116.4,167.64) v5(116.4,167.31) ; v3(119.92,93.43) v5(119.64,93.66)
  L4-GND2 w0.089: v5(116.4,167.31) v7(116.4,166.92) ; v5(119.64,93.66) v7(119.33,93.97)
  L12-SIGNAL5 w0.089: v7(119.33,93.97) 119.18,94.11 arc(119.08,94.27) 119.04,94.46 119.04,95.64 arc(119.12,96.06) 119.36,96.42 120.4,97.46 arc(120.78,98.02) 120.91,98.69 120.91,116.56 arc(121.01,116.8) 121.24,116.89 121.53,116.89 arc(122.08,117.44) 121.53,117.98 121.24,117.98 arc(121.01,118.08) 120.91,118.31 120.91,124.89 arc(121.03,125.49) 121.37,125.99 127.62,132.24 arc(127.78,132.63) 127.62,133.01 127.29,133.34 arc(127.19,133.57) 127.29,133.81 127.29,133.81 arc(127.52,133.9) 127.76,133.81 128.08,133.48 arc(128.47,133.32) 128.86,133.48 130.51,135.13 arc(131.33,136.36) 131.62,137.82 131.62,162.51 arc(131.36,163.81) 130.63,164.91 126.67,168.87 arc(125.95,169.35) 125.09,169.52 121.44,169.52 arc(120.62,169.36) 119.92,168.89 117.39,166.37 arc(117.17,166.22) 116.9,166.16 116.4,166.16 arc(116.2,166.24) 116.12,166.44 116.12,166.55 arc(116.14,166.64) 116.19,166.71 v7(116.4,166.92)
  vias: v1(119.91,93.43)
C_DP0_TX1_P: length 100
  TOP w0.094: C37.1 v3(115.64,167.64)
  L3-SIGNAL1 w0.079: v3(119.12,93.43) v5(118.84,93.66) ; v3(115.64,167.64) v5(115.64,167.31)
  L4-GND2 w0.089: v5(118.84,93.66) v7(118.53,93.97) ; v5(115.64,167.31) v7(115.64,166.92)
  L12-SIGNAL5 w0.089: v7(115.64,166.92) 115.84,166.71 arc(115.89,166.64) 115.91,166.55 115.91,166.44 arc(116.05,166.09) 116.4,165.95 116.9,165.95 arc(117.25,166.02) 117.55,166.22 120.07,168.74 arc(120.7,169.16) 121.44,169.31 125.09,169.31 arc(125.86,169.15) 126.52,168.71 130.47,164.76 arc(131.16,163.73) 131.41,162.51 131.41,137.82 arc(131.13,136.45) 130.36,135.29 128.7,133.63 arc(128.47,133.54) 128.24,133.63 127.91,133.96 arc(127.52,134.12) 127.14,133.96 arc(126.98,133.57) 127.14,133.19 127.46,132.86 arc(127.56,132.63) 127.46,132.39 121.22,126.15 arc(120.83,125.57) 120.7,124.89 120.7,118.31 arc(120.86,117.93) 121.24,117.77 121.53,117.77 arc(121.86,117.44) 121.53,117.11 121.24,117.11 arc(120.86,116.95) 120.7,116.56 120.7,98.69 arc(120.58,98.11) 120.25,97.61 119.21,96.57 arc(118.92,96.14) 118.82,95.64 118.82,94.46 arc(118.79,94.27) 118.68,94.11 v7(118.53,93.97)
  vias: v1(119.11,93.43)
C_DP0_TX2_N: length 100.2
  TOP w0.094: v3(119.34,165.17) 119.21,165.3 arc(119.13,165.42) 119.1,165.56 119.1,166.11 arc(119.12,166.22) 119.18,166.31 C47.1
  L3-SIGNAL1 w0.079: v3(119.34,165.17) v5(119.34,164.84) ; v3(118.32,94.23) v5(118.04,94.46)
  L4-GND2 w0.089: v5(119.34,164.84) v7(119.34,164.44) ; v5(118.04,94.46) v7(117.73,94.77)
  L12-SIGNAL5 w0.089: v7(119.34,164.44) 119.14,164.24 arc(119.09,164.16) 119.07,164.07 119.07,163.92 arc(119.12,163.79) 119.25,163.74 120.19,163.74 arc(120.51,163.87) 120.64,164.19 120.64,165.56 arc(120.98,166.37) 121.8,166.71 124.07,166.71 arc(124.99,166.53) 125.78,166 128.41,163.37 arc(128.99,162.5) 129.19,161.48 129.19,145.41 arc(129.03,145.02) 128.65,144.86 126.69,144.86 arc(126.36,144.53) 126.69,144.2 128.65,144.2 arc(129.07,144.03) 129.24,143.61 129.24,142.87 arc(129.07,142.45) 128.65,142.27 126.74,142.27 arc(126.41,141.94) 126.74,141.61 128.65,141.61 arc(129.03,141.45) 129.19,141.07 129.19,139.38 arc(129.08,138.83) 128.77,138.37 120.06,129.65 arc(119.94,129.47) 119.9,129.26 119.9,128.19 arc(119.85,127.96) 119.72,127.76 118.73,126.78 arc(118.56,126.52) 118.5,126.21 118.5,104.47 arc(118.43,104.12) 118.23,103.82 117.46,103.05 arc(117.22,102.7) 117.14,102.28 117.14,99.02 arc(117.15,98.95) 117.19,98.89 117.31,98.78 arc(117.41,98.63) 117.44,98.46 117.44,95.1 arc(117.45,95.06) 117.47,95.03 v7(117.73,94.77)
  vias: v1(118.31,94.23)
C_DP0_TX2_P: length 100.2
  TOP w0.094: C46.1 118.74,166.31 arc(118.8,166.22) 118.82,166.11 118.82,165.56 arc(118.8,165.42) 118.72,165.3 v3(118.58,165.17)
  L3-SIGNAL1 w0.079: v3(117.52,94.23) v5(117.24,94.46) ; v3(118.58,165.17) v5(118.58,164.84)
  L4-GND2 w0.089: v5(117.24,94.46) v7(116.93,94.77) ; v5(118.58,164.84) v7(118.58,164.44)
  L12-SIGNAL5 w0.089: v7(116.93,94.77) 117.2,95.03 arc(117.22,95.06) 117.22,95.1 117.22,98.46 arc(117.21,98.55) 117.16,98.62 117.04,98.74 arc(116.96,98.87) 116.92,99.02 116.92,102.28 arc(117.02,102.78) 117.31,103.2 118.08,103.98 arc(118.23,104.2) 118.28,104.47 118.28,126.21 arc(118.36,126.6) 118.58,126.93 119.57,127.92 arc(119.65,128.04) 119.68,128.19 119.68,129.26 arc(119.74,129.55) 119.9,129.8 128.62,138.52 arc(128.89,138.91) 128.98,139.38 128.98,141.07 arc(128.88,141.3) 128.65,141.4 126.74,141.4 arc(126.19,141.94) 126.74,142.49 128.65,142.49 arc(128.92,142.6) 129.03,142.87 129.03,143.61 arc(128.92,143.88) 128.65,143.99 126.69,143.99 arc(126.14,144.53) 126.69,145.08 128.65,145.08 arc(128.88,145.18) 128.98,145.41 128.98,161.48 arc(128.79,162.42) 128.26,163.22 125.63,165.85 arc(124.91,166.33) 124.07,166.49 121.8,166.49 arc(121.13,166.22) 120.86,165.56 120.86,164.19 arc(120.66,163.72) 120.19,163.52 119.25,163.52 arc(118.97,163.64) 118.85,163.92 118.85,164.07 arc(118.84,164.16) 118.79,164.24 v7(118.58,164.44)
  vias: v1(117.51,94.23)
