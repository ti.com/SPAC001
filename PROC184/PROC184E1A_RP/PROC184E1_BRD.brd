# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_MCU_OSPI0_DQS: length 37.3
  TOP w0.127: U241.11 v6(123.29,48.51)
  L3-SIGNAL1 w0.089: v3(126.32,70.23) v5(126.09,69.95) ; v5(123.29,48.84) v6(123.29,48.51)
  L4-GND2 w0.102: v5(123.29,48.84) v6(123.29,48.51) ; v5(126.09,69.95) v6(125.78,69.65)
  L5-SIGNAL2 w0.102: v6(123.29,48.51) 123.64,48.16 125.43,48.16 126.45,49.17 126.45,50.78 125.15,52.07 125.15,63.35 125.03,63.48 124.8,63.48 124.65,63.32 124.65,59.25 124.5,59.11 124.21,59.11 124.06,59.26 124.06,65.56 125.78,67.28 v6(125.78,69.65)
  vias: v1(126.32,70.23)
SOC_MDIO1_MDC_MUX: length 76
  TOP w0.127: v2(56.27,98.76) R282.1 55.93,98.81 55.81,98.7 R283.1
  L3-SIGNAL1 w0.089: v3(108.72,73.43) 108.41,73.13 104.68,73.13 101.44,69.89 98.55,69.89 96.58,71.86 94.83,71.86 94.34,72.35 94.34,74.33 90.47,78.19 v5(90.47,79.06)
  L4-GND2 w0.102: v5(90.47,79.06) v6(90.24,79.29)
  L5-SIGNAL2 w0.102: v6(90.24,79.29) 90.71,79.77 90.71,80.47 91.74,81.49 91.74,83.96 89.04,86.67 89.04,90.6 87.36,92.28 86.34,92.28 85.1,93.52 75.22,93.52 73.15,95.59 67.23,95.59 66.98,95.33 59.7,95.33 v2(56.27,98.76)
  vias: v1(108.72,73.43)
SOC_MDIO1_MDIO: length 75.3
  TOP w0.127: R1292.2 56.27,104.26 R263.1 ; R264.1 55.81,104.15 55.93,104.26 R263.1 ; R263.1 v2(56.27,104.21)
  L3-SIGNAL1 w0.089: v3(108.72,75.83) 108.41,75.53 107.42,75.53 106.99,75.11 103.77,75.11 101.95,73.29 99.44,73.29 98.69,74.04 98.69,74.76 93.37,80.07 v5(92.85,80.07)
  L4-GND2 w0.102: v5(92.85,80.07) v6(92.52,80.07)
  L5-SIGNAL2 w0.102: v2(56.27,104.21) 58.25,102.23 58.25,99.31 60.2,97.36 60.92,97.36 62,96.27 73.59,96.27 74.81,95.05 85.96,95.05 89.77,91.23 89.77,86.97 92.52,84.23 v6(92.52,80.07)
  vias: v1(108.72,75.83)
SOC_PORZ_OUT: length 499
  TOP w0.127: U107.1 75.87,40.28 v2(76.14,40.56) ; v2(64.21,162.26) 64.21,163.17 64.41,163.37 U11.18 ; U40.8 56.25,118.11 55.64,118.11 55.2,118.55 54.16,118.55 v2(53.73,118.98)
  L3-SIGNAL1 w0.089: v2(41.55,106.01) 41.12,106.44 41.12,114.65 41.55,115.08 41.97,115.08 42.47,115.58 42.47,118.84 v2(44.34,120.71) 45.07,121.44 46.46,121.44 v2(48.32,123.3)
  L5-SIGNAL2 w0.102: v2(44.34,120.71) 43.64,120.01 39.76,120.01 37.81,118.06 28.82,118.06 28.35,117.59 20.63,117.59 15.35,112.31 v2(15.35,105.86) ; v2(76.14,40.56) 75.04,39.46 57.26,39.46 56.32,38.51 v2(53.36,38.51) ; v2(64.21,162.26) 62.97,163.5 42.16,163.5 38.49,167.17 v2(33.88,167.17)
  L7-SIGNAL3 w0.109: v2(53.36,38.51) 52.95,38.51 51.83,39.63 46.69,39.63 45.55,38.5 33.02,38.5 31.91,39.61 31.91,60.17 v2(29.9,62.17) ; v2(85.05,35.69) 84.59,36.15 83.96,36.15 80.12,39.99 76.72,39.99 v2(76.14,40.56)
  L12-SIGNAL5 w0.102: v2(196.91,60.86) 195.89,60.86 194.6,59.56 190.99,59.56 189.64,58.22 189.64,56.41 185.76,52.53 185.76,44.22 179.66,38.12 179.66,37.23 177.15,34.71 177.15,26.52 169.66,19.02 144.89,19.02 143.87,18.01 140.17,18.01 139.96,18.21 134.3,18.21 133.56,18.95 114.69,18.95 111.41,22.23 109.73,22.23 109.24,22.72 104.52,22.72 102.17,25.07 96.27,25.07 94.46,26.89 93.76,26.89 91.65,28.99 91.65,30.33 88.78,33.2 88.78,35.61 88.25,36.14 85.5,36.14 v2(85.05,35.69) ; v2(17.33,145.52) 18.7,146.9 25.33,146.9 32.7,154.26 32.7,154.59 33.17,155.06 33.17,156.53 31.94,157.77 31.94,164.37 33.88,166.32 v2(33.88,167.17)
  L14-SIGNAL6 w0.089: v2(41.55,106.01) 38.78,106.01 34.45,110.34 31.93,110.34 28.43,106.84 28.43,100.75 26.93,99.25 26.93,90.03 32.8,84.17 32.8,74.25 33.33,73.72 33.33,67.06 29.9,63.63 v2(29.9,62.17) ; v2(17.33,145.52) 17.33,143.52 12.85,139.04 12.85,139.03 12.77,138.95 12.77,134.45 12.23,133.91 12.23,122.05 19.32,114.95 19.32,109.82 v2(15.35,105.86) ; v2(44.34,120.71) 44.66,120.71 44.95,120.42 52.29,120.42 v2(53.73,118.98)
  BOTTOM w0.127: v2(196.91,60.86) 197.05,60.72 R1111.1 ; v2(17.33,145.52) 18.37,146.56 20.36,146.56 20.55,146.76 U181.3 ; U190.2 48.04,123.58 v2(48.32,123.3) ; J54.64 v2(41.55,106.01) ; R1187.2 R1194.1 84.3,35.12 84.49,35.31 84.67,35.31 v2(85.05,35.69) ; U175.2 v2(33.88,167.17)
SOC_PWR_WKN: length 119.5
  TOP w0.127: U137.3 128.48,25.26 128.15,25.59 v2(128.15,26.93) 126.86,26.93 126.7,26.77 U134.4
  L12-SIGNAL5 w0.102: v2(181.51,79.25) 186.71,79.25 191.24,74.72 191.24,62.74 187.44,58.94 187.44,57.54 183.55,53.65 183.55,43.89 178.19,38.53 178.19,37.67 171.44,30.92 164.78,30.92 164.15,30.28 156.83,30.28 154.35,27.8 150.78,27.8 147.42,24.44 138.92,24.44 138.13,23.65 133.21,23.65 130.67,26.19 128.9,26.19 v2(128.15,26.93)
  BOTTOM w0.127: v2(181.51,79.25) 179.22,79.25 179.11,79.14 R1026.1 ; U278.4 v2(128.15,26.93)
SOC_SAFETY_ERRZ: length 253.7
  L3-SIGNAL1 w0.089: v2(84.66,96.13) 85.43,96.13 91.06,90.5 93.68,90.5 101.56,82.63 102.11,82.63 102.91,81.83 106.23,81.83 106.68,82.28 107.51,82.28 107.96,82.73 108.04,82.73 108.22,82.91 108.22,83.17 108.57,83.53 109.05,83.53 109.35,83.83 v3(109.52,83.83)
  L5-SIGNAL2 w0.102: v2(180.82,78.59) 181.59,78.59 183.88,76.3 183.88,72.88 184.65,72.11 184.65,55.67 180.55,51.57 180.55,49.9 173.73,43.08 157.29,43.08 156.23,42.02 130.41,42.02 129.91,42.52 129.04,42.52 128.48,41.96 115.55,41.96 115.15,42.37 98.03,42.37 94.85,45.54 v2(68,45.54)
  L12-SIGNAL5 w0.102: v2(84.66,96.13) 84.43,96.37 81.14,96.37 79.34,94.57 72.26,94.57 71.54,93.85 67.34,93.85 64.48,90.99 64.48,60.78 67.06,58.19 67.06,47.98 67.52,47.52 67.52,46.02 v2(68,45.54)
  BOTTOM w0.127: v2(180.82,78.59) 179.21,78.59 R1035.1
  vias: v1(109.51,83.83)
SOC_SERDES0_REFCLK_N: length 16
  L3-SIGNAL1 w0.079: v2(138.17,125.19) 137.8,125.19 137.72,125.27 137.72,126.06 132.6,131.19 132.6,134.26 132.97,134.63 133.62,134.63 133.76,134.49 133.76,134.27 v3(133.63,134.13)
  BOTTOM w0.094: R899.1 137.84,123.1 137.74,123.19 137.74,124.76 v2(138.17,125.19)
SOC_SERDES0_REFCLK_P: length 16.1
  L3-SIGNAL1 w0.079: v3(133.63,135.15) 133.63,134.96 133.55,134.88 132.87,134.88 132.35,134.36 132.35,131.09 137.48,125.96 137.48,125.27 137.4,125.19 v2(137.03,125.19)
  BOTTOM w0.094: R906.1 137.37,123.1 137.46,123.19 137.46,124.76 v2(137.03,125.19)
SOC_SERDES1_REFCLK_N: length 8.7
  L3-SIGNAL1 w0.079: v3(133.63,132.86) 133.63,132.52 133.72,132.43 134.25,132.43 135.06,133.23 137.57,133.23 137.97,132.84 137.97,132.39 138.09,132.26 v2(138.3,132.26)
  BOTTOM w0.094: v2(138.3,132.26) 137.93,131.9 137.93,131.59 R861.1 137.93,130.85 137.93,130.6 R869.1
SOC_SERDES1_REFCLK_P: length 8.7
  L3-SIGNAL1 w0.079: v2(137.28,132.26) 137.46,132.09 137.62,132.09 137.72,132.19 137.72,132.74 137.47,132.99 135.16,132.99 134.35,132.19 133.73,132.19 133.63,132.08 v3(133.63,131.72)
  BOTTOM w0.094: R870.1 137.65,130.6 137.65,130.84 137.28,131.21 R862.1 137.65,131.59 137.65,131.9 v2(137.28,132.26)
SOC_SERDES4_REFCLK_N: length 45.2
  TOP w0.094: R122.2 105.17,153.66 105.27,153.57 105.27,152.99 R129.1 105.17,152.56 105.27,152.47 105.27,151.99 v2(105.05,151.77)
  L3-SIGNAL1 w0.079: v2(105.05,151.77) 105.28,151.54 105.28,151.17 105,150.89 104.71,150.89 104.62,150.98 104.62,151.19 104.53,151.28 104.4,151.28 104.31,151.19 104.31,150.98 104.22,150.89 104.09,150.89 104,150.98 104,151.19 103.91,151.28 103.78,151.28 103.69,151.19 103.69,150.98 103.6,150.89 103.35,150.89 103.04,151.2 103.04,152.4 104.14,153.49 113.89,153.49 121.5,145.88 121.5,137.07 119.42,135 119.42,132.48 v3(119.09,132.14)
SOC_SERDES4_REFCLK_P: length 45.7
  TOP w0.094: R123.2 105.64,153.66 105.55,153.57 105.55,152.99 R130.1 105.64,152.56 105.55,152.47 105.55,151.99 v2(105.76,151.77)
  L3-SIGNAL1 w0.079: v2(105.76,151.77) 105.52,151.53 105.52,151.07 105.1,150.65 103.25,150.65 102.8,151.1 102.8,152.5 104.03,153.73 114,153.73 121.74,145.99 121.74,136.97 119.67,134.9 119.67,132.48 v3(120,132.14)
SOC_TCK: length 143.5
  TOP w0.127: U47.4 23.67,104.18 23.67,103.4 24.01,103.06 24.01,102.51 27.39,99.13 v2(27.39,98.21)
  L3-SIGNAL1 w0.089: v3(117.52,72.63) v5(117.29,72.36)
  L4-GND2 w0.102: v5(117.29,72.36) v6(116.98,72.05)
  L5-SIGNAL2 w0.102: v2(59.01,72.04) 59.65,72.68 70.31,72.68 73.39,69.6 80.32,69.6 80.86,69.06 80.86,68.43 81.24,68.05 86.11,68.05 87.89,66.26 87.89,64.21 98.72,53.38 101.29,53.38 105.81,57.9 108.58,57.9 109.99,59.31 109.99,59.84 116.01,65.86 116.01,70.54 116.57,71.1 116.57,71.64 v6(116.98,72.05)
  L14-SIGNAL6 w0.089: v2(27.39,98.21) 27.39,99.11 29.35,101.07 34.15,101.07 35.44,99.77 47.51,99.77 48.18,99.11 57.67,89.62 57.67,73.39 v2(59.01,72.04)
  vias: v1(117.52,72.63)
SOC_TDI: length 105.5
  L3-SIGNAL1 w0.089: v2(50.91,110.09) 50.91,109.62 51.34,109.19 53.71,109.19 54.75,108.15 57.67,108.15 63.94,101.88 63.94,100.28 65.29,98.93 67.45,98.93 70.13,96.24 74.27,96.24 78.7,91.82 89.39,91.82 90.92,90.29 93.54,90.29 101.42,82.41 102.03,82.41 102.82,81.61 106.28,81.61 106.76,82.09 107.6,82.09 107.74,82.23 v3(107.92,82.23)
  L5-SIGNAL2 w0.102: v2(19.94,106.43) 20.45,106.95 25.58,106.95 28.72,110.09 v2(50.91,110.09)
  BOTTOM w0.127: U206.7 20.91,105.48 19.96,106.43 v2(19.94,106.43)
  vias: v1(107.91,82.23)
SOC_TDO: length 107
  L3-SIGNAL1 w0.089: v3(107.92,83.03) 107.36,82.47 106.6,82.47 106.19,82.07 102.98,82.07 102.17,82.88 101.64,82.88 94.14,90.38 94.14,91.01 93.71,91.44 91.63,91.44 91.1,91.97 90.15,91.97 85.38,96.74 73.34,96.74 68.27,101.81 64.47,101.81 57.11,109.17 56.09,109.17 55.63,109.63 v2(51.62,109.63)
  L5-SIGNAL2 w0.102: v2(51.62,109.63) 49.64,109.63 49.09,109.08 44.9,109.08 44.18,109.8 28.79,109.8 25.69,106.7 22.35,106.7 21.35,105.69 21.35,104.29 v2(19.93,102.88)
  BOTTOM w0.127: U206.4 20.58,103.53 v2(19.93,102.88)
  vias: v1(107.91,83.03)
SOC_TMS: length 104.2
  TOP w0.127: v2(25.53,105.48) 24.43,106.59 24.01,106.59 TP68.1
  L3-SIGNAL1 w0.089: v2(50.88,108.94) 53.4,108.94 54.44,107.9 57.56,107.9 63.58,101.88 63.58,100.17 65.1,98.65 66.48,98.65 69.32,95.81 73.78,95.81 78.98,90.61 89.83,90.61 89.85,90.6 89.87,90.6 90.63,89.84 93.2,89.84 100.11,82.93 100.11,82.58 101.52,81.16 106.37,81.16 106.92,81.71 108.09,81.71 108.61,82.23 v3(108.72,82.23)
  L5-SIGNAL2 w0.102: v2(50.88,108.94) 50.73,108.79 44.7,108.79 43.92,109.57 30.15,109.57 26.05,105.48 v2(25.53,105.48)
  BOTTOM w0.127: v2(25.53,105.48) 26.18,106.13 U206.9
  vias: v1(108.71,82.23)
SOC_TRST#: length 145.5
  TOP w0.127: v2(29.09,96.48) 28.09,96.48 24.94,99.63 24.94,100.83 23.54,102.23 U47.7
  L3-SIGNAL1 w0.089: v3(120.72,72.63) v5(120.49,72.35) ; v5(107.12,53.85) 105.44,53.85 103.49,55.8 75.4,55.8 69.71,61.49 61.98,61.49 59.75,63.73 58.1,63.73 55,66.82 50.08,66.82 48.17,68.73 v2(48.17,69.22)
  L4-GND2 w0.102: v5(120.49,72.35) v6(120.18,72.05) ; v5(107.12,53.85) v6(107.45,53.85)
  L5-SIGNAL2 w0.102: v6(120.18,72.05) 120.79,71.45 120.79,59.69 115.4,54.31 111.92,54.31 111.57,54.66 108.26,54.66 v6(107.45,53.85)
  L14-SIGNAL6 w0.089: v2(29.09,96.48) 30.96,96.48 35.95,91.48 35.95,74.61 38.67,71.89 45.51,71.89 v2(48.17,69.22)
  vias: v1(120.72,72.63)
SOC_UART8_CTSN_MUX: length 79.1
  TOP w0.127: v2(56.27,100.58) R275.1 55.93,100.63 55.81,100.52 R276.1
  L3-SIGNAL1 w0.089: v5(89.37,78.65) 89.37,78.18 93.56,73.99 93.56,72.18 95.72,70.01 97.52,70.01 98.28,69.25 102.74,69.25 105.65,72.16 108.24,72.16 v3(108.72,72.63)
  L4-GND2 w0.102: v5(89.37,78.65) v6(89.37,78.98)
  L5-SIGNAL2 w0.102: v6(89.37,78.98) 89.71,78.98 89.74,78.95 90.38,78.95 90.94,79.51 90.94,80.33 91.97,81.36 91.97,84.13 89.26,86.83 89.26,90.7 87.4,92.56 86.44,92.56 84.41,94.59 74.51,94.59 73.28,95.81 61.75,95.81 60.79,96.77 60.07,96.77 v2(56.27,100.58)
  vias: v1(108.72,72.63)
SOC_UART8_RTSN_MUX: length 75.5
  TOP w0.127: v2(56.27,102.39) R268.1 55.93,102.45 55.81,102.33 R270.1
  L3-SIGNAL1 w0.089: v5(91.71,78.65) 91.71,77.78 98.33,71.16 100.74,71.16 101.51,71.93 102.42,71.93 104.3,73.82 107.5,73.82 107.62,73.93 108.41,73.93 v3(108.72,74.23)
  L4-GND2 w0.102: v5(91.71,78.65) v6(91.48,78.88)
  L5-SIGNAL2 w0.102: v2(56.27,102.39) 57.39,101.28 57.39,99.85 60.19,97.05 60.89,97.05 61.9,96.04 73.43,96.04 74.66,94.82 84.51,94.82 86.54,92.79 87.5,92.79 89.49,90.79 89.49,86.93 92.2,84.22 92.2,81.25 91.48,80.54 v6(91.48,78.88)
  vias: v1(108.72,74.23)
SOC_WKUP_I2C0_SCL: length 354.2
  TOP w0.127: U78.1 R445.2 28.57,65.06 v2(29.29,65.06)
  L3-SIGNAL1 w0.089: v3(121.52,68.63) 121.7,68.45 121.7,57.2 110.65,46.16 108.21,46.16 100.31,54.06 95.62,54.06 95.15,53.59 72.86,53.59 71.01,55.44 61.17,55.44 57.48,51.75 v2(38.51,51.75)
  L5-SIGNAL2 w0.102: v2(29.29,65.06) 30.67,63.69 30.67,61.47 36.23,55.91 37.19,55.91 38.51,54.59 38.51,53.75 v2(38.51,51.75) 38.51,44.83 38.29,44.6 38.29,37.83 41.93,34.19 43.33,34.19 47,30.52 61.91,30.52 65.44,26.98 69.7,26.98 71,28.28 71.11,28.28 71.26,28.43 81.45,28.43 81.81,28.8 92.51,28.8 93.16,29.45 98.47,29.45 98.8,29.12 103.76,29.12 104.37,28.51 106.27,28.51 108.52,26.26 108.52,22.48 112.15,18.85 113.2,18.85 120.75,11.3 126.21,11.3 126.74,11.83 146.71,11.83 153.08,18.2 185.33,18.2 188.06,15.47 196.5,15.47 197.8,14.17 209.3,14.17 213.06,17.93 218.73,17.93 219.61,18.81 224.05,18.81 224.78,19.54 228.02,19.54 v2(229.42,18.14)
  BOTTOM w0.127: U268.3 228.9,17.82 229.22,18.14 v2(229.42,18.14)
  vias: v1(121.52,68.63)
SOC_WKUP_I2C0_SDA: length 357.7
  TOP w0.127: v2(26.4,59.27) R478.2 U78.5
  L3-SIGNAL1 w0.089: v3(115.92,71.03) v5(115.69,70.75) ; v2(26.4,59.27) 27.07,59.93 32.05,59.93 32.25,59.73 32.89,59.73 35.82,62.66 35.82,63.6 38.29,66.07 38.29,67.93 45.82,75.46 55.08,75.46 56.6,76.99 70.7,76.99 73.15,74.54 73.15,73.77 75.01,71.91 77.91,71.91 80.81,69.01 80.81,67.11 82.76,65.16 88.34,65.16 90.57,62.92 106,62.92 106.66,62.26 v5(107.09,62.26)
  L4-GND2 w0.102: v5(107.09,62.26) v6(107.42,62.26) ; v5(115.69,70.75) v6(115.38,70.45)
  L5-SIGNAL2 w0.102: v6(115.38,70.45) 115.38,70.09 112.99,67.69 112.99,65.35 109.56,61.93 107.76,61.93 v6(107.42,62.26) ; v2(226.3,19.01) 225.57,18.28 223.33,18.28 222.64,17.6 218.12,17.6 216.67,16.15 212.15,16.15 209.74,13.74 187.79,13.74 187.33,14.2 187.33,15.75 185.22,17.86 153.14,17.86 146.89,11.6 126.84,11.6 126.3,11.07 120.66,11.07 115.53,16.19 113.38,18.34 111.84,18.34 108.09,22.09 108.09,26.09 107.09,27.08 105.32,27.08 103.84,28.56 83.14,28.56 82.79,28.2 71.36,28.2 69.91,26.75 65.35,26.75 61.81,30.29 46.91,30.29 43.25,33.94 41.85,33.94 38.06,37.74 38.06,53.37 35.93,55.51 35.57,55.51 35.31,55.25 35.31,55.02 34.93,54.64 34.04,54.64 33.61,55.07 31.51,57.18 28.49,57.18 v2(26.4,59.27)
  BOTTOM w0.127: v2(226.3,19.01) 226.95,18.36 U268.6
  vias: v1(115.92,71.03)
SPI5_CLK: length 11.1
  BOTTOM w0.127: J26.1 9.41,73.57 15.71,73.57 16.53,72.74 R1060.2
SPI5_CS0: length 10.2
  BOTTOM w0.127: J26.5 10.65,64.65 15.17,64.65 R1102.2
SPI5_CS1: length 9.6
  BOTTOM w0.127: R1094.2 15.92,67.28 14.11,65.46 8.93,65.46 J26.4
SPI5_D0: length 9.5
  BOTTOM w0.127: J26.2 9.87,69.63 11.13,70.9 15.45,70.9 R1076.2
SPI5_D1: length 9.1
  BOTTOM w0.127: R1086.2 16.05,68.55 15.86,68.36 9.28,68.36 J26.3
SS1_LM5140: length 5.5
  TOP w0.254: U46.30 213.81,108.03 213.34,108.49 211.69,108.49 211.48,108.7 C205.1
SS1_LM5143: length 10.6
  TOP w0.127: U25.30 205.97,146.78 206.13,146.62 206.92,146.62 207.12,146.41 v2(207.12,145.76)
  L3-SIGNAL1 w0.089: v2(207.12,145.76) 207.12,152.2 v3(205.97,153.35)
SS2_LM5140: length 7.1
  TOP w0.254: U46.1 213.1,101.79 210.75,99.44 209.36,99.44 208.82,99.98 C223.1
SS_LM5141: length 2
  TOP w0.127: C314.1 203.72,56.75 204.4,57.44 U81.22
SVS_ENABLE: length 89.8
  TOP w0.127: U89.5 171.85,49.14 173.49,47.51 v2(176.67,47.51) 176.67,47.96 177.07,48.37 178.49,48.37 178.71,48.58 U87.5
  L14-SIGNAL6 w0.089: v2(231.04,19.13) 231.04,16.71 228.87,14.54 224.73,14.54 224.08,13.88 212.97,13.88 212.25,14.61 206.08,14.61 202.95,17.73 202.95,19.55 192.36,30.15 192.36,32.99 177.84,47.51 v2(176.67,47.51)
  BOTTOM w0.127: v2(231.04,19.13) 231.04,19.37 230.54,19.87 228.46,19.87 227.6,20.73 U268.12
SVS_SYNCN: length 17.2
  TOP w0.127: U89.9 170.58,51.39 170.58,51.6 170.85,51.87 v2(171.71,51.87) ; U87.9 181.19,49.88 182.01,49.06 182.44,49.06 v2(182.89,48.61)
  L7-SIGNAL3 w0.109: v2(171.71,51.87) 171.92,51.87 172.53,52.48 179.44,52.48 181.76,50.16 181.76,49.74 v2(182.89,48.61)
SW_LM5141: length 5.9
  TOP w0.254: C302.1 209.9,59.74 209.11,58.94 U81.12
  TOP w0.305: C302.1 210.38,59.74 211.51,60.87 212.93,60.87 213.05,60.99 213.7,60.99
  vias: v2(213.55,61.5) v2(213.55,60.48) v2(214.56,61.5) v2(214.56,60.48) v2(215.58,61.5) v2(215.58,60.48) v2(216.59,61.5) v2(216.59,60.48) v2(218.68,59.72) v2(218.68,58.71) v2(218.68,57.69) v2(218.68,56.67) v2(219.69,59.72) v2(219.69,58.71) v2(219.69,57.69) v2(219.69,56.67)
SW_PB_EXTINTN: length 26.9
  TOP w0.127: U98.6 232.03,45.62 233.33,46.92 233.33,50.38 234.48,51.52 234.48,61.91 SW6.2 SW6.3
SW_PB_MCU_PORZ: length 18.2
  TOP w0.127: SW14.3 SW14.2 233.66,35.08 232.7,36.05 232.7,41.99 231.67,43.02 U98.2
SW_PB_MCU_RESETZ: length 12
  TOP w0.127: U98.3 232.49,43.67 233.97,42.2 SW12.2 SW12.3
SW_PB_PORZ: length 15.1
  TOP w0.127: SW10.3 SW10.2 235.24,49.31 234.37,48.45 234.37,45.6 233.09,44.32 U98.4
SW_PB_RESETZ: length 20.7
  TOP w0.127: U98.5 232.5,44.97 233.79,46.26 233.79,49.69 234.91,50.81 234.91,55.23 SW9.2 SW9.3
SW_PB_SYS_IRQZ: length 33.3
  TOP w0.127: U98.7 231.82,46.27 232.52,46.97 232.52,50.58 233.92,51.98 233.92,62.69 234.98,63.76 234.98,69.53 SW5.2 SW5.3
SYNOUT_LM5140: length 6.7
  TOP w0.127: TP75.1 207.07,103.12 207.16,103.04 U46.39
SYNOUT_LM5143: length 5
  TOP w0.127: TP23.1 208.77,154.67 208.77,152.66 208.59,152.48 207.73,152.48 207.35,152.1 U25.39
SYS_BOOTMODE0: length 22.3
  TOP w0.127: v2(58.42,45.74) 58,45.74 57.77,45.51 57.41,45.51 57.18,45.74 SW11.1
  L5-SIGNAL2 w0.102: v2(58.42,45.74) 58.86,46.17 58.86,47.19 58.43,47.62 54.39,47.62 49.22,52.79 v2(49.22,55.7)
  BOTTOM w0.127: U248.4 58.11,46.57 58.42,46.25 v2(58.42,45.74) ; U243.9 v2(49.22,55.7)
SYS_BOOTMODE1: length 21.4
  TOP w0.127: v2(58.42,47.01) SW11.2
  L5-SIGNAL2 w0.102: v2(48.2,55.7) 48.2,53.65 48.19,53.64 48.19,53.49 54.68,47.01 v2(58.42,47.01)
  BOTTOM w0.127: U243.10 48.7,56.2 v2(48.2,55.7) ; v2(58.42,47.01) 58.39,46.97 U248.5
SYS_BOOTMODE2: length 20.1
  TOP w0.127: v2(58.42,48.28) SW11.3
  L5-SIGNAL2 w0.102: v2(49.22,56.7) 49.65,56.27 49.65,53.04 49.65,52.85 52.53,49.96 52.53,49.96 54.22,48.28 v2(58.42,48.28)
  BOTTOM w0.127: v2(58.42,48.28) 57.52,47.37 U248.6 ; U243.11 v2(49.22,56.7)
SYS_BOOTMODE3: length 23
  TOP w0.127: v2(58.42,49.55) SW11.4
  L5-SIGNAL2 w0.102: v2(48.2,56.7) 48.63,57.13 49.4,57.13 49.88,56.65 49.88,52.94 52.63,50.19 57.78,50.19 v2(58.42,49.55)
  BOTTOM w0.127: v2(48.2,56.7) 48.7,57.2 U243.12 ; U248.7 57.27,47.77 57.91,48.4 57.91,49.03 v2(58.42,49.55)
SYS_BOOTMODE4: length 19.5
  TOP w0.127: v2(58.42,50.82) SW11.5
  L5-SIGNAL2 w0.102: v2(58.42,50.82) 52.33,50.82 50.11,53.04 50.11,56.81 v2(49.22,57.7)
  BOTTOM w0.127: v2(58.42,50.82) 57.92,51.32 U244.4 ; U243.13 v2(49.22,57.7)
SYS_BOOTMODE5: length 21.7
  TOP w0.127: v2(58.42,52.09) SW11.6
  L5-SIGNAL2 w0.102: v2(58.42,52.09) 51.38,52.09 50.34,53.13 50.34,57.19 49.4,58.13 48.63,58.13 v2(48.2,57.7)
  BOTTOM w0.127: U244.5 58.06,51.72 v2(58.42,52.09) ; U243.14 48.7,58.2 v2(48.2,57.7)
SYS_BOOTMODE6: length 24.6
  TOP w0.127: v2(58.42,53.36) SW11.7
  L5-SIGNAL2 w0.102: v2(58.42,53.36) 57.67,52.6 51.19,52.6 50.56,53.23 50.56,57.29 49.5,58.35 49.5,60.46 v2(49.9,60.87)
  BOTTOM w0.127: U244.6 57.74,52.12 58.42,52.81 v2(58.42,53.36) ; U243.15 49.55,58.7 49.42,58.83 49.42,60.38 v2(49.9,60.87)
SYS_BOOTMODE7: length 21
  TOP w0.127: v2(58.42,54.63) SW11.8
  L5-SIGNAL2 w0.102: v2(58.42,54.63) 57.3,53.5 51.31,53.5 50.89,53.92 50.89,57.34 49.93,58.3 v2(49.93,59.85)
  BOTTOM w0.127: v2(49.93,59.85) 50.12,59.66 U243.16 ; U244.7 57.66,52.52 57.97,52.83 57.97,54.18 v2(58.42,54.63)
SYS_IRQZ: length 84.2
  L3-SIGNAL1 w0.089: v2(108.85,37.41) 99.12,37.41 94.93,41.61 89.44,41.61 89.01,41.17 83.4,41.17 83.02,41.55 77.73,41.55 76.49,42.8 69.43,42.8 68.58,43.65 v2(66.87,43.65) ; v3(120.72,69.43) 120.72,69.09 120.41,68.79 120.41,57.22 111.06,47.88 v2(108.11,47.88)
  L7-SIGNAL3 w0.109: v2(108.11,47.88) 108.11,40.72 108.85,39.98 v2(108.85,37.41)
  vias: v1(120.72,69.43)
SYS_MCU_EN: length 10.7
  TOP w0.127: U130.4 228.67,27.32 228.15,26.8 v2(228.15,25.31)
  BOTTOM w0.127: U268.10 226.3,23.15 226.09,23.35 226.09,23.79 226.07,23.81 226.07,24.72 226.53,25.18 228.02,25.18 v2(228.15,25.31) 228.25,25.21 U268.13
SYS_MCU_PWRDN: length 288
  TOP w0.127: R428.1 66.56,70.43 v2(66.99,70.86) ; v2(227.76,37.96) U113.1
  L3-SIGNAL1 w0.089: v3(119.92,71.83) v5(119.69,71.55) ; v2(66.99,70.86) 66.99,66.06 76.1,56.95 105.01,56.95 106.1,55.86 v5(110.7,55.86)
  L4-GND2 w0.102: v5(110.7,55.86) v6(111.03,55.86) ; v5(119.69,71.55) v6(119.38,71.25)
  L5-SIGNAL2 w0.102: v6(119.38,71.25) 119.68,70.95 119.68,59.56 115.11,54.99 112.58,54.99 111.72,55.86 v6(111.03,55.86)
  L12-SIGNAL5 w0.102: v2(66.99,70.86) 66.99,62.81 72.45,57.35 72.45,47.42 78.14,41.73 79.79,41.73 83.24,38.28 83.24,35.97 84.09,35.12 86.32,35.12 90.83,30.62 90.83,29.4 93.73,26.49 94.27,26.49 96.91,23.85 102.07,23.85 104.22,21.69 109.99,21.69 119.01,12.67 125.89,12.67 126.03,12.54 171.09,12.54 177.06,18.51 178.46,18.51 182.08,22.12 182.89,22.12 183.27,22.5 192.63,22.5 200.23,30.11 220.31,30.11 227.76,37.56 v2(227.76,37.96)
  vias: v1(119.92,71.83)
SYS_PWR_PG: length 76.3
  TOP w0.127: U130.6 229.38,29.12 229.88,29.62 Q2.1 v2(229.22,30.88)
  L3-SIGNAL1 w0.089: v2(161.88,28.91) 164.07,26.72 174.85,26.72 176.36,28.23 195.65,28.23 197.61,30.19 228.53,30.19 v2(229.22,30.88)
  BOTTOM w0.127: 161.88,29.67 v2(161.88,28.91) ; 161.88,29.67 162.02,29.82 U258.3 ; 161.88,29.67 161.73,29.83 161.5,29.83 161.24,30.09 U255.4
SYSBOOT_BUF_ENZ: length 4.3
  BOTTOM w0.127: U253.2 R1172.2 R1181.2 R1185.2
TA_BM_IOEXP_RSTN: length 155.2
  TOP w0.127: U10.9 v2(17.74,168.36)
  L12-SIGNAL5 w0.102: v2(15.47,150.2) 17.55,148.12 17.55,146.84 16.7,146 16.7,143.87 20.55,140.02 37.21,140.02 38,139.23 38,138.13 39.03,137.1 39.03,133.52 40.06,132.49 40.06,131.63 41.79,129.9 42.71,129.9 47.24,125.37 47.24,122.91 48.01,122.13 48.01,120.13 50.93,117.21 50.93,113.4 49.87,112.34 49.56,112.34 49.09,111.87 49.09,110.95 49.48,110.56 49.48,108.75 49.04,108.31 49.04,84.22 48.65,83.83 48.65,69.99 49.05,69.59 49.05,63.48 52.39,60.15 55.06,60.15 v2(57.01,58.2)
  L14-SIGNAL6 w0.089: v2(15.47,150.2) 14.36,151.31 14.36,153.84 10.42,157.78 10.42,165.77 11.24,166.58 11.24,167.04 11.55,167.36 12.01,167.36 13.28,168.63 17.47,168.63 v2(17.74,168.36)
  BOTTOM w0.127: J50.33 15.37,150.1 v2(15.47,150.2) ; U243.28 56.51,57.7 v2(57.01,58.2)
TA_BOOTMODE_CNTL#: length 33
  TOP w0.127: TP26.1 13.32,150.48 13.11,150.27 v2(13.11,149.7) ; v2(16.82,171.52) 17.09,171.25 U10.8
  L14-SIGNAL6 w0.089: v2(13.11,149.7) 13.11,154.49 10.01,157.58 10.01,167.01 10.8,167.8 11.88,167.8 15.48,171.41 15.48,171.69 15.73,171.94 16.4,171.94 v2(16.82,171.52)
  BOTTOM w0.127: v2(13.11,149.7) 13.21,149.6 J50.32
TA_PORZN: length 308.9
  TOP w0.127: U10.4 14.49,170.84 v2(13.88,171.44) ; U124.3 164.08,30.8 v2(163.86,31.02)
  L3-SIGNAL1 w0.089: v2(163.86,31.02) 163.41,31.47 155.46,31.47 154.39,30.4 135.64,30.4 133.21,32.84 114,32.84 111.23,35.61 99.59,35.61 94.9,40.29 86.28,40.29 86.06,40.07 58.7,40.07 56.23,42.55 47.74,42.55 47.2,43.09 45.28,43.09 43.23,45.15 34.12,45.15 30.65,48.62 25.9,48.62 22.13,44.84 v2(22.13,44.44)
  L12-SIGNAL5 w0.102: v2(22.13,44.44) 19.06,47.51 19.06,58.26 16.69,60.63 16.69,73.24 13.95,75.99 13.95,122.31 6.74,129.52 v2(6.74,146.44)
  L14-SIGNAL6 w0.089: v2(6.74,146.44) 10.35,146.44 11.26,145.52 15.48,145.52 16.3,146.34 v2(16.3,146.74) 16.74,146.74 17.57,147.57 17.57,148.8 17.2,149.17 17.2,158.49 16.07,159.62 16.07,165.03 18.16,167.12 18.16,170.78 16.8,172.15 14.59,172.15 v2(13.88,171.44)
  BOTTOM w0.127: U251.1 v2(22.13,44.44) ; v2(16.3,146.74) 15.88,146.74 15.53,147.1 J50.27
TA_POWERDOWNZ: length 362.8
  TOP w0.127: U10.3 13.84,170.5 v2(12.87,171.47) ; v2(225.78,27.32) U130.3
  L12-SIGNAL5 w0.102: v2(225.78,27.32) 221.47,23.02 221.47,18.36 220.34,17.23 216.87,17.23 216.34,17.75 215.06,17.75 214.76,17.45 205.77,17.45 204.73,16.41 199.63,16.41 198.76,15.54 188.1,15.54 187.59,15.03 177.78,15.03 171.08,8.33 116.77,8.33 112.17,12.93 94.91,12.93 84.06,23.77 83.4,23.77 81.87,25.3 81.87,26.69 80.35,28.2 79.88,28.2 78.52,29.56 78.52,30.46 74.54,34.44 74.54,35.29 67.92,41.92 64.21,41.92 55.16,50.96 55.16,58.13 53.92,59.37 52.5,59.37 48.61,63.26 48.61,69.4 48.2,69.81 48.2,84.02 48.54,84.36 48.54,108.57 49.03,109.06 49.03,110.37 48.64,110.76 48.64,112.19 49.33,112.88 49.33,113.58 49.79,114.05 49.79,116.2 50,116.41 50,117.51 46.79,120.72 46.79,124.89 42.66,129.02 41.62,129.02 39.88,130.77 34.57,130.77 34.05,131.29 34.05,132.75 34.99,133.69 34.99,137.3 34.01,138.28 34.01,139.12 33.56,139.57 18.38,139.57 14.44,143.51 14.44,145.35 v2(13.18,146.6)
  L14-SIGNAL6 w0.089: v2(13.18,146.6) 11.84,147.94 11.84,155.13 9.61,157.37 9.61,168.2 v2(12.87,171.47)
  BOTTOM w0.127: J50.26 v2(13.18,146.6)
TA_RESETZ: length 151.1
  TOP w0.127: v2(15.43,168.09) 15.14,168.39 U10.5
  L12-SIGNAL5 w0.102: v2(6.84,147.63) 6.33,147.12 6.33,129.61 13.72,122.22 13.72,75.89 16.09,73.52 16.09,60.64 16.72,60.01 16.72,48.36 21.09,43.99 22.28,43.99 22.77,44.49 v2(25.41,44.49)
  L14-SIGNAL6 w0.089: v2(15.43,168.09) 15.86,167.66 15.86,159.54 16.99,158.41 16.99,148.58 v2(16.3,147.89) 14.48,146.06 11.96,146.06 10.39,147.63 v2(6.84,147.63)
  BOTTOM w0.127: J50.28 15.48,147.6 15.77,147.89 v2(16.3,147.89) ; U249.3 v2(25.41,44.49)
TA_SOC_INT1Z: length 173.3
  TOP w0.127: U92.2 67.01,50.14 66.67,49.8 65.76,49.8 64.81,48.86 61.01,48.86 v2(60.84,48.69) ; v2(14.99,171.52) 15.79,170.73 U10.6
  L12-SIGNAL5 w0.102: v2(13.11,148.5) 14.13,147.47 14.13,146.12 20.46,139.8 35.35,139.8 36.05,139.1 36.05,138.08 37.02,137.12 37.02,133.58 38.03,132.57 38.03,131.64 38.5,131.16 40.04,131.16 41.8,129.41 42.89,129.41 47.01,125.28 47.01,120.81 50.71,117.12 50.71,113.49 49.86,112.65 49.51,112.65 48.86,112 48.86,110.86 49.25,110.47 49.25,108.97 48.81,108.52 48.81,84.31 48.43,83.93 48.43,69.9 48.83,69.49 48.83,63.39 52.44,59.78 54.35,59.78 55.4,58.73 55.4,51.99 58.53,48.87 60.66,48.87 v2(60.84,48.69)
  L14-SIGNAL6 w0.089: v2(13.11,148.5) 12.32,149.29 12.32,154.96 9.81,157.47 9.81,167.95 12.48,170.62 14.09,170.62 v2(14.99,171.52)
  BOTTOM w0.127: v2(13.11,148.5) 13.21,148.6 J50.30
TA_SOC_INT2Z: length 181
  TOP w0.127: U10.7 16.44,170.99 v2(15.91,171.52)
  L12-SIGNAL5 w0.102: v2(15.47,149) 12.19,149 11.86,148.66 11.86,145.7 19.81,137.75 29.39,137.75 29.42,137.78 31.56,137.78 33.23,136.1 33.23,134.72 31.89,133.38 31.89,131.82 33.31,130.4 39.51,130.4 46.57,123.34 46.57,120.63 49.78,117.42 49.78,116.5 49.57,116.29 49.57,114.31 48.92,113.67 48.57,113.67 48.22,113.31 48.22,98.57 48.32,98.47 48.32,84.45 47.77,83.9 47.77,54.92 55.94,46.74 58.08,46.74 64.18,40.64 65.52,40.64 v2(65.92,41.05)
  L14-SIGNAL6 w0.089: v2(15.47,149) 14.14,150.33 14.14,153.75 10.22,157.67 10.22,165.92 10.98,166.68 10.98,167.08 11.46,167.57 11.94,167.57 15.89,171.52 v2(15.91,171.52)
  BOTTOM w0.127: v2(15.47,149) 15.37,149.1 J50.31
TCA6424_EXP_INT: length 1.9
  BOTTOM w0.127: R1135.1 55.96,54.93 55.84,55.06 55.84,55.53 55.67,55.7 U243.32
TCA9543_A0: length 3.1
  BOTTOM w0.127: U181.1 19.25,148.95 19.07,149.14 R821.1 R822.2
TCA9543_A1: length 3.2
  BOTTOM w0.127: R819.2 R820.1 20.21,149.18 19.9,148.88 U181.2
TCA9543_INT#: length 2.1
  TOP w0.127: R157.1 20.71,140.9 v2(20.94,140.67)
  BOTTOM w0.127: U181.11 21.2,140.94 v2(20.94,140.67)
TEMP_DIODE_P0: length 9.9
  L3-SIGNAL1 w0.089: v3(107.96,64.11) 108.39,64.54 108.39,68.73 109.15,69.5 109.15,69.98 110.24,71.07 111.15,71.07 v3(111.92,71.83)
  vias: v1(111.92,71.83)
TEMP_DIODE_P1: length 44.5
  L3-SIGNAL1 w0.089: v3(112.72,72.63) v5(112.49,72.35)
  L4-GND2 w0.102: v5(112.49,72.35) v6(112.18,72.05)
  L5-SIGNAL2 w0.102: v6(112.18,72.05) 111.92,72.31 111.92,76.25 111.62,76.56 109.2,76.56 109.05,76.4 104.4,76.4 v7(102.95,77.85)
  L7-SIGNAL3 w0.109: v7(102.95,77.85) 102.66,78.14 96.23,78.14 93.24,75.16 91.6,75.16 88.46,75.16 82.94,75.16 81.59,76.5 77.08,76.5 v2(75.78,77.8)
  vias: v1(112.72,72.63)
TIMER_IO0_R: length 33.2
  TOP w0.127: v2(86.97,97.24) 87.3,97.58 TP81.1 ; U59.AA32 108.72,84.63 v2(109.12,85.03)
  L10-SIGNAL4 w0.109: v2(86.97,97.24) 87.41,96.8 87.41,92.15 88.07,91.49 88.07,89.18 91.52,85.73 102.68,85.73 103.37,85.03 v2(109.12,85.03)
TIMER_IO1: length 48.3
  TOP w0.127: R310.2 87.64,94.09 88.07,94.52 88.07,95.38 v3(88.14,95.45)
  L3-SIGNAL1 w0.089: v3(110.32,83.03) v5(110.19,82.7) ; v5(88.45,96.7) 88.14,96.39 v3(88.14,95.45)
  L4-GND2 w0.102: v7(110.03,83.25) 110.17,83.13 v5(110.19,82.7) ; v5(88.45,96.7) v7(88.76,97)
  L12-SIGNAL5 w0.102: v7(88.76,97) 91.58,97 93.05,95.53 93.05,92.18 89.9,89.03 89.42,89.03 86.67,86.28 86.67,84.59 88.3,82.96 92.27,82.96 93.06,83.74 109.53,83.74 v7(110.03,83.25)
  vias: v1(110.31,83.03)
TM4C129_RST#: length 2.3
  TOP w0.127: TP3.1 v2(15.17,184.67)
  BOTTOM w0.127: R735.2 v2(15.17,184.67)
TM4C129_TCK: length 4.3
  BOTTOM w0.127: U170.100 24.76,175.26 23.78,175.26 23.39,174.87 23.39,173.35 23.02,172.98 v2(22.32,172.98)
TM4C129_TDI: length 3.2
  BOTTOM w0.127: U170.98 24.76,176.06 23.66,176.06 22.38,174.77 v2(22.38,174.51)
TM4C129_TDO: length 4.6
  BOTTOM w0.127: v2(20.95,174.52) 21.71,174.52 23.65,176.46 24.76,176.46 U170.97
TM4C129_TMS: length 5.6
  BOTTOM w0.127: U170.99 24.76,175.66 23.72,175.66 23.15,175.09 23.15,173.95 22.82,173.62 21.56,173.62 v2(20.95,173.02)
TMP1_ADD0: length 3.3
  TOP w0.127: U82.5 198.05,100.05 198.2,100.2 198.2,100.53 198.4,100.73 R499.2 R498.2
TMP1_ADD1: length 2.8
  TOP w0.127: U82.3 193.8,99.1 193.69,99.21 R479.2 R472.2
TMP2_ADD0: length 2.8
  TOP w0.127: R358.1 97.76,85.58 R353.2 98.15,86.65 98.48,86.98 U55.5
TMP2_ADD1: length 3.2
  TOP w0.127: U55.3 101.78,87.93 101.01,88.69 R331.2 100.39,89.33 100.29,89.43 R336.2
TRC_CLK: length 26.2
  TOP w0.127: v2(43.11,90.23) U58.30
  L5-SIGNAL2 w0.102: v2(43.11,90.23) 43.54,89.8 43.54,87.51 41.72,85.69 23.58,85.69 v2(22.77,86.49)
TRC_CTL: length 32.3
  TOP w0.127: U58.52 46.03,79.23 46.72,79.92 v2(46.72,82.13)
  L5-SIGNAL2 w0.102: v2(46.72,82.13) 46.34,82.51 45.22,82.51 44.24,83.49 41.98,83.49 40.02,85.45 23.21,85.45 22.34,86.32 22.34,87.21 v2(22.77,87.64)
TRC_DATA0: length 10.8
  L3-SIGNAL1 w0.089: v2(26.67,81.71) 24.71,81.71 21.62,84.81 21.62,86.68 v2(20.66,87.64)
  BOTTOM w0.127: U227.2 v2(26.67,81.71)
TRC_DATA0_MUX: length 97.7
  L3-SIGNAL1 w0.089: v3(109.52,80.63) v5(109.29,80.35)
  L4-GND2 w0.102: v5(109.29,80.35) v7(109,80.65)
  L5-SIGNAL2 w0.102: v7(85.05,85.52) 84.39,86.18 84.39,89.95 84.14,90.19 78.85,90.19 77.4,88.74 77.4,87.4 76.13,86.13 76.13,85.32 74.33,83.52 62.18,83.52 60.99,82.32 57.79,82.32 55.91,80.44 51.11,80.44 49.36,78.69 40.09,78.69 39.56,78.16 34.22,78.16 v2(33.92,78.47)
  L12-SIGNAL5 w0.102: v7(109,80.65) 109,81.1 107.4,82.7 101.13,82.7 100.41,81.98 92.95,81.98 92.92,82.02 86.99,82.02 86.48,82.53 86.48,83.37 85.05,84.8 v7(85.05,85.52)
  BOTTOM w0.127: v2(33.92,78.47) 28.51,78.47 27.97,79 U227.4
  vias: v1(109.52,80.63)
TRC_DATA1: length 22
  TOP w0.127: U58.32 43.56,89.23 43.33,89 43.15,89 v2(43.06,89.09)
  L5-SIGNAL2 w0.102: v2(43.06,89.09) 42.96,88.98 22.97,88.98 v2(22.77,88.78)
TRC_DATA2: length 28.5
  TOP w0.127: U58.54 43.56,78.23 v2(43.31,77.98)
  L3-SIGNAL1 w0.089: v2(43.31,77.98) 42.88,78.41 35.44,78.41 33.99,79.86 30.51,79.86 23.27,87.1 22.34,87.1 v2(20.66,88.78)
TRC_DATA3: length 26.2
  TOP w0.127: U58.50 43.55,80.23 v2(43.31,79.98)
  L3-SIGNAL1 w0.089: v2(43.31,79.98) 42.57,80.72 37.19,80.72 35.37,82.55 29.74,82.55 22.77,89.52 v2(22.77,89.92)
TRC_DATA4: length 30.2
  TOP w0.127: U50.50 43.56,97.58 v2(43.31,97.33)
  L5-SIGNAL2 w0.102: v2(43.31,97.33) 42.01,97.33 41.44,97.89 33.17,97.89 29.17,93.9 20.59,93.9 20.23,93.53 20.23,90.35 v2(20.66,89.92)
TRC_DATA5: length 41.6
  TOP w0.127: U50.30 43.56,107.58 v2(43.31,107.33)
  L5-SIGNAL2 w0.102: v2(43.31,107.33) 43.22,107.42 35.64,107.42 33.92,105.69 33.92,103.48 29.74,99.29 29.74,97.84 29.36,97.47 20.74,97.47 20,96.73 20,89.97 20.48,89.49 21.2,89.49 v2(22.77,91.07)
TRC_DATA6: length 32.8
  TOP w0.127: U58.43 45.5,83.73 45.75,83.98 v2(45.75,84.16)
  L5-SIGNAL2 w0.102: v2(45.75,84.16) 45.01,84.16 43.82,85.35 43.82,90.41 42.73,91.5 21.09,91.5 v2(20.66,91.07)
TRC_DATA7: length 30.1
  TOP w0.127: U58.41 45.52,84.73 45.78,84.99 v2(45.78,85.07)
  L5-SIGNAL2 w0.102: v2(45.78,85.07) 45.07,85.78 45.07,90.32 43.18,92.21 v2(22.77,92.21)
TRC_DATA8: length 34.5
  TOP w0.127: U58.45 45.52,82.73 v2(45.77,82.98)
  L5-SIGNAL2 w0.102: v2(20.66,92.21) 21.09,91.78 42.99,91.78 44.84,89.92 44.84,85.28 45.53,84.59 45.93,84.59 46.29,84.23 46.29,83.5 v2(45.77,82.98)
TRC_DATA9: length 28.2
  TOP w0.127: v2(45.77,99.33) 45.52,99.08 U50.47
  L5-SIGNAL2 w0.102: v2(45.77,99.33) 44.85,98.41 44.85,97.69 43.71,96.55 42.32,96.55 41.2,97.66 33.26,97.66 29,93.4 22.82,93.4 v2(22.77,93.35)
TRC_DATA10: length 32.9
  TOP w0.127: U58.36 46.06,87.23 v2(46.77,87.94)
  L5-SIGNAL2 w0.102: v2(20.66,93.35) 21.09,92.92 35.68,92.92 35.93,93.17 42.58,93.17 43.31,92.44 45.34,90.41 45.34,87.8 45.59,87.55 46.38,87.55 v2(46.77,87.94)
TRC_DATA11: length 39.2
  TOP w0.127: U58.34 45.52,88.23 v2(45.77,87.98)
  L5-SIGNAL2 w0.102: v2(22.77,94.5) 29.45,94.5 35.15,100.19 44.96,100.19 45.02,100.26 45.45,100.26 46.2,99.51 46.2,88.41 v2(45.77,87.98)
TRC_DATA12: length 29.3
  TOP w0.127: U50.43 45.52,101.08 v2(45.77,101.33)
  L5-SIGNAL2 w0.102: v2(45.77,101.33) 44.87,100.42 35,100.42 29.55,94.98 29.48,94.98 29.43,94.93 21.09,94.93 v2(20.66,94.5)
TRC_DATA13: length 28.9
  TOP w0.127: v2(43.31,105.33) 43.56,105.58 U50.34
  L5-SIGNAL2 w0.102: v2(43.31,105.33) 43.97,104.67 43.97,102.38 43.35,101.76 36.01,101.76 29.46,95.21 23.2,95.21 v2(22.77,95.64)
TRC_DATA14: length 29
  TOP w0.127: v2(41.96,102.31) 41.96,100.68 42.57,100.08 U50.45
  L5-SIGNAL2 w0.102: v2(41.96,102.31) 36.22,102.31 29.46,95.55 24.22,95.55 23.64,96.13 21.15,96.13 v2(20.66,95.64)
TRC_DATA15: length 25.8
  TOP w0.127: U50.36 43.56,104.58 v2(43.31,104.33)
  L5-SIGNAL2 w0.102: v2(43.31,104.33) 42.39,103.41 37,103.41 29.37,95.78 24.44,95.78 23.44,96.78 v2(22.77,96.78)
TRC_DATA16: length 28.2
  TOP w0.127: v2(43.31,106.33) 43.56,106.58 U50.32
  L5-SIGNAL2 w0.102: v2(20.66,96.78) 21.09,97.21 29.43,97.21 32.17,99.95 32.17,100.41 37.26,105.5 42.48,105.5 v2(43.31,106.33)
TRC_DATA17: length 43.5
  TOP w0.127: v2(45.83,82.02) 45.54,81.73 U58.47
  L5-SIGNAL2 w0.102: v2(45.83,82.02) 45.03,82.02 44.64,82.41 42.72,82.41 39.92,85.22 22.94,85.22 20.95,87.21 20.41,87.21 19.31,88.3 19.31,97.19 20.48,98.36 22.34,98.36 v2(22.77,97.92)
TRC_DATA18: length 36.3
  TOP w0.127: v2(41.99,87.23) 41.99,86.01 42.35,85.66 44.47,85.66 U58.39
  L5-SIGNAL2 w0.102: v2(41.99,87.23) 41.64,87.23 40.75,88.12 20.71,88.12 19.54,89.29 19.54,96.81 v2(20.66,97.92)
TRC_DATA19: length 56.5
  TOP w0.127: v2(45.77,102.33) 45.52,102.08 U50.41
  L5-SIGNAL2 w0.102: v2(6.95,87.15) 6.52,87.59 6.52,88.48 17.59,99.55 27.22,99.55 28.71,101.04 30.84,101.04 33.47,103.67 33.47,105.88 35.57,107.99 43.81,107.99 44.89,106.91 44.89,105.86 46.43,104.32 46.43,102.99 v2(45.77,102.33)
TRC_DATA20: length 52.6
  TOP w0.127: U50.39 45.52,103.08 v2(45.77,103.33)
  L5-SIGNAL2 w0.102: v2(45.77,103.33) 44.42,104.67 44.42,106.82 43.49,107.76 35.67,107.76 33.69,105.79 33.69,103.57 30.94,100.81 29.02,100.81 27.53,99.32 17.97,99.32 v2(6.95,88.3)
TXS0108_OE: length 1.7
  BOTTOM w0.127: R1134.2 188.88,57.46 189.02,57.32 U242.10
UART2_RXD: length 4.3
  BOTTOM w0.127: U264.5 214.76,24.54 213.44,23.22 213.39,23.22 R1251.1
UART2_TXD: length 7.6
  BOTTOM w0.127: R1228.2 217.69,26.02 217.51,25.84 U264.7 215.27,25.84 213.67,24.24 R1247.1
UART3_RXD: length 226.8
  TOP w0.127: v2(43.31,80.98) 43.56,81.23 U58.48 ; U143.4 v2(202.44,24.28)
  L12-SIGNAL5 w0.102: v2(200.54,15.55) 200.14,15.55 198.18,13.59 186.62,13.59 185.3,12.27 176.79,12.27 170.58,6.06 117.78,6.06 111.13,12.71 94.82,12.71 85.16,22.36 82.58,22.36 80.63,24.31 80.63,26.85 80.35,27.13 79.78,27.13 72.79,34.12 54.44,34.12 52.22,36.34 52.22,47.51 46.75,52.98 46.75,62.44 44.21,64.98 44.21,80.08 v2(43.31,80.98)
  BOTTOM w0.127: v2(202.44,24.28) 202.44,22.6 200.54,20.7 v2(200.54,15.55)
UART3_RXD_MUX: length 73.8
  TOP w0.127: U58.6 53.02,79.73 v2(53.27,79.98)
  L3-SIGNAL1 w0.089: v2(53.27,79.98) 56.47,83.17 71.58,83.17 77.08,77.67 77.08,76.96 78.77,75.28 79.39,75.28 81.28,73.39 82.73,73.39 86.98,69.14 89.33,69.14 92.23,66.23 98.05,66.23 v5(98.51,66.69) ; v3(111.92,73.43) v5(111.69,73.15)
  L4-GND2 w0.102: v5(111.69,73.15) v6(111.38,72.85) ; v5(98.51,66.69) v6(98.51,67.02)
  L5-SIGNAL2 w0.102: v6(98.51,67.02) 100.68,67.02 104.28,70.61 109.18,70.61 109.56,70.23 110.98,70.23 111.13,70.38 111.13,70.89 111.68,71.44 111.68,72.55 v6(111.38,72.85)
  vias: v1(111.92,73.43)
UART3_TXD: length 167.7
  TOP w0.127: U143.6 201.14,24.33 ; 201.14,24.33 R635.2 ; 201.14,24.33 v2(201.13,24.31) ; U112.6 55.37,35.9 v2(55.69,36.22)
  L3-SIGNAL1 w0.089: v2(201.13,24.31) 200.65,24.79 187.89,24.79 183.67,20.56 175.27,20.56 173.88,19.17 143.95,19.17 143.39,18.61 122.91,18.61 122.12,19.4 113.65,19.4 112.95,18.69 66.81,18.69 57.51,28 57.51,29.06 60.66,32.21 60.66,34.04 59.22,35.48 56.44,35.48 v2(55.69,36.22)
UART3_TXD_MUX: length 78.7
  TOP w0.127: U58.9 51.06,81.23 v2(50.81,80.98)
  L3-SIGNAL1 w0.089: v5(89.37,79.95) 89.72,79.59 89.72,78.21 93.84,74.09 93.84,72.24 95.85,70.23 97.6,70.23 98.37,69.46 102.64,69.46 105.62,72.44 107.72,72.44 v3(107.92,72.63)
  L4-GND2 w0.102: v5(89.37,79.95) 89.37,80.28 v6(89.36,80.28)
  L5-SIGNAL2 w0.102: v2(50.81,80.98) 51.46,81.64 53.88,81.64 55.08,82.83 61.17,82.83 62.09,83.74 72.47,83.74 75.22,86.49 75.22,87.25 78.39,90.42 84.24,90.42 84.74,89.91 84.74,86.92 85.48,86.18 85.48,85.19 86.06,84.61 86.06,82.04 87.83,80.28 v6(89.36,80.28)
  vias: v1(107.92,72.63)
UART5_RXD: length 280.7
  L3-SIGNAL1 w0.089: v3(111.12,80.63) v5(110.78,80.52)
  L4-GND2 w0.102: v5(110.78,80.52) v7(110.93,80.14)
  L12-SIGNAL5 w0.102: v2(213.55,21.39) 213.55,23.59 212.74,24.4 205.73,24.4 204.86,23.52 194.62,23.52 193.09,22 184,22 182.44,20.43 181.94,20.43 179.57,18.06 177.3,18.06 171.33,12.09 125.53,12.09 125.41,12.22 118.79,12.22 118.76,12.24 118.6,12.24 110.37,20.47 103.31,20.47 101.3,22.48 94.55,22.48 87.94,29.08 87.94,30.99 85.68,33.25 83.9,33.25 82.41,34.74 82.41,38.21 79.49,41.12 77.68,41.12 70.6,48.21 70.6,48.69 70.44,48.84 70.44,58.47 66.36,62.56 66.36,90.76 67.42,91.82 68.64,91.82 69.38,91.08 70.57,91.08 71.27,91.78 79.61,91.78 82.4,94.57 84.23,94.57 86.86,91.94 86.86,87.92 84.64,85.7 84.64,84.63 85.83,83.44 85.83,82.55 87.23,81.15 88.55,81.15 88.73,81.33 91.23,81.33 91.29,81.38 100.77,81.38 101.51,82.12 107.32,82.12 108.37,81.07 108.37,80.38 108.74,80.02 109.26,80.02 109.38,80.14 v7(110.93,80.14)
  BOTTOM w0.127: U264.4 214.49,23.89 213.55,22.94 v2(213.55,21.39)
  vias: v1(111.12,80.63)
UART5_TXD: length 282.8
  L3-SIGNAL1 w0.089: v3(111.12,79.03) v5(110.89,78.75)
  L4-GND2 w0.102: v5(110.89,78.75) v7(110.47,78.74)
  L12-SIGNAL5 w0.102: v7(110.47,78.74) 110.07,78.34 107.29,78.34 106.43,79.2 102.85,79.2 102.09,79.96 95.89,79.96 95.41,79.48 89.54,79.48 v8(89.47,79.55) ; v2(219.05,28.28) 217.47,29.85 200.31,29.85 192.74,22.27 183.88,22.27 182.26,20.65 181.85,20.65 179.48,18.28 177.17,18.28 171.2,12.32 125.82,12.32 125.69,12.44 118.88,12.44 109.89,21.44 105.19,21.44 104.94,21.18 103.21,21.18 101.63,22.76 94.95,22.76 93.72,23.99 93.72,24.66 91.38,27.01 90.6,27.01 88.26,29.35 88.26,31.23 85.33,34.16 84.46,34.16 82.69,35.94 82.69,38.43 79.74,41.38 77.88,41.38 71.53,47.73 71.53,49.17 71.36,49.35 71.36,58.01 66.58,62.79 66.58,90.53 67.51,91.46 68.57,91.46 69.22,90.81 70.7,90.81 71.43,91.54 80.22,91.54 v2(82.81,94.14)
  L13-GND5 w0.102: v8(89.47,79.55) v9(89.14,79.88)
  L14-SIGNAL6 w0.089: v2(82.81,94.14) 84.57,92.38 87,92.38 87.77,91.61 87.77,89.08 88.45,88.39 88.45,84.48 89.04,83.9 89.04,80.29 89.14,80.19 v9(89.14,79.88)
  BOTTOM w0.127: U264.6 216.58,25.2 217.79,25.2 219.05,26.46 v2(219.05,28.28)
  vias: v1(111.12,79.03)
UART6_RXD: length 11.7
  L5-SIGNAL2 w0.102: v2(22.23,32.18) 23.09,31.33 25.75,31.33 29.92,35.49 v2(29.92,37.45)
UART6_RXD_MUX: length 62.6
  TOP w0.127: v2(54.67,77.19) 54.13,77.73 U58.2
  L3-SIGNAL1 w0.089: v5(89.23,72.32) 92.99,72.32 95.51,69.8 97.43,69.8 98.19,69.04 102.88,69.04 105.67,71.83 v3(107.92,71.83)
  L4-GND2 w0.102: v5(89.23,72.32) v6(88.85,72.32)
  L5-SIGNAL2 w0.102: v2(54.67,77.19) 55.02,76.84 62.47,76.84 65.59,73.71 73.21,73.71 75.73,71.2 78.7,71.2 79.18,70.71 81.09,70.71 81.72,70.08 86.6,70.08 87.14,70.62 87.14,70.84 88.63,72.32 v6(88.85,72.32)
  vias: v1(107.92,71.83)
UART6_TXD: length 9.3
  L5-SIGNAL2 w0.102: v2(29.9,38.82) 29.12,38.04 29.12,36.5 24.8,32.18 v2(24.21,32.18)
UART6_TXD_MUX: length 61.6
  TOP w0.127: U58.4 54.48,78.73 v2(55.84,77.37)
  L3-SIGNAL1 w0.089: v3(107.92,73.43) 107.83,73.34 104.59,73.34 101.96,70.71 98.05,70.71 96.53,72.23 v5(94.92,72.23)
  L4-GND2 w0.102: v5(94.92,72.23) 94.93,72.23 v6(94.69,72.46)
  L5-SIGNAL2 w0.102: v2(55.84,77.37) 62.8,77.37 66.23,73.94 73.49,73.94 75.93,71.5 79.15,71.5 79.56,71.1 87.08,71.1 88.65,72.67 88.78,72.67 88.78,72.67 89.04,72.67 89.24,72.46 v6(94.69,72.46)
  vias: v1(107.92,73.43)
UART8_CTSN: length 246.4
  TOP w0.127: v2(49.69,100.52) 49.36,100.85 45.65,100.85 45.38,100.58 U50.44
  L12-SIGNAL5 w0.102: v2(49.69,100.52) 49.69,84.24 49.1,83.65 49.1,70.28 49.5,69.87 49.5,63.69 52.46,60.74 55.58,60.74 60.69,55.63 64.32,55.63 65.06,54.89 65.06,49.3 64.27,48.51 64.27,44.6 66.02,42.85 69.15,42.85 76.87,35.13 76.87,34.18 82.88,28.17 82.88,26.32 93.43,15.77 110.46,15.77 116.53,9.69 171.37,9.69 178.22,16.53 181.73,16.53 183.35,18.15 188.64,18.15 189.06,17.73 193.48,17.73 193.98,18.23 197.65,18.23 199.25,19.83 206.24,19.83 208.19,17.88 214.65,17.88 v2(215.22,18.46)
  BOTTOM w0.127: U273.5 v2(215.22,18.46)
UART8_CTSN_MUX: length 2.9
  TOP w0.127: R276.2 54.19,100.52 53.25,99.58 U50.11
UART8_RTSN: length 247.5
  TOP w0.127: v2(49.74,101.73) 49.59,101.58 46.15,101.58 45.95,101.77 45.59,101.77 45.39,101.58 U50.42
  L12-SIGNAL5 w0.102: v2(215.22,19.76) 215.01,19.55 215.01,19.54 213.68,18.21 208.47,18.21 206.43,20.24 193.99,20.24 192.41,18.67 191.37,18.67 191.08,18.38 183.26,18.38 181.7,16.82 178.18,16.82 171.28,9.92 116.71,9.92 108.86,17.77 91.74,17.77 83.15,26.36 83.15,28.55 80.57,31.13 80.57,31.75 69.09,43.23 66.33,43.23 64.52,45.03 64.52,48.23 65.37,49.08 65.37,55.01 64.47,55.91 60.79,55.91 55.74,60.96 52.65,60.96 49.72,63.89 49.72,69.97 49.32,70.37 49.32,83.56 50.1,84.33 50.1,101.38 v2(49.74,101.73)
  BOTTOM w0.127: U273.7 v2(215.22,19.76)
UART8_RTSN_MUX: length 3.8
  TOP w0.127: U50.13 53.21,100.58 53.98,101.35 53.98,102.2 54.11,102.33 R270.2
UART8_RXD: length 279.7
  L3-SIGNAL1 w0.089: v3(108.72,83.83) 108.45,83.83 107.95,83.33 107.79,83.33 107.12,82.66 106.52,82.66 106.23,82.38 102.97,82.38 102.25,83.11 101.73,83.11 95.21,89.63 95.21,91.03 94.5,91.75 91.65,91.75 89.75,93.65 89.75,95.88 v2(90.41,96.55)
  L12-SIGNAL5 w0.102: v2(90.41,96.55) 88.58,96.55 87.76,95.73 84.49,95.73 84.31,95.91 81.23,95.91 79.59,94.27 72.28,94.27 71.63,93.63 67.6,93.63 64.7,90.73 64.7,60.87 67.55,58.03 67.55,47.96 70.39,45.11 70.39,42.56 76.62,36.33 81.02,31.93 81.02,31.32 83.6,28.73 83.6,26.55 91.78,18.37 108.63,18.37 116.59,10.41 133.71,10.41 134.49,11.19 171.78,11.19 177.75,17.16 181.42,17.16 183.67,19.42 192.15,19.42 193.56,20.83 209.41,20.83 211.39,18.85 213.62,18.85 214.31,19.53 214.31,20.57 214.82,21.09 215.98,21.09 218.09,18.97 v2(218.09,18.37)
  BOTTOM w0.127: v2(218.09,18.37) 217.53,17.81 U273.4
  vias: v1(108.71,83.83)
UART8_TXD: length 281.6
  L3-SIGNAL1 w0.089: v3(109.52,82.23) v5(109.51,81.89)
  L4-GND2 w0.102: v5(109.51,81.89) v7(109.23,82.19)
  L12-SIGNAL5 w0.102: v7(109.23,82.19) 108.19,83.24 100.6,83.24 99.8,82.43 93.13,82.43 93.07,82.5 88.02,82.5 86.19,84.33 86.19,86.49 87.31,87.61 87.31,89.42 90.08,92.19 90.08,95.45 89.78,95.75 89.03,95.75 88.52,95.25 81.59,95.25 78.78,92.44 67.22,92.44 65.15,90.36 65.15,61.12 68.77,57.51 68.77,47.72 72.11,44.37 73.52,44.37 77.76,40.13 77.76,35.93 83.11,30.59 84.85,30.59 94.27,21.16 101.55,21.16 103.59,19.13 108.51,19.13 116.64,11 133.26,11 133.9,11.64 171.52,11.64 177.49,17.61 180.74,17.61 182.35,19.22 182.35,19.6 184.25,21.5 193.27,21.5 193.4,21.63 194.6,22.83 203.57,22.83 204.87,21.54 210.04,21.54 210.98,20.6 212.71,20.6 213.49,19.82 v2(213.49,19.77)
  BOTTOM w0.127: U273.6 214.15,19.11 v2(213.49,19.77)
  vias: v1(109.51,82.23)
UART9_RXD: length 42.1
  L14-SIGNAL6 w0.089: v2(44.25,62.46) 44.25,60.59 44.69,60.15 44.69,55.28 43.68,54.28 43.68,41.1 35.36,32.77 27.81,32.77 v2(27.22,32.18)
UART9_RXD_MUX: length 80.7
  TOP w0.127: v2(50.81,81.98) 51.06,82.23 U58.11
  L3-SIGNAL1 w0.089: v3(109.52,73.43) 109.02,72.93 107.61,72.93 107.5,72.82 104.68,72.82 101.54,69.68 98.46,69.68 97.63,70.5 96.75,70.5 96.4,70.84 96.4,71.06 96.08,71.37 95.01,71.37 94.12,72.26 94.12,74.19 89.95,78.36 v5(89.95,80.34)
  L4-GND2 w0.102: v6(89.94,80.67) 89.95,80.67 v5(89.95,80.34)
  L5-SIGNAL2 w0.102: v2(50.81,81.98) 53.87,81.98 54.97,83.08 61.07,83.08 61.96,83.97 68.39,83.97 69.6,85.19 73.49,85.19 74.99,86.69 74.99,87.34 78.29,90.65 84.33,90.65 84.97,90.01 84.97,87.1 85.78,86.28 85.78,85.24 86.34,84.69 86.34,82.09 87.76,80.67 v6(89.94,80.67)
  vias: v1(109.52,73.43)
UART9_TXD: length 42.9
  L14-SIGNAL6 w0.089: v2(45.2,62.42) 45.2,61.58 45.8,60.98 45.8,56.11 43.95,54.26 43.95,41.08 35.05,32.18 v2(29.17,32.18)
  BOTTOM w0.127: v2(45.2,62.42) 45.2,63.46 44.93,63.73 R1107.2
UART9_TXD_MUX: length 76.3
  TOP w0.127: U58.13 51.06,83.23 v2(50.81,82.98)
  L3-SIGNAL1 w0.089: v5(89.21,81.74) 90.09,81.74 90.9,80.93 90.9,80.4 98.99,72.31 98.99,71.98 99.33,71.64 100.53,71.64 101.3,72.42 102.3,72.42 104.13,74.24 107.3,74.24 107.59,74.54 109.02,74.54 v3(109.52,75.03)
  L4-GND2 w0.102: v6(88.88,81.73) 88.88,81.74 v5(89.21,81.74)
  L5-SIGNAL2 w0.102: v6(88.88,81.73) 87.42,83.19 87.42,84.07 86.04,85.45 86.04,86.41 85.2,87.25 85.2,90.1 84.43,90.87 78.2,90.87 74.75,87.43 74.75,86.83 73.39,85.47 69.45,85.47 68.18,84.2 60.46,84.2 59.67,83.41 51.24,83.41 v2(50.81,82.98)
  vias: v1(109.52,75.03)
UFS0_REF_CLK: length 83.2
  TOP w0.127: v2(130.72,91.43) 130.32,91.03 U59.AJ5
  L3-SIGNAL1 w0.089: v3(145.84,146.82) 146.28,146.82 146.48,147.02 146.48,148.34 147.16,149.01 150.6,149.01 151.07,148.53 v5(151.8,148.53)
  L4-GND2 w0.102: v5(151.8,148.53) v7(152.2,148.53)
  L12-SIGNAL5 w0.102: v7(152.2,148.53) 152.69,148.04 152.69,141.63 155.3,139.03 155.3,128.96 154.46,128.13 154.46,114.67 149.44,109.65 149.44,107.72 147.96,106.25 147.96,104.88 146.41,103.33 145.6,103.33 143.26,100.99 143.26,94.82 140.9,92.46 134.93,92.46 134.28,91.81 131.34,91.81 130.96,91.43 v2(130.72,91.43)
UFS0_RST#: length 85.9
  L3-SIGNAL1 w0.089: v5(151.8,149.23) 146.95,149.23 146.08,148.37 146.08,147.5 145.9,147.32 v3(145.84,147.32) ; v3(128.72,91.03) v5(128.94,91.31)
  L4-GND2 w0.102: v5(128.94,91.31) v7(129.25,91.62) ; v5(151.8,149.23) v7(152.2,149.23)
  L12-SIGNAL5 w0.102: v7(129.25,91.62) 129.81,91.06 134.22,91.06 134.5,91.34 134.5,91.64 135.09,92.23 141.01,92.23 143.54,94.76 143.54,100.86 145.78,103.1 146.51,103.1 148.19,104.78 148.19,106.16 149.66,107.63 149.66,109.55 154.69,114.58 154.69,128.04 155.52,128.87 155.52,139.12 152.92,141.72 152.92,148.52 v7(152.2,149.23)
  vias: v1(128.72,91.03)
UFS0_RX0_N: length 73.5
  L3-SIGNAL1 w0.079: v5(147.18,146.82) v3(146.84,146.82) ; v3(130.32,91.83) v5(130.54,92.11)
  L4-GND2 w0.089: v5(130.54,92.11) v7(130.85,92.42) ; v5(147.18,146.82) v7(147.57,146.71)
  L12-SIGNAL5 w0.089: v7(130.85,92.42) 130.85,92.09 arc(130.88,92.01) 130.97,91.97 131.12,91.97 arc(131.21,92.01) 131.25,92.1 131.25,92.43 arc(131.31,92.57) 131.44,92.62 131.66,92.62 arc(132,92.69) 132.29,92.88 133.45,94.04 arc(133.62,94.16) 133.83,94.2 134.25,94.2 arc(134.42,94.17) 134.56,94.07 134.87,93.76 arc(135.25,93.51) 135.7,93.42 137.32,93.42 arc(138.86,94.06) 139.49,95.59 139.49,98.29 arc(139.6,98.83) 139.9,99.28 144.46,103.84 arc(144.63,103.95) 144.83,103.99 145.35,103.99 arc(145.72,104.14) 145.87,104.51 145.87,105.83 arc(145.94,106.18) 146.14,106.47 146.49,106.82 arc(146.79,107.28) 146.9,107.82 146.9,108.71 arc(147.03,109.37) 147.41,109.94 150.6,113.13 arc(151.11,113.89) 151.29,114.8 151.29,117.3 arc(151.42,117.92) 151.77,118.45 152.85,119.53 arc(153.28,120.18) 153.43,120.94 153.43,130.61 arc(153.27,131.4) 152.83,132.07 148.39,136.51 arc(148.02,137.06) 147.89,137.72 147.89,144.68 arc(147.83,144.98) 147.65,145.24 147.05,145.85 arc(146.95,145.99) 146.92,146.15 146.92,146.77 arc(146.98,146.9) 147.11,146.96 147.32,146.96 arc(147.5,146.89) v7(147.57,146.71)
  vias: v1(130.32,91.83)
UFS0_RX0_P: length 73.5
  L3-SIGNAL1 w0.079: v3(129.52,91.83) v5(129.74,92.11) ; v5(147.18,147.32) v3(146.84,147.32)
  L4-GND2 w0.089: v5(147.18,147.32) v7(147.57,147.42) ; v5(129.74,92.11) v7(130.05,92.42)
  L12-SIGNAL5 w0.089: v7(130.05,92.42) 130.21,92.58 arc(130.5,92.77) 130.84,92.84 131.66,92.84 arc(131.91,92.89) 132.13,93.03 133.29,94.2 arc(133.54,94.36) 133.83,94.42 134.25,94.42 arc(134.5,94.37) 134.72,94.22 135.02,93.92 arc(135.33,93.71) 135.7,93.64 137.32,93.64 arc(138.7,94.21) 139.28,95.59 139.28,98.29 arc(139.4,98.91) 139.75,99.43 144.31,103.99 arc(144.54,104.15) 144.83,104.2 145.35,104.2 arc(145.57,104.29) 145.66,104.51 145.66,105.83 arc(145.74,106.26) 145.99,106.62 146.34,106.97 arc(146.59,107.36) 146.68,107.82 146.68,108.71 arc(146.83,109.46) 147.26,110.09 150.45,113.28 arc(150.91,113.97) 151.07,114.8 151.07,117.3 arc(151.22,118) 151.62,118.61 152.7,119.69 arc(153.08,120.26) 153.22,120.94 153.22,130.61 arc(153.08,131.32) 152.67,131.92 148.24,136.35 arc(147.82,136.98) 147.67,137.72 147.67,144.68 arc(147.63,144.9) 147.5,145.09 146.89,145.7 arc(146.76,145.91) 146.71,146.15 146.71,146.77 arc(146.82,147.06) 147.11,147.17 147.32,147.17 arc(147.5,147.25) v7(147.57,147.42)
  vias: v1(129.52,91.83)
UFS0_RX1_N: length 81.8
  L3-SIGNAL1 w0.079: v5(148.18,146.82) v3(147.84,146.82) ; v3(131.12,92.63) v5(131.34,92.91)
  L4-GND2 w0.089: v5(148.18,146.82) v7(148.57,146.71) ; v5(131.34,92.91) v7(131.65,93.22)
  L12-SIGNAL5 w0.089: v7(148.57,146.71) 148.15,147.13 arc(148.08,147.24) 148.05,147.37 148.05,148.35 arc(147.98,148.7) 147.79,149 arc(147.61,149.26) 147.54,149.58 147.54,150.52 arc(147.44,150.78) 147.18,150.89 144.86,150.89 arc(144.48,150.96) 144.15,151.18 arc(144.08,151.23) 144,151.24 142.53,151.24 arc(141.82,150.95) 141.52,150.24 141.52,147.98 arc(141.55,147.83) 141.64,147.7 142.03,147.31 arc(142.28,146.95) 142.36,146.52 142.36,139.07 arc(142.72,137.27) 143.74,135.74 148.88,130.6 arc(149.54,129.61) 149.77,128.45 149.77,122.36 arc(149.65,121.77) 149.32,121.27 148.18,120.13 arc(147.97,119.82) 147.9,119.45 147.9,116.23 arc(147.73,115.38) 147.25,114.67 143.26,110.68 arc(142.91,110.16) 142.79,109.54 142.79,108.89 arc(142.7,108.45) 142.45,108.08 141.75,107.38 141.36,106.99 arc(141.13,106.64) 141.04,106.22 141.04,104.23 arc(140.89,103.48) 140.47,102.84 137.84,100.21 arc(137.62,100.06) 137.36,100.01 136.43,100.01 arc(136.19,99.96) 135.98,99.83 134.6,98.45 arc(134.39,98.31) 134.15,98.26 132.8,98.26 arc(132.48,98.2) 132.21,98.02 131.8,97.6 arc(131.64,97.36) 131.58,97.08 131.58,94.95 arc(131.54,94.74) 131.42,94.56 131.36,94.5 arc(131.3,94.41) 131.28,94.31 131.28,93.7 arc(131.3,93.59) 131.37,93.5 v7(131.65,93.22)
  vias: v1(131.12,92.63)
