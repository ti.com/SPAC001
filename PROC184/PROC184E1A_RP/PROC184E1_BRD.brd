# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSI1_TX1_P: length 122.5
  TOP w0.127: v3(72.09,184.95) 72.09,186.32 J10.13
  L3-SIGNAL1 w0.084: v3(111.92,92.63) v5(111.64,92.86) ; v3(72.09,184.95) arc(72.02,184.85) 72,184.72 72,183.34 arc(72.04,183.15) 72.14,182.99 72.25,182.89 arc(72.45,182.58) 72.52,182.22 72.52,178.97 arc(72.55,178.81) v5(72.65,178.67)
  L4-GND2 w0.084: v5(72.65,178.67) v7(72.71,178.25) ; v5(111.64,92.86) v7(111.33,93.17)
  L12-SIGNAL5 w0.102: v7(72.71,178.25) 72.63,178.17 arc(72.61,178.14) 72.6,178.1 72.6,177.12 arc(72.7,176.88) 72.93,176.78 74.07,176.78 arc(74.29,176.83) 74.47,176.95 75.92,178.39 arc(76.67,178.89) 77.55,179.07 80.27,179.07 arc(82.01,178.35) 82.74,176.6 82.74,173.31 arc(82.62,172.74) 82.3,172.26 arc(81.59,171.2) 81.34,169.95 81.34,164.06 arc(81.17,163.65) 80.75,163.47 79.84,163.47 arc(79.48,163.33) 79.33,162.97 79.33,162.23 arc(79.49,161.85) 79.87,161.7 80.68,161.7 arc(81.15,161.5) 81.34,161.04 81.34,149.88 arc(81.22,149.23) 80.85,148.69 80.74,148.58 arc(80.51,148.23) 80.42,147.81 80.42,145.14 arc(80.54,144.55) 80.88,144.05 85.86,139.07 arc(86.21,138.54) 86.34,137.92 86.34,137.14 arc(86.43,136.65) 86.71,136.23 90.9,132.04 arc(91.21,131.58) 91.32,131.03 91.32,129.73 arc(91.47,129.01) 91.88,128.4 104.16,116.11 arc(104.73,115.26) 104.93,114.25 104.93,104.19 arc(105.04,103.66) 105.34,103.2 108.1,100.44 arc(108.71,99.53) 108.92,98.46 108.92,95.09 arc(108.97,94.84) 109.12,94.63 109.96,93.78 arc(110.05,93.72) 110.16,93.7 110.4,93.7 arc(110.77,93.63) 111.08,93.42 v7(111.33,93.17)
  vias: v1(111.91,92.63)
CSI1_TX2_N: length 122.6
  TOP w0.127: J10.19 70.07,186.32 v3(70.07,184.95)
  L3-SIGNAL1 w0.084: v3(111.92,93.43) v5(111.64,93.66) ; v5(70.57,180.89) arc(70.61,180.95) 70.62,181.02 70.62,182.25 arc(70.57,182.52) 70.41,182.76 arc(70.23,183.02) 70.17,183.34 70.17,184.72 arc(70.14,184.85) v3(70.07,184.95)
  L4-GND2 w0.084: v5(111.64,93.66) v7(111.33,93.97) ; v7(70.46,180.51) v5(70.57,180.89)
  L12-SIGNAL5 w0.102: v7(111.33,93.97) 111.36,94 arc(111.5,94.21) 111.55,94.46 111.55,96.68 arc(111.49,96.99) 111.31,97.26 110.58,97.99 arc(110.33,98.37) 110.24,98.81 110.24,102.41 arc(110.3,102.71) 110.47,102.97 111.48,103.98 arc(111.6,104.15) 111.64,104.36 111.64,108.5 arc(111.6,108.73) 111.47,108.93 110.53,109.86 arc(110.07,110.56) 109.9,111.38 109.9,112.46 arc(109.81,112.91) 109.56,113.29 93.79,129.06 arc(93.15,130.02) 92.92,131.16 92.92,131.25 arc(92.76,132.08) 92.29,132.77 91.3,133.77 arc(90.65,134.73) 90.43,135.87 90.43,139.56 arc(90.12,141.09) 89.25,142.4 84.78,146.86 arc(83.02,149.51) 82.4,152.62 82.4,169.44 arc(82.53,170.1) 82.9,170.66 83.33,171.09 83.75,171.52 arc(83.94,171.79) 84.01,172.12 84.01,178.14 arc(83.94,178.46) 83.76,178.74 80.37,182.12 arc(80.06,182.33) 79.7,182.4 76.04,182.4 arc(75.7,182.34) 75.42,182.15 75.24,181.97 arc(75,181.61) 74.91,181.18 74.91,179.77 arc(74.7,179.26) 74.18,179.05 71.37,179.05 arc(70.9,179.24) 70.71,179.71 70.71,180.22 arc(70.7,180.26) 70.68,180.29 v7(70.46,180.51)
  vias: v1(111.91,93.43)
CSI1_TX2_P: length 122.6
  TOP w0.127: v3(70.59,184.95) 70.59,186.32 J10.17
  L3-SIGNAL1 w0.084: v3(112.72,93.43) v5(112.44,93.66) ; v5(71.07,180.89) arc(70.98,181.02) 70.95,181.17 70.95,182.25 arc(70.87,182.65) 70.64,182.99 arc(70.54,183.15) 70.5,183.34 70.5,184.72 arc(70.52,184.85) v3(70.59,184.95)
  L4-GND2 w0.084: v7(71.17,180.51) v5(71.07,180.89) ; v5(112.44,93.66) v7(112.13,93.97)
  L12-SIGNAL5 w0.102: v7(112.13,93.97) 112.1,94 arc(111.96,94.21) 111.91,94.46 111.91,96.68 arc(111.82,97.13) 111.57,97.51 110.83,98.24 arc(110.66,98.5) 110.6,98.81 110.6,102.41 arc(110.63,102.58) 110.72,102.72 111.73,103.72 arc(111.93,104.02) 112,104.36 112,108.5 arc(111.92,108.87) 111.72,109.18 110.79,110.11 arc(110.4,110.69) 110.26,111.38 110.26,112.46 arc(110.14,113.04) 109.81,113.54 94.04,129.31 arc(93.48,130.16) 93.28,131.16 93.28,131.25 arc(93.09,132.21) 92.55,133.02 91.55,134.02 arc(90.98,134.87) 90.78,135.87 90.78,139.56 arc(90.45,141.23) 89.5,142.65 85.04,147.12 arc(83.35,149.64) 82.75,152.62 82.75,169.44 arc(82.86,169.97) 83.16,170.41 84.01,171.26 arc(84.27,171.66) 84.36,172.12 84.36,178.14 arc(84.27,178.6) 84.01,178.99 80.62,182.38 arc(80.2,182.66) 79.7,182.76 76.04,182.76 arc(75.57,182.67) 75.17,182.4 74.99,182.22 arc(74.67,181.74) 74.56,181.18 74.56,179.77 arc(74.45,179.51) 74.18,179.4 71.37,179.4 arc(71.15,179.49) 71.06,179.71 71.06,180.36 arc(71.07,180.4) 71.09,180.43 v7(71.17,180.51)
  vias: v1(112.71,93.43)
CSI1_TX3_N: length 122.7
  TOP w0.127: J10.23 68.57,186.32 v3(68.57,184.95)
  L3-SIGNAL1 w0.084: v3(112.72,94.23) v5(112.44,94.46) ; v3(68.57,184.95) v5(68.58,184.63)
  L4-GND2 w0.084: v5(112.44,94.46) v7(112.74,94.77) ; v5(68.58,184.63) v7(68.48,184.24)
  L12-SIGNAL5 w0.102: v7(68.48,184.24) 68.52,184.2 arc(68.62,184.05) 68.66,183.88 68.66,183.26 arc(68.82,182.87) 69.21,182.7 73.15,182.7 arc(73.48,182.77) 73.75,182.95 74.45,183.65 arc(74.87,183.93) 75.37,184.03 78.55,184.03 arc(80.12,183.72) 81.46,182.82 84.49,179.8 arc(85.11,178.87) 85.32,177.77 85.32,171.2 arc(85.22,170.7) 84.94,170.27 84.74,170.07 arc(84.43,169.62) 84.33,169.08 84.33,152.89 arc(84.62,151.4) 85.47,150.14 85.87,149.73 arc(86.36,149.53) 86.85,149.73 87.2,150.08 arc(87.44,150.18) 87.67,150.08 arc(87.77,149.85) 87.67,149.61 87.32,149.26 arc(87.12,148.77) 87.32,148.28 92.76,142.85 arc(93.52,141.71) 93.78,140.37 93.78,135.36 arc(94.33,132.6) 95.9,130.25 102.54,123.61 arc(102.97,123.32) 103.48,123.22 104.42,123.22 arc(104.92,123.12) 105.34,122.84 111.15,117.03 arc(112.44,115.09) 112.89,112.81 112.89,102.54 arc(112.84,102.24) 112.66,101.98 112.15,101.47 arc(111.87,101.05) 111.77,100.54 111.77,99.67 arc(111.84,99.32) 112.03,99.03 112.61,98.45 arc(112.87,98.06) 112.96,97.6 112.96,95.26 arc(112.91,95.01) 112.77,94.8 v7(112.74,94.77)
  vias: v1(112.71,94.23)
CSI1_TX3_P: length 122.7
  TOP w0.127: J10.21 69.09,186.32 v3(69.09,184.95)
  L3-SIGNAL1 w0.084: v3(69.09,184.95) v5(69.08,184.63) ; v3(113.52,94.23) v5(113.24,94.46)
  L4-GND2 w0.084: v5(113.24,94.46) v7(113.54,94.77) ; v5(69.08,184.63) v7(69.19,184.24)
  L12-SIGNAL5 w0.102: v7(69.19,184.24) 69.14,184.2 arc(69.05,184.05) 69.01,183.88 69.01,183.26 arc(69.07,183.12) 69.21,183.06 73.08,183.06 arc(73.34,183.11) 73.55,183.25 74.2,183.9 arc(74.74,184.26) 75.37,184.39 78.55,184.39 arc(80.26,184.05) 81.71,183.07 84.74,180.05 arc(85.43,179) 85.68,177.77 85.68,171.2 arc(85.55,170.56) 85.19,170.02 84.99,169.82 arc(84.76,169.48) 84.68,169.08 84.68,152.89 arc(84.95,151.54) 85.72,150.39 86.12,149.99 arc(86.36,149.89) 86.6,149.99 86.95,150.34 arc(87.44,150.54) 87.93,150.34 arc(88.13,149.85) 87.93,149.36 87.58,149.01 arc(87.48,148.77) 87.58,148.53 93.01,143.1 arc(93.84,141.85) 94.14,140.37 94.14,135.36 arc(94.66,132.73) 96.15,130.51 102.8,123.86 arc(103.11,123.65) 103.48,123.58 104.42,123.58 arc(105.05,123.45) 105.59,123.09 111.4,117.28 arc(112.77,115.23) 113.25,112.81 113.25,102.54 arc(113.16,102.1) 112.92,101.73 112.4,101.22 arc(112.2,100.91) 112.12,100.54 112.12,99.67 arc(112.17,99.46) 112.29,99.28 112.86,98.7 arc(113.2,98.2) 113.32,97.6 113.32,95.26 arc(113.37,95.01) 113.51,94.8 v7(113.54,94.77)
  vias: v1(113.51,94.23)
CSI1_TXCLK_N: length 122.6
  TOP w0.127: J10.7 74.57,186.32 v3(74.57,184.95)
  L3-SIGNAL1 w0.084: v3(109.52,91.03) v5(109.24,91.26) ; v3(74.57,184.95) arc(74.64,184.85) 74.67,184.72 74.67,183.36 arc(74.73,183.04) 74.91,182.77 74.93,182.75 arc(75.08,182.52) 75.14,182.25 75.14,175.14 arc(74.96,174.7) 74.52,174.52 72.82,174.52 arc(72.16,174.25) 71.89,173.59 71.89,173 arc(71.85,172.84) v5(71.76,172.7)
  L4-GND2 w0.084: v5(71.76,172.7) v7(71.7,172.29) ; v5(109.24,91.26) v7(108.93,91.57)
  L12-SIGNAL5 w0.102: v7(71.7,172.29) 71.85,172.13 arc(71.88,172.09) 71.89,172.03 71.89,161.7 arc(71.64,161.1) 71.05,160.86 70.7,160.86 arc(70.07,160.6) 69.81,159.97 69.81,158.94 arc(70.08,158.27) 70.75,157.99 71.36,157.99 arc(71.73,157.83) 71.89,157.46 71.89,156.74 arc(71.79,156.49) 71.54,156.39 70.91,156.39 arc(70.21,155.7) 70.91,155.01 71.84,155.01 arc(72.18,154.67) 71.84,154.33 70.91,154.33 arc(70.21,153.64) 70.91,152.95 71.84,152.95 arc(72.08,152.85) 72.18,152.61 72.18,147.98 arc(72.38,146.96) 72.96,146.09 80.73,138.32 arc(81.1,137.76) 81.24,137.11 81.24,135.74 arc(81.43,134.78) 81.97,133.97 85.4,130.53 arc(85.72,130.06) 85.84,129.49 85.84,127.92 arc(86.02,126.99) 86.55,126.19 99.7,113.04 arc(100.41,111.98) 100.66,110.73 100.66,99.4 arc(100.85,98.42) 101.41,97.58 105.3,93.69 arc(105.6,93.49) 105.95,93.42 106.42,93.42 arc(106.6,93.39) 106.75,93.28 107.43,92.61 arc(107.47,92.51) 107.43,92.41 arc(107.38,92.3) 107.43,92.2 107.44,92.19 arc(107.54,92.15) 107.64,92.19 arc(107.75,92.23) 107.85,92.19 108.11,91.93 arc(108.31,91.79) 108.56,91.75 108.71,91.75 arc(108.75,91.74) 108.78,91.72 v7(108.93,91.57)
  vias: v1(109.51,91.03)
CSI1_TXCLK_P: length 122.6
  TOP w0.127: v3(75.09,184.95) 75.09,186.32 J10.5
  L3-SIGNAL1 w0.084: v3(110.32,91.03) v5(110.04,91.26) ; v5(72.34,172.7) arc(72.25,172.84) 72.22,173 72.22,173.59 arc(72.39,174.02) 72.82,174.19 74.52,174.19 arc(75.19,174.47) 75.47,175.14 75.47,182.25 arc(75.39,182.65) 75.17,182.98 75.15,183 arc(75.04,183.17) 75,183.36 75,184.72 arc(75.02,184.85) v3(75.09,184.95)
  L4-GND2 w0.084: v5(72.34,172.7) v7(72.41,172.29) ; v5(110.04,91.26) v7(109.73,91.57)
  L12-SIGNAL5 w0.102: v7(109.73,91.57) 109.48,91.82 arc(109.17,92.03) 108.8,92.1 108.56,92.1 arc(108.45,92.12) 108.36,92.18 108.25,92.29 107.01,93.54 arc(106.74,93.71) 106.42,93.78 105.95,93.78 arc(105.74,93.82) 105.55,93.94 101.67,97.83 arc(101.18,98.55) 101.01,99.4 101.01,110.73 arc(100.74,112.12) 99.95,113.3 93.38,119.87 86.8,126.44 arc(86.35,127.12) 86.19,127.92 86.19,129.49 arc(86.05,130.19) 85.65,130.79 82.22,134.22 arc(81.75,134.92) 81.59,135.74 81.59,137.11 arc(81.43,137.9) 80.98,138.57 73.21,146.34 arc(72.71,147.09) 72.53,147.98 72.53,152.61 arc(72.33,153.1) 71.84,153.3 70.91,153.3 arc(70.57,153.64) 70.91,153.98 71.84,153.98 arc(72.53,154.67) 71.84,155.36 70.91,155.36 arc(70.57,155.7) 70.91,156.03 71.54,156.03 arc(72.04,156.24) 72.25,156.74 72.25,157.46 arc(71.99,158.08) 71.36,158.34 70.75,158.34 arc(70.34,158.52) 70.16,158.94 70.16,159.97 arc(70.32,160.35) 70.7,160.5 71.05,160.5 arc(71.9,160.85) 72.25,161.7 72.25,171.91 arc(72.29,172.11) 72.4,172.28 v7(72.41,172.29)
  vias: v1(110.31,91.03)
CSI2_A_GPIO0_DV: length 33
  TOP w0.127: U80.4 196.53,57.75 v2(196.66,57.62)
  L14-SIGNAL6 w0.089: v2(212.69,38.14) 212.07,37.51 209.41,37.51 208.92,38 208.92,44.07 197.33,55.66 197.33,56.95 v2(196.66,57.62)
  BOTTOM w0.127: J57.6 213.19,37.98 213.03,38.14 v2(212.69,38.14)
CSI2_A_GPIO1_DV: length 33.5
  L14-SIGNAL6 w0.089: v2(212.69,34.91) 210.34,37.26 209.28,37.26 208.72,37.82 208.72,43.94 197.89,54.77 v2(196.66,54.77)
  BOTTOM w0.127: U242.1 195.16,57.32 195.46,57.02 195.46,55.76 196.45,54.77 v2(196.66,54.77) ; J57.8 v2(212.69,34.91)
CSI2_A_GPIO2_DV: length 28.4
  L14-SIGNAL6 w0.089: v2(193.41,55.48) 194.72,54.17 198.18,54.17 208.19,44.16 v2(208.19,38.14)
  BOTTOM w0.127: U242.3 v2(193.41,55.48) ; v2(208.19,38.14) 208.53,38.14 208.69,37.98 J57.18
CSI2_A_GPIO3_DV: length 33.6
  L14-SIGNAL6 w0.089: v2(208.19,34.91) 206.27,36.84 206.27,38.6 207.5,39.83 207.5,44.2 198.01,53.68 194.2,53.68 193.87,54.02 192.86,54.02 v2(192.41,54.47)
  BOTTOM w0.127: v2(192.41,54.47) 192.91,54.97 U242.4 ; J57.20 v2(208.19,34.91)
CSI2_A_GPIO4_DV: length 29.5
  L14-SIGNAL6 w0.089: v2(206.69,38.14) 207.78,39.22 207.78,44.27 198.08,53.97 194.51,53.97 193.59,54.89 193,54.89 v2(192.41,55.48)
  BOTTOM w0.127: J57.22 207.19,37.98 207.03,38.14 v2(206.69,38.14) ; U242.5 v2(192.41,55.48)
CSI2_A_REFCLK_DV: length 31.8
  TOP w0.127: U80.5 194.71,58.4 v2(196.62,58.4)
  L14-SIGNAL6 w0.089: v2(196.62,58.4) 197.6,57.42 197.6,55.69 209.18,44.12 209.18,38.05 209.52,37.71 210.77,37.71 v2(211.19,38.14)
  BOTTOM w0.127: v2(211.19,38.14) 211.53,38.14 211.69,37.98 J57.10
CSI2_B_GPIO1_DV: length 63.4
  L14-SIGNAL6 w0.089: v2(191.41,54.47) 191.01,54.07 190.24,54.07 189.74,54.57 189.74,62.77 191.48,64.52 193.09,64.52 194.88,66.31 199.15,66.31 206.64,73.8 206.64,90.96 209.19,93.5 214,93.5 v2(215.68,91.82)
  BOTTOM w0.127: v2(191.41,54.47) 191.91,54.97 U242.6 ; J55.8 v2(215.68,91.82)
CSI2_B_GPIO2_DV: length 51.5
  L14-SIGNAL6 w0.089: v2(211.89,91.82) 208.77,88.7 208.77,87.22 207.25,85.7 207.25,73.55 204.84,71.14 197.61,63.91 192.29,63.91 192.2,63.82 192.2,63.24 191.97,63.01 191.64,63.01 190.46,61.83 190.46,58.87 190.46,57.6 190.46,56.43 v2(191.41,55.48)
  BOTTOM w0.127: v2(211.89,91.82) 211.68,91.61 J55.18 ; U242.7 v2(191.41,55.48)
CSI2_B_GPIO3_DV: length 55
  L14-SIGNAL6 w0.089: v2(210.97,91.82) 210.57,92.22 209.27,92.22 206.85,89.79 206.85,73.72 198.45,65.33 194.86,65.33 193.84,64.31 191.57,64.31 190.75,63.5 189.94,62.69 189.94,54.94 v2(190.41,54.47)
  BOTTOM w0.127: v2(190.41,54.47) 190.91,54.97 U242.8 ; J55.20 211.18,91.61 v2(210.97,91.82)
CSI2_B_GPIO4_DV: length 50.9
  L14-SIGNAL6 w0.089: v2(209.68,91.82) 208.09,90.23 208.09,87.02 207.05,85.98 207.05,73.64 197.52,64.11 191.65,64.11 190.14,62.6 190.14,55.75 v2(190.41,55.48)
  BOTTOM w0.127: v2(209.68,91.82) 210.02,91.82 210.18,91.66 J55.22 ; U242.9 v2(190.41,55.48)
CSI2_B_REFCLK_DV: length 46.3
  TOP w0.127: v2(198.61,58.69) 198.25,59.05 U80.6
  L14-SIGNAL6 w0.089: v2(198.61,58.69) 198.05,59.25 198.05,60.53 201.79,64.27 201.79,67.71 207.45,73.38 207.45,85.37 212.57,90.49 212.85,90.49 v2(214.18,91.82)
  BOTTOM w0.127: J55.10 214.68,91.66 214.52,91.82 v2(214.18,91.82)
CSI2_EXP_A_GPIO0: length 24.4
  TOP w0.127: v2(197.01,66.81) 196.57,66.37 U76.3 ; U80.13 187.3,57.75 186.85,58.2 v2(186.85,58.71)
  L3-SIGNAL1 w0.089: v2(197.01,66.81) 196.12,66.81 195.4,67.54 188.98,67.54 186.2,64.76 186.2,59.36 v2(186.85,58.71)
CSI2_EXP_A_GPIO1: length 10
  TOP w0.127: U76.4 v2(195.15,66.87)
  BOTTOM w0.127: U242.20 195.07,58.82 195.28,59.04 195.28,61.37 195.59,61.68 195.59,66.43 v2(195.15,66.87)
CSI2_EXP_A_GPIO2: length 231.6
  TOP w0.127: v2(45.77,107.33) 45.52,107.08 U50.31
  L5-SIGNAL2 w0.102: v2(50.35,45.44) 51.42,45.44 56.94,39.92 74.45,39.92 75.99,41.46 82.93,41.46 83.24,41.15 87.73,41.15 89.86,39.01 109.56,39.01 110.7,37.87 131.83,37.87 132.96,39 174.17,39 184.26,49.09 184.26,51.87 189.57,57.18 189.57,57.99 191.69,60.11 192.86,60.11 v2(193.41,60.66)
  L12-SIGNAL5 w0.102: v2(50.35,45.44) 49.31,45.44 39.79,54.96 39.79,70.21 42.42,72.84 42.42,74.65 41.72,75.35 41.72,78.04 41.72,78.04 41.72,80.06 41.53,80.25 41.53,96.43 46.2,101.1 46.2,106.9 v2(45.77,107.33)
  BOTTOM w0.127: U242.18 v2(193.41,60.66)
CSI2_EXP_A_GPIO3: length 12.4
  TOP w0.127: U76.5 193.6,68.84 v2(193.1,69.34)
  BOTTOM w0.127: v2(193.1,69.34) 194.09,68.34 194.09,64.93 193.61,64.45 193.61,62.17 192.91,61.48 U242.17
CSI2_EXP_A_GPIO4: length 230.6
  TOP w0.127: U50.29 45.52,108.08 v2(45.77,108.33)
  L5-SIGNAL2 w0.102: v2(50.31,46.93) 57.09,40.15 74.31,40.15 75.84,41.69 83.02,41.69 83.34,41.37 87.82,41.37 89.88,39.32 116.75,39.32 117.15,38.91 131.1,38.91 131.92,39.73 174.58,39.73 183.92,49.07 183.92,51.86 189.26,57.2 189.26,58 191.92,60.66 v2(192.41,60.66)
  L12-SIGNAL5 w0.102: v2(45.77,108.33) 46.43,107.67 46.43,100.9 44.44,98.92 44.44,88.75 41.76,86.07 41.76,80.34 41.95,80.15 41.95,75.44 42.64,74.74 42.64,72.75 40.02,70.12 40.02,55.05 48.13,46.93 v2(50.31,46.93)
  BOTTOM w0.127: U242.16 v2(192.41,60.66)
CSI2_EXP_B_GPIO1: length 12.4
  TOP w0.127: U76.7 192.6,68.84 v2(192.1,69.34)
  BOTTOM w0.127: U242.15 191.91,62.65 192.25,62.99 192.25,64.61 191.68,65.18 191.68,66.94 192.54,67.8 192.54,68.89 v2(192.1,69.34)
CSI2_EXP_B_GPIO2: length 9.8
  TOP w0.127: U76.8 v2(192.1,68.42)
  BOTTOM w0.127: U242.14 191.41,62.59 191.36,62.64 191.36,67.69 v2(192.1,68.42)
CSI2_EXP_B_GPIO3: length 8.2
  TOP w0.127: U76.9 v2(190.54,66.87)
  BOTTOM w0.127: U242.13 190.91,62.75 191,62.85 191,66.41 v2(190.54,66.87)
CSI2_EXP_B_GPIO4: length 9.4
  TOP w0.127: v2(189.63,66.87) 190.13,66.37 U76.10
  BOTTOM w0.127: U242.12 190.41,62.34 190.05,62.69 190.05,66.45 v2(189.63,66.87)
CSI2_EXP_RSTZ: length 18.4
  TOP w0.127: U80.10 187.33,59.7 R469.2 ; U76.2 v2(195.15,65.87)
  L3-SIGNAL1 w0.089: v2(195.15,65.87) 193.7,67.32 189.17,67.32 186.41,64.56 186.41,60.49 v2(187.28,59.62)
CSI2_I2C_SCL_DV: length 63.8
  TOP w0.127: v2(211.23,51.11) 210.67,50.55 U88.3
  L14-SIGNAL6 w0.089: v2(214.19,38.14) 210.47,41.87 210.47,50.34 v2(211.23,51.11) 211.8,51.68 211.8,68.92 217.36,74.48 217.36,91.3 v2(217.89,91.82)
  BOTTOM w0.127: J57.2 214.69,37.98 214.53,38.14 v2(214.19,38.14) ; v2(217.89,91.82) 217.68,91.61 J55.2
CSI2_I2C_SDA_DV: length 66.7
  TOP w0.127: U88.4 210.03,51.2 210.4,51.57 210.55,51.57 v2(211.23,52.26)
  L14-SIGNAL6 w0.089: v2(216.97,91.82) 216.97,91.56 217.16,91.38 217.16,74.66 211.6,69.1 211.6,52.62 v2(211.23,52.26) 210.26,51.28 210.26,41.7 213.45,38.51 213.45,35.65 v2(214.19,34.91)
  BOTTOM w0.127: v2(216.97,91.82) 217.18,91.61 J55.4 ; J57.4 v2(214.19,34.91)
CSI2_REFCLK: length 240.1
  TOP w0.127: v3(86.54,152.65) 86.54,152.31 86.66,152.18 R131.2 ; U80.11 188.2,59.05 v2(187.87,58.72) 188.19,58.4 U80.12
  L3-SIGNAL1 w0.089: v2(157.94,173.73) 157.1,173.73 155.15,171.77 141.27,171.77 138.75,169.26 133.23,169.26 132.54,169.94 129.67,169.94 128.89,170.72 127.1,170.72 125.9,169.52 114.33,169.52 113.9,169.94 104.33,169.94 103.33,168.93 103.33,168.55 100.21,165.43 100.21,165.43 100.17,165.39 99.78,165.39 99.78,165.38 99.55,165.15 87.05,152.65 v3(86.54,152.65)
  L12-SIGNAL5 w0.102: v2(157.94,173.73) 157.54,173.73 156.48,172.67 156.48,171.19 157.12,170.55 158.69,170.55 159.8,169.44 159.8,166.92 160.82,165.91 162.5,165.91 162.69,165.73 162.69,163.48 163.19,162.97 163.19,162.56 162.04,161.4 160.51,161.4 157.03,157.92 155.57,157.92 153.63,155.98 153.63,141.92 156.61,138.94 156.61,124.65 159.27,122 159.27,112.12 162.3,109.08 176.4,109.08 181.04,104.44 181.04,96.29 186.11,91.22 186.11,88.06 193.84,80.34 193.84,63.65 193.12,62.94 192.1,62.94 v2(187.87,58.72)
CSI2_RSTZ_DV: length 72.7
  TOP w0.127: v2(198.61,59.77) 198.67,59.77 198.66,59.78 R471.1
  L14-SIGNAL6 w0.089: v2(209.69,38.14) 209.69,44.8 199.42,55.07 199.42,58.95 v2(198.61,59.77) 198.61,60.71 201.99,64.1 201.99,67.63 207.66,73.29 207.66,85.17 212.63,90.14 213.27,90.14 214.58,91.46 214.58,91.66 214.58,91.99 214.35,92.22 213.08,92.22 v2(212.68,91.82)
  BOTTOM w0.127: J55.14 213.18,91.66 213.02,91.82 v2(212.68,91.82) ; v2(209.69,38.14) 210.03,38.14 210.19,37.98 J57.14
CSI2_RX0_N: length 209
  L3-SIGNAL1 w0.084: v2(214.07,79.54) 214.24,79.37 arc(214.26,79.34) 214.26,79.31 214.26,77.88 arc(214.11,77.11) 213.68,76.46 213.25,76.04 arc(213,75.66) 212.91,75.21 212.91,68.44 arc(212.61,67.71) 211.88,67.41 203.13,67.41 arc(202.36,67.73) 202.04,68.5 202.04,74.38 arc(201.93,74.91) 201.63,75.36 200.74,76.26 arc(200.59,76.48) 200.54,76.73 200.54,86.39 arc(200.34,87.4) 199.77,88.25 arc(199.26,89.02) 199.08,89.92 199.08,93.26 arc(199.21,93.9) 199.57,94.44 200.05,94.92 arc(200.56,95.68) 200.73,96.57 200.73,115.86 arc(200.25,118.31) 198.86,120.38 194.12,125.12 arc(193.38,125.62) 192.51,125.79 169.03,125.79 arc(168.46,125.67) 167.97,125.35 167.97,125.35 arc(167.67,125.15) 167.33,125.08 163.72,125.08 arc(163.02,124.94) 162.43,124.55 157.61,119.73 arc(156.58,119.04) 155.36,118.8 114.43,118.8 arc(113.56,118.62) 112.82,118.13 109.52,114.83 arc(108.72,113.64) 108.44,112.23 108.44,95.35 arc(108.35,94.89) 108.09,94.5 107.68,94.09 107.68,94.09 107.27,93.68 arc(107.05,93.35) 106.97,92.96 106.97,90.48 arc(107.04,90.11) 107.24,89.81 107.65,89.4 arc(107.77,89.23) 107.81,89.02 107.81,88.77 arc(107.88,88.41) 108.09,88.1 109.59,86.59 arc(109.77,86.48) 109.98,86.43 110.12,86.43 arc(110.26,86.38) 110.32,86.24 v3(110.32,86.23)
  BOTTOM w0.127: J55.11 214.17,84.46 214.17,79.77 arc(214.14,79.64) v2(214.07,79.54)
  vias: v1(110.31,86.23)
CSI2_RX0_P: length 209
  L3-SIGNAL1 w0.084: v2(214.79,79.54) 214.62,79.37 arc(214.6,79.34) 214.59,79.31 214.59,77.88 arc(214.42,76.98) 213.91,76.22 213.49,75.8 arc(213.31,75.53) 213.24,75.21 213.24,68.44 arc(212.84,67.48) 211.88,67.08 203.13,67.08 arc(202.12,67.5) 201.71,68.5 201.71,74.38 arc(201.63,74.79) 201.4,75.13 200.5,76.03 arc(200.29,76.35) 200.21,76.73 200.21,86.39 arc(200.03,87.27) 199.54,88.02 arc(198.95,88.89) 198.75,89.92 198.75,93.26 arc(198.9,94.02) 199.34,94.67 199.82,95.15 arc(200.25,95.8) 200.4,96.57 200.4,115.86 arc(199.94,118.18) 198.63,120.14 193.88,124.89 arc(193.26,125.31) 192.51,125.46 169.03,125.46 arc(168.58,125.37) 168.2,125.12 168.2,125.11 arc(167.8,124.85) 167.33,124.75 163.72,124.75 arc(163.15,124.64) 162.66,124.31 157.84,119.5 arc(156.7,118.73) 155.36,118.47 114.43,118.47 arc(113.68,118.32) 113.05,117.9 109.75,114.59 arc(109.03,113.51) 108.77,112.23 108.77,95.35 arc(108.65,94.77) 108.32,94.27 107.91,93.86 107.71,93.65 107.5,93.45 arc(107.35,93.22) 107.3,92.96 107.3,90.48 arc(107.34,90.24) 107.48,90.04 107.88,89.64 arc(108.07,89.35) 108.14,89.02 108.14,88.77 arc(108.19,88.53) 108.32,88.33 109.82,86.83 arc(109.89,86.78) 109.98,86.76 110.43,86.76 arc(110.57,86.9) 110.43,87.03 v3(110.32,87.03)
  BOTTOM w0.127: J55.9 214.69,84.46 214.69,79.77 arc(214.71,79.64) v2(214.79,79.54)
  vias: v1(110.31,87.03)
CSI2_RX1_N: length 209
  L3-SIGNAL1 w0.084: v3(109.52,85.43) 109.4,85.55 arc(109.34,85.59) 109.28,85.6 109.08,85.6 arc(108.99,85.58) 108.92,85.53 108.38,85 arc(108.17,84.85) 107.92,84.8 106.1,84.8 arc(105.8,84.87) 105.54,85.04 105.05,85.52 arc(104.86,85.65) 104.62,85.7 104.37,85.7 arc(103.73,85.83) 103.2,86.18 102.53,86.86 arc(102.28,87.22) 102.19,87.66 102.19,118.57 arc(102.31,119.16) 102.64,119.66 104.58,121.6 arc(105.7,122.35) 107.03,122.61 151.14,122.61 arc(152.53,122.89) 153.71,123.67 158.84,128.81 arc(160.57,129.96) 162.61,130.37 173.53,130.37 arc(173.9,130.3) 174.21,130.09 174.46,129.84 arc(174.78,129.63) 175.14,129.56 194.14,129.56 arc(195.12,129.36) 195.95,128.81 203.74,121.01 arc(204.91,119.27) 205.32,117.21 205.32,98.93 arc(205.37,98.67) 205.51,98.46 arc(205.7,98.18) 205.76,97.85 205.76,94.16 arc(205.7,93.82) 205.51,93.54 205.4,93.43 arc(205.28,93.26) 205.24,93.06 205.24,91.69 arc(205.4,91.3) 205.79,91.14 arc(206.28,90.94) 206.49,90.45 206.49,90.01 arc(206.31,89.57) 205.87,89.38 205.79,89.38 arc(205.24,88.83) 205.79,88.28 arc(206.28,88.08) 206.49,87.59 206.49,87.15 arc(206.31,86.71) 205.87,86.52 205.79,86.52 arc(205.4,86.36) 205.24,85.97 205.24,85.02 arc(205.35,84.76) 205.6,84.66 206.74,84.66 arc(207.42,83.97) 206.74,83.28 205.6,83.28 arc(205.35,83.17) 205.24,82.92 205.24,81.88 arc(205.68,80.81) 206.75,80.37 210.63,80.37 arc(210.83,80.33) 211.01,80.21 211.23,79.99 arc(211.35,79.91) 211.49,79.88 212.22,79.88 arc(212.6,80.04) 212.76,80.42 212.76,80.76 arc(212.75,80.83) 212.71,80.88 v2(212.57,81.02)
  BOTTOM w0.127: J55.15 212.67,84.46 212.67,81.25 arc(212.64,81.12) v2(212.57,81.02)
  vias: v1(109.51,85.43)
CSI2_RX1_P: length 209
  L3-SIGNAL1 w0.084: v3(109.52,86.23) 109.59,86.23 arc(109.74,86.08) 109.59,85.93 109.08,85.93 arc(108.87,85.89) 108.68,85.76 108.15,85.23 arc(108.04,85.16) 107.92,85.13 106.1,85.13 arc(105.92,85.17) 105.77,85.27 105.29,85.76 arc(104.98,85.96) 104.62,86.03 104.37,86.03 arc(103.86,86.13) 103.43,86.42 102.76,87.09 arc(102.58,87.35) 102.52,87.66 102.52,118.57 arc(102.62,119.04) 102.88,119.43 104.81,121.36 arc(105.83,122.04) 107.03,122.28 151.14,122.28 arc(152.66,122.58) 153.94,123.44 159.07,128.58 arc(160.7,129.66) 162.61,130.04 173.53,130.04 arc(173.77,129.99) 173.98,129.86 174.23,129.6 arc(174.65,129.32) 175.14,129.22 194.14,129.22 arc(194.99,129.06) 195.71,128.57 203.51,120.78 arc(204.6,119.14) 204.99,117.21 204.99,98.93 arc(205.06,98.55) 205.28,98.23 arc(205.39,98.05) 205.43,97.85 205.43,94.16 arc(205.39,93.95) 205.27,93.77 205.16,93.66 arc(204.98,93.38) 204.91,93.06 204.91,91.69 arc(205.17,91.07) 205.79,90.81 arc(206.05,90.71) 206.16,90.45 206.16,90.01 arc(206.07,89.8) 205.87,89.71 205.79,89.71 arc(204.91,88.83) 205.79,87.95 arc(206.05,87.85) 206.16,87.59 206.16,87.15 arc(206.07,86.94) 205.87,86.85 205.79,86.85 arc(205.17,86.6) 204.91,85.97 204.91,85.02 arc(205.11,84.53) 205.6,84.33 206.74,84.33 arc(207.09,83.97) 206.74,83.61 205.6,83.61 arc(205.11,83.41) 204.91,82.92 204.91,81.88 arc(205.45,80.58) 206.75,80.04 210.63,80.04 arc(210.71,80.02) 210.77,79.98 210.99,79.76 arc(211.22,79.61) 211.49,79.55 212.22,79.55 arc(212.84,79.81) 213.09,80.42 213.09,80.76 arc(213.1,80.82) 213.13,80.87 v2(213.29,81.02)
  BOTTOM w0.127: J55.13 213.19,84.46 213.19,81.25 arc(213.21,81.12) v2(213.29,81.02)
  vias: v1(109.51,86.23)
CSI2_RX2_N: length 209
  L3-SIGNAL1 w0.084: v3(108.72,86.23) 108.53,86.42 arc(108.48,86.45) 108.41,86.47 arc(108.13,86.52) 107.89,86.68 107.8,86.77 arc(107.75,86.8) 107.69,86.82 107.31,86.82 arc(107.06,86.87) 106.84,87.02 106.67,87.18 arc(106.5,87.44) 106.43,87.76 106.43,88.36 arc(106.36,88.73) 106.15,89.05 arc(105.83,89.53) 105.72,90.1 105.72,93.45 arc(105.83,94.04) 106.16,94.53 106.86,95.23 arc(107.15,95.66) 107.25,96.16 107.25,107.42 arc(107.17,107.81) 106.95,108.14 105.31,109.78 arc(105.03,110.19) 104.94,110.68 104.94,114.87 arc(105.01,115.26) 105.23,115.59 105.94,116.3 arc(106.11,116.56) 106.18,116.87 106.18,118.26 arc(106.25,118.62) 106.45,118.92 107.27,119.74 arc(107.72,120.04) 108.25,120.15 153.77,120.15 arc(154.89,120.37) 155.84,121.01 160.66,125.82 arc(162.03,126.74) 163.66,127.07 193.11,127.07 arc(193.85,126.92) 194.48,126.5 201.05,119.93 arc(201.86,118.72) 202.14,117.3 202.14,96.07 arc(202.17,95.95) 202.24,95.84 arc(202.39,95.61) 202.45,95.34 202.45,89.32 arc(202.35,88.82) 202.06,88.4 arc(201.82,88.04) 201.74,87.61 201.74,77.57 arc(201.82,77.17) 202.05,76.83 202.78,76.1 arc(203.11,75.59) 203.23,75 203.23,70.99 arc(203.48,70.4) 204.07,70.16 207.5,70.16 arc(207.79,70.27) 207.91,70.56 207.91,75.9 arc(208.18,76.54) 208.82,76.81 211.04,76.81 arc(211.1,76.82) 211.16,76.86 211.22,76.92 arc(211.25,76.97) 211.26,77.03 211.26,77.69 arc(211.26,77.72) 211.24,77.74 v2(211.07,77.91)
  BOTTOM w0.127: J55.19 211.17,84.46 211.17,78.14 arc(211.14,78.02) v2(211.07,77.91)
  vias: v1(108.71,86.23)
CSI2_RX2_P: length 209
  L3-SIGNAL1 w0.084: v2(211.79,77.91) 211.98,77.91 arc(212.08,77.87) 212.12,77.77 212.12,77.66 arc(212.07,77.54) 211.96,77.5 211.8,77.5 arc(211.66,77.43) 211.59,77.29 211.59,77.03 arc(211.56,76.85) 211.45,76.69 211.39,76.63 arc(211.23,76.52) 211.04,76.48 208.82,76.48 arc(208.41,76.31) 208.24,75.9 208.24,70.56 arc(208.02,70.04) 207.5,69.83 204.07,69.83 arc(203.25,70.17) 202.9,70.99 202.9,75 arc(202.81,75.47) 202.54,75.87 201.82,76.59 arc(201.52,77.04) 201.41,77.57 201.41,87.61 arc(201.52,88.16) 201.83,88.63 arc(202.04,88.95) 202.12,89.32 202.12,95.34 arc(202.09,95.48) 202,95.61 arc(201.86,95.82) 201.81,96.07 201.81,117.3 arc(201.55,118.6) 200.82,119.7 194.25,126.26 arc(193.73,126.61) 193.11,126.74 163.66,126.74 arc(162.16,126.44) 160.89,125.59 156.07,120.77 arc(155.02,120.07) 153.77,119.82 108.25,119.82 arc(107.85,119.74) 107.5,119.51 106.68,118.69 arc(106.55,118.49) 106.51,118.26 106.51,116.87 arc(106.42,116.43) 106.17,116.06 105.47,115.36 arc(105.32,115.14) 105.27,114.87 105.27,110.68 arc(105.34,110.32) 105.54,110.01 107.18,108.37 arc(107.47,107.93) 107.58,107.42 107.58,96.16 arc(107.45,95.53) 107.09,94.99 106.4,94.3 arc(106.14,93.91) 106.05,93.45 106.05,90.1 arc(106.13,89.66) 106.38,89.28 arc(106.67,88.86) 106.76,88.36 106.76,87.76 arc(106.8,87.57) 106.91,87.41 107.07,87.25 arc(107.18,87.17) 107.31,87.15 107.69,87.15 arc(107.88,87.11) 108.04,87 108.12,86.92 arc(108.25,86.83) 108.41,86.8 arc(108.48,86.81) 108.53,86.85 v3(108.72,87.03)
  BOTTOM w0.127: J55.17 211.69,84.46 211.69,78.14 arc(211.71,78.02) v2(211.79,77.91)
  vias: v1(108.71,87.03)
CSI2_RX3_N: length 209
  L3-SIGNAL1 w0.084: v3(107.92,85.43) 107.76,85.58 arc(107.72,85.61) 107.67,85.62 107.2,85.62 arc(106.88,85.69) 106.61,85.87 105.69,86.79 arc(105.52,86.9) 105.31,86.94 104.53,86.94 arc(104.23,87) 103.97,87.18 103.76,87.38 arc(103.62,87.6) 103.56,87.86 103.56,111.83 103.57,111.83 103.57,117.7 arc(103.67,118.23) 103.97,118.68 105.8,120.5 arc(106.75,121.14) 107.88,121.37 152.75,121.37 arc(153.5,121.52) 154.13,121.94 154.54,122.35 160.35,128.16 arc(161.39,128.85) 162.61,129.1 172.6,129.1 arc(173.16,128.98) 173.63,128.67 arc(174.04,128.39) 174.52,128.3 193.98,128.3 arc(194.52,128.19) 194.99,127.88 203.28,119.59 arc(203.82,118.78) 204.01,117.84 204.01,97.88 arc(204.06,97.59) 204.23,97.34 arc(204.49,96.96) 204.57,96.51 204.57,94.98 arc(204.49,94.57) 204.26,94.21 204.05,94.01 arc(203.9,93.78) 203.85,93.52 203.85,88.27 arc(203.76,87.82) 203.5,87.44 203.22,87.16 arc(203.06,86.92) 203.01,86.64 203.01,78.36 arc(203.1,77.88) 203.38,77.47 204.18,76.66 arc(204.38,76.36) 204.45,76 204.45,72.75 arc(204.61,72.37) 204.99,72.21 206.38,72.21 arc(206.6,72.3) 206.69,72.52 206.69,77.83 arc(206.9,78.35) 207.42,78.56 209.59,78.56 arc(209.71,78.61) 209.76,78.73 209.76,79 arc(209.75,79.06) 209.71,79.11 v2(209.57,79.25)
  BOTTOM w0.127: J55.23 209.67,84.46 209.67,79.48 arc(209.64,79.35) v2(209.57,79.25)
  vias: v1(107.91,85.43)
CSI2_RX3_P: length 209
  L3-SIGNAL1 w0.084: v3(107.92,86.23) 108.01,86.23 arc(108.15,86.09) 108.01,85.95 107.2,85.95 arc(107.01,85.99) 106.85,86.1 105.93,87.02 arc(105.64,87.21) 105.31,87.27 105.09,87.27 104.53,87.27 arc(104.35,87.31) 104.2,87.41 104,87.62 arc(103.92,87.73) 103.89,87.86 103.89,111.76 103.9,111.76 103.9,117.7 arc(103.98,118.11) 104.21,118.45 106.03,120.27 arc(106.88,120.84) 107.88,121.04 152.75,121.04 arc(153.62,121.21) 154.36,121.71 154.87,122.21 160.59,127.93 arc(161.51,128.55) 162.61,128.76 172.6,128.76 arc(173.03,128.68) 173.4,128.43 arc(173.91,128.09) 174.52,127.97 193.98,127.97 arc(194.4,127.88) 194.75,127.65 203.05,119.35 arc(203.51,118.66) 203.68,117.84 203.68,97.88 arc(203.76,97.46) 204,97.11 arc(204.18,96.83) 204.24,96.51 204.24,94.98 arc(204.19,94.69) 204.02,94.45 203.82,94.24 arc(203.59,93.91) 203.52,93.52 203.52,88.27 arc(203.45,87.95) 203.27,87.67 202.99,87.39 arc(202.76,87.05) 202.67,86.64 202.67,78.36 arc(202.8,77.75) 203.14,77.23 203.94,76.43 arc(204.08,76.23) 204.12,76 204.12,72.75 arc(204.38,72.14) 204.99,71.88 206.38,71.88 arc(206.83,72.07) 207.02,72.52 207.02,77.83 arc(207.13,78.12) 207.42,78.23 209.59,78.23 arc(209.94,78.38) 210.09,78.73 210.09,78.99 arc(210.1,79.05) 210.13,79.1 v2(210.29,79.25)
  BOTTOM w0.127: J55.21 210.19,84.46 210.19,79.48 arc(210.21,79.35) v2(210.29,79.25)
  vias: v1(107.91,86.23)
CSI2_RX_CALIB: length 46.6
  L3-SIGNAL1 w0.089: v3(111.12,90.23) v5(110.84,90.46)
  L4-GND2 w0.102: v5(110.84,90.46) v7(110.53,90.77)
  L13-GND5 w0.102: v9(110.24,91.05) 110.32,90.98 v7(110.53,90.77)
  L14-SIGNAL6 w0.089: v9(110.24,91.05) 109.03,91.05 108.31,91.77 105.93,91.77 105.22,92.48 103.77,92.48 102.98,93.27 96.93,93.27 91.19,99.01 91.19,114.45 90.05,115.6 90.05,119.14 v2(90.72,119.82)
  BOTTOM w0.127: R918.1 90.9,120.36 90.72,120.18 v2(90.72,119.82)
  vias: v1(111.11,90.23)
CSI2_RXCLK_N: length 209
  L3-SIGNAL1 w0.084: v3(111.12,86.23) 110.93,86.05 arc(110.88,86.01) 110.81,86 arc(110.6,85.96) 110.42,85.84 110.15,85.57 109.13,84.54 arc(109.05,84.48) 108.95,84.46 107.66,84.46 arc(107.43,84.43) 107.22,84.33 arc(107.16,84.28) 107.09,84.23 107,84.13 arc(106.8,84) 106.56,83.95 105.63,83.95 arc(105.39,84) 105.18,84.14 104.9,84.41 arc(104.64,84.59) 104.33,84.65 102.61,84.65 arc(102.36,84.7) 102.14,84.84 101.43,85.56 arc(101,86.2) 100.85,86.97 100.85,120.27 arc(101.18,121.08) 101.99,121.41 102.37,121.41 arc(102.72,121.48) 103.02,121.68 104.63,123.29 arc(104.92,123.48) 105.27,123.55 150.71,123.55 150.71,123.55 arc(152.04,123.82) 153.16,124.57 158.32,129.72 arc(160.03,130.87) 162.06,131.27 174.23,131.27 arc(174.43,131.23) 174.6,131.12 174.77,130.95 arc(175.08,130.74) 175.46,130.67 194.19,130.67 arc(195.27,130.46) 196.18,129.85 205.13,120.9 arc(205.94,119.67) 206.23,118.23 206.23,102.42 arc(206.38,101.68) 206.79,101.06 207.16,100.7 arc(207.64,99.97) 207.81,99.12 207.81,86.44 arc(208.07,85.81) 208.7,85.55 215.2,85.55 arc(215.6,85.38) 215.76,84.98 215.76,84.37 arc(215.72,84.25) 215.6,84.2 215.44,84.2 arc(215.27,84.03) 215.44,83.87 215.6,83.87 arc(215.72,83.82) 215.76,83.7 215.76,82.92 arc(215.72,82.82) 215.62,82.78 215.31,82.78 arc(215.18,82.72) 215.12,82.59 215.12,82.52 arc(215.17,82.4) 215.29,82.36 v2(215.57,82.36)
  BOTTOM w0.127: J55.7 215.67,84.46 215.67,82.59 arc(215.64,82.46) v2(215.57,82.36)
  vias: v1(111.11,86.23)
CSI2_RXCLK_P: length 209
  L3-SIGNAL1 w0.084: v3(111.12,85.43) 110.93,85.62 arc(110.88,85.65) 110.81,85.67 arc(110.73,85.65) 110.66,85.6 109.37,84.3 arc(109.17,84.18) 108.95,84.13 107.66,84.13 arc(107.53,84.11) 107.4,84.05 arc(107.36,84.03) 107.33,83.99 107.23,83.9 arc(106.92,83.69) 106.56,83.62 105.63,83.62 arc(105.26,83.69) 104.95,83.9 104.67,84.18 arc(104.51,84.29) 104.33,84.32 102.61,84.32 arc(102.23,84.4) 101.91,84.61 101.2,85.32 arc(100.69,86.08) 100.52,86.97 100.52,120.27 arc(100.95,121.31) 101.99,121.74 102.37,121.74 arc(102.6,121.79) 102.79,121.92 104.39,123.52 arc(104.79,123.79) 105.27,123.88 150.71,123.88 arc(151.91,124.12) 152.93,124.8 158.08,129.96 arc(159.91,131.18) 162.06,131.6 174.23,131.6 arc(174.56,131.54) 174.84,131.35 175,131.19 arc(175.21,131.05) 175.46,131 194.19,131 arc(195.39,130.76) 196.41,130.08 205.36,121.13 arc(206.25,119.8) 206.56,118.23 206.56,102.42 arc(206.68,101.81) 207.03,101.3 207.39,100.93 arc(207.95,100.1) 208.14,99.12 208.14,86.44 arc(208.3,86.04) 208.7,85.88 215.2,85.88 arc(215.83,85.61) 216.09,84.98 216.09,82.82 arc(216.14,82.57) v2(216.29,82.36)
  BOTTOM w0.127: J55.5 216.19,84.46 216.19,82.59 arc(216.21,82.46) v2(216.29,82.36)
  vias: v1(111.11,85.43)
CSI_VIO_SEL: length 236
  TOP w0.127: SW2.7 v2(146.54,170.25)
  L12-SIGNAL5 w0.102: v2(146.54,170.25) 147.82,171.53 147.82,174.11 155.91,182.2 160.39,182.2 164.52,178.06 164.52,169.65 166.35,167.82 166.35,162.61 163.94,160.2 163.94,151.23 161.88,149.17 161.88,139.68 157.73,135.52 157.73,125.81 161.24,122.29 161.24,112.52 163.37,110.39 176.9,110.39 185.05,102.24 185.05,96.75 187.16,94.64 193.61,94.64 201.15,87.1 201.15,81.51 202.32,80.34 202.32,62.2 201.33,61.21 201.33,56.03 197.9,52.6 197.9,39.29 199.68,37.52 199.68,32.69 191.18,24.19 183.22,24.19 180.37,21.34 180.06,21.34 v2(179.98,21.41)
  BOTTOM w0.127: U265.1 v2(179.98,21.41)
CTRL_PM_I2C_OE#: length 184.6
  TOP w0.127: v2(10.43,151.58) Q1.1
  L3-SIGNAL1 w0.089: v2(159.41,164.5) 159.83,164.91 164.26,164.91 165.35,166 165.35,168.36 159.27,174.44 157.21,174.44 154.97,172.2 140.75,172.2 139.18,170.63 130.04,170.63 126.94,173.73 124.78,173.73 123.58,174.93 111.13,174.93 109.4,173.19 103.45,173.19 102.5,174.15 88.02,174.15 74.96,161.09 56.88,161.09 55.98,161.98 31.65,161.98 30.49,160.82 18.24,160.82 10.43,153.02 v2(10.43,151.58)
  BOTTOM w0.127: U173.9 v2(159.41,164.5)
DDR0_CA0: length 34.3
  L3-SIGNAL1 w0.076: v3(154.33,91.98) 154.63,91.69 154.63,90.01 v5(154.33,89.71) 154.33,89.29 154.64,88.97 154.64,87.74 v3(154.33,87.43)
  L3-SIGNAL1 w0.132: v3(131.92,84.63) v1(131.92,84.63) v5(132.34,84.94)
  L4-GND2 w0.146: v5(154.33,89.71) v7(154.71,90.14)
  L4-GND2 w0.185: v7(132.24,84.53) v5(132.34,84.94)
  L7-SIGNAL3 w0.185: 153.48,90.38 153.68,90.58 154.27,90.58 v7(154.71,90.14)
  L7-SIGNAL3 w0.191: v7(132.24,84.53) 132.7,84.07 132.7,83.26 133.41,82.55 143.26,82.55 145.86,85.14 147.89,85.14 152.14,89.4 153.29,89.4 153.48,89.59 153.48,90.38
  vias: v1(154.33,91.98) v1(154.33,87.43)
DDR0_CA1: length 34.3
  L3-SIGNAL1 w0.076: v3(154.33,88.08) 154.33,88.54 154.11,88.77 153.5,88.77 153.27,88.99 153.27,89.44 v5(153.54,89.71) 153.27,89.97 153.27,90.34 153.55,90.62 154.14,90.62 154.33,90.82 v3(154.33,91.33)
  L3-SIGNAL1 w0.132: v3(131.12,83.83) v1(131.12,83.83) v5(131.35,84.15)
  L4-GND2 w0.146: v5(153.54,89.71) v7(153.92,90.14)
  L4-GND2 w0.185: v7(131.11,83.78) v5(131.35,84.15)
  L7-SIGNAL3 w0.191: v7(153.92,90.14) 154.21,89.85 154.21,89.33 153.78,88.9 152.24,88.9 151.91,88.58 151.91,88.46 147.99,84.53 147.13,84.53 145.75,83.16 144.64,83.16 143.49,82.02 132.88,82.02 v7(131.11,83.78)
  vias: v1(154.33,91.33) v1(154.33,88.08)
DDR0_CA2: length 34.4
  L3-SIGNAL1 w0.076: v3(148.73,91.98) 148.37,91.62 148.37,90.37 148.62,90.11 v5(148.62,89.71) 148.62,89.3 148.37,89.05 148.37,87.79 v3(148.73,87.43)
  L3-SIGNAL1 w0.132: v5(131.48,84.58) v1(131.12,84.63) v3(131.12,84.63)
  L4-GND2 w0.146: v5(148.62,89.71) v7(149,90.14)
  L4-GND2 w0.185: v7(131.4,85.01) v5(131.48,84.58)
  L7-SIGNAL3 w0.191: v7(149,90.14) 149,91 148.81,91.19 148.05,91.19 147.86,91 147.86,89.28 147.51,88.93 146.85,88.93 146.51,89.26 145.62,89.26 145.42,89.39 145.18,89.64 144.97,89.64 144.59,89.25 144.59,88.61 144.33,88.35 144.11,88.35 143.9,88.14 142.91,88.14 142.14,87.37 142.14,87.16 142.72,86.58 142.72,86.38 142.52,86.18 142.25,86.18 141.66,86.77 141.39,86.77 141.19,86.57 141.19,86.3 141.76,85.73 141.76,85.46 141.57,85.27 141.08,85.27 140.29,86.06 139.63,86.06 139.05,85.47 133.94,85.47 133.34,86.07 131.86,86.07 131.4,85.62 v7(131.4,85.01)
  vias: v1(148.73,91.98) v1(148.73,87.43)
DDR0_CA3: length 34.3
  L3-SIGNAL1 w0.076: v3(147.93,91.98) 147.93,91.68 147.81,91.56 147.81,91.15 148.09,90.87 148.09,90.21 147.89,90.01 v5(147.89,89.71) 147.89,89.4 148.04,89.25 148.04,88.59 147.76,88.31 147.76,87.91 147.93,87.73 v3(147.93,87.43)
  L3-SIGNAL1 w0.132: v3(131.92,85.43) v1(131.92,85.43) v5(132.32,85.6)
  L4-GND2 w0.146: v5(147.89,89.71) v7(148.29,90.14)
  L4-GND2 w0.185: v5(132.32,85.6) v7(132.85,85.65)
  L7-SIGNAL3 w0.191: v7(148.29,90.14) 148.67,89.76 148.67,89.36 147.71,88.39 146.51,88.39 146.08,88.82 145.73,88.82 145.49,88.57 145.49,88.07 145.3,87.88 144.31,87.88 144.12,87.69 144.12,87.47 143.92,87.28 143.72,87.28 143.39,87.61 143.12,87.61 142.92,87.41 142.92,87.14 143.48,86.57 143.48,86.25 142.43,85.2 142.43,84.94 142.28,84.79 140.51,84.79 140.32,84.98 140.32,85.26 140.13,85.45 139.83,85.45 139.68,85.3 139.68,84.93 139.49,84.73 138.12,84.73 137.93,84.54 137.93,84.07 137.76,83.9 137.49,83.9 137.3,84.1 137.3,84.84 137.15,84.99 136.83,84.99 136.63,84.8 136.63,84.04 136.44,83.85 136.16,83.85 135.96,84.04 135.96,84.81 135.77,85 135.5,85 135.31,84.81 135.31,84.06 135.12,83.87 134.85,83.87 134.65,84.07 134.65,84.81 134.4,85.07 133.43,85.07 v7(132.85,85.65)
  vias: v1(147.93,91.98) v1(147.93,87.43)
DDR0_CA4: length 34.3
  L3-SIGNAL1 w0.076: v3(147.13,87.43) 147.43,87.73 147.43,89.4 v5(147.13,89.71) 147.43,90.01 147.43,91.68 v3(147.13,91.98)
  L3-SIGNAL1 w0.132: v5(132.27,84.02) v3(131.94,83.8)
  L4-GND2 w0.146: v5(147.13,89.71) v7(147.43,90.14)
  L4-GND2 w0.185: v7(132.04,83.69) v5(132.27,84.02)
  L7-SIGNAL3 w0.191: v7(147.43,90.14) 147,89.71 145.83,89.71 145.57,89.97 145.51,89.97 145.37,90.11 145.13,90.11 144.84,90.4 144.84,91.2 144.65,91.39 144.29,91.39 144.1,91.2 144.1,90.61 143.87,90.38 143.87,90.06 143.72,89.91 143.41,89.91 143.26,89.77 143.26,89.56 143.41,89.42 143.72,89.42 143.87,89.27 143.87,88.89 143.68,88.7 142.55,88.7 140.65,86.79 139.38,86.79 139.07,86.49 138.68,86.49 138.53,86.34 138.53,86.1 138.39,85.95 138.18,85.95 138.04,86.1 138.04,86.34 137.89,86.49 137.57,86.49 137.38,86.3 137.38,86.09 137.24,85.94 137.03,85.94 136.89,86.09 136.89,86.39 136.74,86.54 136.54,86.54 136.39,86.39 136.39,86.09 136.25,85.94 136.04,85.94 135.9,86.09 135.9,86.39 135.75,86.54 135.55,86.54 135.4,86.39 135.4,86.09 135.26,85.94 135.05,85.94 134.91,86.09 134.91,86.32 134.72,86.51 131.73,86.51 130.89,85.67 130.89,84.84 v7(132.04,83.69)
  vias: v1(131.92,83.83) v1(147.13,91.98) v1(147.13,87.43)
DDR0_CA5: length 34.3
  L3-SIGNAL1 w0.076: v3(147.13,91.33) 147.13,90.83 146.87,90.57 146.34,90.57 146.06,90.29 146.06,90.07 v5(146.41,89.71) 145.96,89.25 145.96,88.87 146.58,88.24 146.97,88.24 v3(147.13,88.08)
  L3-SIGNAL1 w0.132: v5(130.67,85.14) 130.32,85.43 v3(130.32,85.43)
  L4-GND2 w0.146: v5(146.41,89.71) v7(146.01,90.14)
  L4-GND2 w0.185: v7(130.39,84.81) v5(130.67,85.14)
  L7-SIGNAL3 w0.185: 131.54,87.01 130.39,85.85 v7(130.39,84.81)
  L7-SIGNAL3 w0.191: v7(146.01,90.14) 145.51,90.63 145.51,91.67 145.32,91.86 143.58,91.86 142.94,91.22 142.94,91.02 143.14,90.81 143.14,90.61 143,90.46 142.79,90.46 142.59,90.67 142.39,90.67 142.2,90.48 142.2,90.21 142.59,89.82 142.59,89.54 142.44,89.4 142.24,89.4 141.73,89.91 141.52,89.91 141.38,89.76 141.38,89.56 141.89,89.05 141.89,88.84 141.74,88.7 141.54,88.7 141.03,89.21 140.82,89.21 140.68,89.06 140.68,88.86 141.19,88.35 141.19,88.14 141.04,88 140.84,88 140.33,88.51 140.12,88.51 139.98,88.36 139.98,88.16 140.48,87.65 140.48,87.44 140.34,87.3 140.13,87.3 139.67,87.76 139.37,87.76 138.62,87.01 131.54,87.01
  vias: v1(130.32,85.43) v1(147.13,91.33) v1(147.13,88.08)
DDR0_CAL0: length 56.6
  TOP w0.127: U59.R7 128.72,79.83 v2(129.12,79.43)
  L12-SIGNAL5 w0.102: v2(163.96,104.12) 163.48,103.64 162.86,103.64 161.6,102.38 146.15,102.38 144.27,100.5 144.27,93.85 139.83,89.41 128.96,89.41 128.74,89.19 128.74,88.91 128.44,88.61 128.16,88.61 127.9,88.34 127.9,82.14 128.74,81.3 128.74,79.81 v2(129.12,79.43)
DDR0_CK_C: length 34.3
  L3-SIGNAL1 w0.076: v3(148.73,91.33) 149.08,91.33 150.17,90.24 150.17,89.93 v5(149.94,89.71) 150.16,89.49 150.16,89.13 149.11,88.08 v3(148.73,88.08)
  L3-SIGNAL1 w0.132: v5(133.05,84) v1(132.72,83.83) v3(132.72,83.83)
  L4-GND2 w0.146: v5(149.94,89.71) v7(150.31,90.14)
  L4-GND2 w0.185: v7(133.36,83.69) v5(133.05,84)
  L7-SIGNAL3 w0.178: v7(133.36,83.69) 133.64,83.69 134.3,83.03 138.37,83.03 138.75,83.4 138.75,83.67 138.92,83.85 139.17,83.85 139.35,83.67 139.35,83.39 139.69,83.06 140.23,83.06 140.6,83.43 140.6,83.76 140.74,83.9 141.05,83.9 141.23,83.72 141.23,83.48 141.6,83.11 142.96,83.11 143.57,83.72 143.57,84.63 144.07,85.14 144.58,85.14 146.41,86.97 147.59,86.97 148.56,87.94 150.13,87.94 151.85,89.65 151.85,90.94 151.48,91.31 150.82,91.31 150.31,90.8 v7(150.31,90.14)
  vias: v1(148.73,91.33) v1(148.73,88.08)
DDR0_CK_T: length 34.3
  L3-SIGNAL1 w0.076: v3(149.53,88.08) 150.02,88.08 150.81,88.87 150.81,89.49 v5(150.59,89.71) 150.83,89.94 150.83,90.47 149.97,91.33 v3(149.53,91.33)
  L3-SIGNAL1 w0.132: v5(133.88,84.8) 133.88,84.8 133.88,84.8 133.88,84.79 v1(133.52,84.63) v3(133.52,84.63)
  L4-GND2 w0.146: v5(150.59,89.71) v7(150.98,90.14)
  L4-GND2 w0.185: v5(133.88,84.8) 133.88,84.8 133.88,84.8 133.88,84.79 v7(133.51,84.58)
  L7-SIGNAL3 w0.178: v7(150.98,90.14) 150.64,90.47 150.64,90.67 150.96,90.98 151.34,90.98 151.52,90.81 151.52,89.79 150.76,89.03 150.56,89.03 150.2,89.39 150,89.39 149.86,89.25 149.86,89.05 150.17,88.73 150.17,88.44 150,88.27 148.42,88.27 147.46,87.3 146.28,87.3 144.44,85.47 143.94,85.47 143.24,84.77 143.24,83.86 142.82,83.44 141.74,83.44 141.56,83.62 141.56,83.86 141.19,84.23 140.6,84.23 140.27,83.89 140.27,83.57 140.09,83.39 139.82,83.39 139.68,83.53 139.68,83.81 139.31,84.18 138.79,84.18 138.42,83.81 138.42,83.54 138.24,83.36 134.44,83.36 133.51,84.29 v7(133.51,84.58)
  vias: v1(149.53,91.33) v1(149.53,88.08)
DDR0_CKE0: length 34.6
  L3-SIGNAL1 w0.127: v5(129.83,85.27) v3(129.52,85.43)
  L3-SIGNAL1 w0.14: v3(152.73,88.08) 152.73,88.59 152.53,88.8 152.33,88.8 152.19,88.93 152.19,89.1 152.31,89.22 152.71,89.22 152.86,89.37 152.86,89.58 v5(152.73,89.71) 152.86,89.84 152.86,90.04 152.71,90.19 152.31,90.19 152.19,90.31 152.19,90.48 152.33,90.62 152.53,90.62 152.73,90.82 v3(152.73,91.33)
  L4-GND2 w0.146: v5(152.73,89.71) v7(153.06,90.09) ; v7(129.95,85.73) v5(129.83,85.27)
  L12-SIGNAL5 w0.152: v7(129.95,85.73) 130.49,86.26 131.96,86.26 133.31,87.61 144.41,87.61 145.6,88.8 146.26,88.8 146.67,88.39 147.38,88.39 147.52,88.26 147.52,87.92 147.65,87.78 147.84,87.78 147.98,87.92 147.98,88.26 148.11,88.39 148.3,88.39 148.43,88.26 148.43,87.92 148.57,87.78 148.76,87.78 148.89,87.92 148.89,88.26 149.02,88.39 149.21,88.39 149.35,88.26 149.35,87.92 149.48,87.78 149.67,87.78 149.8,87.92 149.8,88.26 149.94,88.39 151.75,88.39 153.06,89.7 v7(153.06,90.09)
  vias: v1(152.73,91.33) v1(152.73,88.08)
DDR0_CKE1: length 34.6
  L3-SIGNAL1 w0.127: v5(129.07,85.28) v3(128.72,85.43)
  L3-SIGNAL1 w0.14: v3(151.93,88.08) 151.39,88.08 151.24,88.23 151.24,89.01 v5(151.94,89.71) 151.24,90.4 151.24,91.19 151.39,91.33 v3(151.93,91.33)
  L4-GND2 w0.146: v7(129.12,85.7) v5(129.07,85.28) ; v5(151.94,89.71) v7(152.32,90.14)
  L12-SIGNAL5 w0.152: v7(129.12,85.7) 130.06,86.64 131.66,86.64 133.08,88.06 143.11,88.06 144.86,89.81 145.5,89.81 145.96,89.36 146.56,89.36 146.69,89.22 146.69,89.03 146.83,88.9 147.02,88.9 147.15,89.03 147.15,89.38 147.28,89.51 147.47,89.51 147.61,89.38 147.61,88.96 147.74,88.82 147.93,88.82 148.06,88.96 148.06,89.38 148.2,89.51 148.39,89.51 148.52,89.38 148.52,88.96 148.65,88.82 148.84,88.82 148.98,88.96 148.98,89.38 149.26,89.66 151.84,89.66 v7(152.32,90.14)
  vias: v1(151.93,91.33) v1(151.93,88.08)
DDR0_CSN0_0: length 31.8
  TOP w0.33: v1(152.33,87.1) v7(152.33,87.1) U54.H4
  L3-SIGNAL1 w0.129: v5(152.73,86.78) 152.73,86.78 v7(152.33,87.1)
  L3-SIGNAL1 w0.132: v5(129.88,84.79) 129.52,84.63 v3(129.52,84.63)
  L4-GND2 w0.146: v7(152.33,87.1) v5(152.73,86.78) ; v7(129.55,84.53) v5(129.88,84.79)
  L7-SIGNAL3 w0.14: 152.27,87.05 151.9,86.67 151.9,85.78 151.73,85.61 151.55,85.61 151.12,86.03 150.94,86.03 150.81,85.9 150.81,85.72 151.23,85.29 151.23,85.11 150.2,84.07 147.48,84.07 147,83.59 147,83.06 146.62,82.68 144.86,82.68 143.56,81.37 131.59,81.37 130.43,82.53 130.43,82.91 129.92,83.42 129.92,84.16 v7(129.55,84.53)
  L7-SIGNAL3 w0.146: v7(152.33,87.1) 152.27,87.05
  vias: v1(129.52,84.63)
DDR0_CSN0_1: length 31.7
  TOP w0.305: v1(153.13,92.3) 153.05,92.3 U54.R4
  L3-SIGNAL1 w0.129: v5(152.73,91.98) U54.R4 v3(153.13,92.3)
  L3-SIGNAL1 w0.132: v5(130.67,84.02) 130.32,83.83 v3(130.32,83.83)
  L4-GND2 w0.146: v7(153.12,91.62) v5(152.73,91.98) ; v7(130.34,83.8) v5(130.67,84.02)
  L7-SIGNAL3 w0.14: v7(130.34,83.8) 130.34,84.23 129.95,84.61 129.95,84.84 129.52,85.27 129.52,85.87 131.1,87.45 138.44,87.45 143.29,92.3 146.82,92.3 147.3,91.82 150.15,91.82 150.6,92.28 150.88,92.28 151.54,91.62 v7(153.12,91.62)
  vias: v1(130.32,83.83)
DDR0_CSN1_0: length 31.7
  TOP w0.33: U54.H3 v3(153.13,87.1) v1(153.13,87.1)
  L3-SIGNAL1 w0.129: v5(153.53,86.78) 153.53,86.78 v3(153.13,87.1)
  L3-SIGNAL1 w0.132: v5(129.08,83.99) v1(128.72,83.83) v3(128.72,83.83)
  L4-GND2 w0.146: v7(153.13,86.45) v5(153.53,86.78) ; v7(128.76,83.8) v5(129.08,83.99)
  L7-SIGNAL3 w0.14: v7(153.13,86.45) 153.13,85.2 152.17,84.25 151.26,84.25 150.68,83.67 149.51,83.67 148.06,82.22 145.04,82.22 143.77,80.95 142.26,80.95 142.26,80.95 131.3,80.95 130.86,81.39 129.8,81.39 128.72,82.47 128.72,83.38 128.76,83.41
  L7-SIGNAL3 w0.146: 128.76,83.41 v7(128.76,83.8)
DDR0_CSN1_1: length 31.8
  TOP w0.305: v1(153.93,92.3) 153.61,91.98 U54.R3
  L3-SIGNAL1 w0.129: v5(153.53,91.98) U54.R3 v3(153.93,92.3)
  L3-SIGNAL1 w0.132: v3(128.72,84.63) v1(128.72,84.63) v5(129.08,84.79)
  L4-GND2 w0.146: v7(128.74,84.63) v5(129.08,84.79) ; v5(153.53,91.98) v3(153.93,92.3) v7(153.93,92.31)
  L7-SIGNAL3 w0.14: v7(153.93,92.31) 153.09,92.31 152.66,92.74 143.11,92.74 138.25,87.87 130.96,87.87 129.19,86.1 128.95,86.1 128.72,85.87 128.72,85.53 128.74,85.52 128.74,85.49
  L7-SIGNAL3 w0.146: 128.74,85.49 v7(128.74,84.63)
DDR0_DM0_DBI0#: length 31.5
  L3-SIGNAL1 w0.127: v5(129.88,81.55) v3(129.52,81.43)
  L3-SIGNAL1 w0.129: v5(153.93,83.86) 153.93,83.85 v3(153.53,84.18)
  L4-GND2 w0.146: v6(153.65,84.15) v5(153.93,83.86) ; v6(130.13,81.79) v5(129.88,81.55)
  L5-SIGNAL2 w0.152: v6(153.65,84.15) 154.34,85.65 154.34,85.95 152.43,87.86 152.31,87.86 151.82,88.34 147.87,88.34 146.89,87.37 145.77,87.37 145.68,87.45 142.83,87.45 138.13,82.75 131.35,82.75 v6(130.13,81.79)
  vias: v1(153.53,84.18)
DDR0_DM1_DBI1#: length 21.9
  L3-SIGNAL1 w0.14: v3(132.72,82.23) 133.12,82.23 133.56,81.79 134.3,81.79 134.45,81.64 144.85,81.64 145.12,81.9 145.12,82.96 145.26,83.1 146.78,83.1 146.92,82.96 146.92,82.74 146.78,82.6 145.89,82.6 145.75,82.46 145.75,82.19 145.88,82.06 146.54,82.06 146.71,81.89 146.91,81.89 147.05,82.03 147.05,82.12 147.53,82.6 147.8,82.6 147.94,82.74 147.94,83.36 148.27,83.69 148.27,83.84 v3(147.93,84.18)
DDR0_DM2_DBI2#: length 31.3
  L3-SIGNAL1 w0.127: v5(133.08,87.96) v3(132.72,87.83)
  L3-SIGNAL1 w0.129: v5(153.13,95.55) 153.13,95.56 v6(153.53,95.23)
  L4-GND2 w0.146: v6(153.53,95.23) v5(153.13,95.55) ; v6(132.73,87.9) v5(133.08,87.96)
  L5-SIGNAL2 w0.152: v6(153.53,95.23) 153.21,95.56 151.93,95.56 151.27,96.22 150.8,96.22 150.66,96.08 150.66,95.87 150.53,95.73 150.34,95.73 150.21,95.87 150.21,96.08 150.07,96.22 149.82,96.22 149.68,96.08 149.68,95.84 149.55,95.71 149.36,95.71 149.23,95.84 149.23,96.08 149.09,96.22 148.9,96.22 148.77,96.08 148.77,95.87 148.64,95.73 148.45,95.73 148.31,95.87 148.31,96.08 148.18,96.22 147.27,96.22 147.14,96.08 147.14,95.84 147,95.71 146.81,95.71 146.68,95.84 146.68,96.15 146.46,96.37 145.35,96.37 144.24,95.26 144.24,94.09 142.86,92.71 142.67,92.71 142.54,92.84 142.36,92.84 142.22,92.71 142.22,92.52 142.35,92.39 142.35,92.2 142.22,92.07 142.03,92.07 141.9,92.2 141.71,92.2 141.57,92.06 141.57,91.87 141.7,91.74 141.7,91.56 141.51,91.36 140.36,91.36 137.29,88.29 133.71,88.29 133.21,87.79 132.84,87.79 v6(132.73,87.9)
  vias: v1(153.53,95.23)
DDR0_DM3_DBI3#: length 23.9
  L3-SIGNAL1 w0.14: v3(129.52,88.63) 130.22,88.63 130.72,89.13 130.72,89.51 131.1,89.89 132.01,89.89 132.37,90.25 134.08,90.25 134.32,90.49 134.32,91.42 135.16,92.25 136.72,92.25 136.87,92.1 136.87,91.87 137.01,91.73 137.25,91.73 137.39,91.87 137.39,92.1 137.55,92.25 138.62,92.25 142.96,96.6 146.9,96.6 147.56,95.94 147.56,95.61 v3(147.93,95.23)
DDR0_DQ0: length 31.5
  L3-SIGNAL1 w0.127: v5(130.13,79.5) v3(130.32,79.83)
  L3-SIGNAL1 w0.129: v5(154.73,83.21) 154.73,83.2 v3(154.33,83.53)
  L4-GND2 w0.146: v6(130.33,79.9) v5(130.13,79.5) ; v6(155.33,82.42) v5(154.73,83.21)
  L5-SIGNAL2 w0.152: v6(155.33,82.42) 155.65,82.1 155.65,81.81 155.5,81.66 155.27,81.66 155.13,81.53 155.13,80.85 154.98,80.7 145.75,80.7 143.49,78.44 130.62,78.44 130.33,78.72 v6(130.33,79.9)
  vias: v1(154.33,83.53)
DDR0_DQ1: length 31.5
  L3-SIGNAL1 w0.127: v5(131.48,79.95) v3(131.12,79.83)
  L3-SIGNAL1 w0.129: v3(154.33,84.18) 154.73,83.85 v5(154.73,83.86)
  L4-GND2 w0.146: v6(131.22,79.68) v5(131.48,79.95) ; v6(154.33,83.53) v5(154.73,83.86)
  L5-SIGNAL2 w0.152: v6(154.33,83.53) 154.59,83.27 154.59,82.3 154.38,82.08 153.94,82.08 153.65,81.8 153.65,81.38 153.4,81.13 152.97,81.13 152.84,81.26 152.84,81.48 152.7,81.61 152.51,81.61 152.38,81.48 152.38,81.26 152.24,81.13 151.97,81.13 151.83,81.26 151.83,81.48 151.7,81.61 151.51,81.61 151.37,81.48 151.37,81.26 151.24,81.13 150.96,81.13 150.83,81.26 150.83,81.48 150.69,81.61 150.5,81.61 150.37,81.48 150.37,81.26 150.24,81.13 145.57,81.13 143.31,78.87 131.1,78.87 130.82,79.15 130.82,79.53 130.97,79.68 v6(131.22,79.68)
  vias: v1(154.33,84.18)
