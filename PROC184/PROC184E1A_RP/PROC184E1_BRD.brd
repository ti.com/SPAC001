# Allegro board PROC184E1_BRD.brd (continued)
## Nets (continued)
VDD_MCU_RAM_0V85_N: R408.2 R1057.1 TP136.1(TP)
VDD_MCU_RAM_0V85_P: R412.2 R1057.4 TP138.1(TP)
VDD_MCU_WAKE1: C1012.1 R421.2 R424.2 U59.J26(VDD_MCU_WAKE1)
VDD_MCUIO_1V8: C352.1 C360.1 C361.1 C1021.1 C1032.1 C1070.1 R439.3 R448.2 TP159.1(TP) U59.G22(VDDSHV1_MCU#G22) U59.H23(VDDSHV1_MCU#H23) U89.1(VMON3) U89.3(VMON4) U89.4(VMON5)
VDD_MCUIO_1V8_N: R439.4 R579.2 TP209.1(TP)
VDD_MCUIO_1V8_P: R439.1 R583.2 TP210.1(TP)
VDD_MCUIO_1V8_REG: C288.1 R429.3 R439.2 U68.13(VOUT_LDO1)
VDD_MCUIO_3V3: C1022.1 C1028.1 C1078.1 R452.1 R528.2 R1096.2 TP151.1(TP) U59.G24(VDDSHV2_MCU#G24) U59.H25(VDDSHV2_MCU#H25) U279.1(IN1)
VDD_MCUIO_3V3_N: R592.2 R1096.1 TP216.1(TP)
VDD_MCUIO_3V3_P: R601.2 R1096.4 TP218.1(TP)
VDD_MCUIO_3V3_REG: C286.1 R1058.3 R1096.3 U68.11(VOUT_LDO2)
VDD_MMC1: C170.1 C721.1 J53.4(VDD) TP58.1(TP) U34.5(QOD) U34.6(VOUT) U200.1(VCC)
VDD_PHYCORE_0V8: FL66.1 FL71.1 FL83.1 FL84.1 FL86.2 FL87.1 FL89.1 FL94.1 FL97.2 R226.2 TP61.1(TP)
VDD_PHYCORE_0V8_IN+: C720.2 R929.1 U198.D3(IN+) U199.10(VIN+)
VDD_PHYCORE_0V8_IN-: C720.1 R925.1 U198.D1(BUS) U198.D2(IN-) U199.8(VBUS) U199.9(VIN-)
VDD_PHYCORE_0V8_N: R226.1 R925.2 TP280.1(TP)
VDD_PHYCORE_0V8_P: R226.4 R929.2 TP283.1(TP)
VDD_PMIC_BUCK_SW1: L34.1 U68.27(SW_B1A) U68.28(SW_B1B)
VDD_PMIC_BUCK_SW2: L33.1 U68.15(SW_B2A) U68.16(SW_B2B)
VDD_PMIC_BUCK_SW3: L31.1 U68.43(SW_B3A) U68.44(SW_B3B)
VDD_PMIC_BUCK_SW4: L30.1 U68.55(SW_B4A) U68.56(SW_B4B)
VDD_PMIC_BUCK_SW5: L32.1 U68.34(SW_B5A)
VDD_RAM_0V85: FL151.1 FL194.1 R362.3 TP119.1(TP) U68.49(FB_B3)
VDD_RAM_0V85_N: R362.4 R968.2 TP297.1(TP)
VDD_RAM_0V85_P: R362.1 R969.2 TP298.1(TP)
VDD_RAM_0V85_REG: C254.1 C891.1 L31.2 R362.2
VDD_SD_DV: C966.1 C968.1 R351.2 R916.1 R922.1 R934.1 R936.1 R937.1 TP65.1(TP) U59.N27(VDDSHV5)
VDD_SD_DV_1V8: R324.1 U53.5(OUT2)
VDD_SD_DV_3V3: R318.1 U53.6(OUT1)
VDD_SD_DV_IN+: C812.2 R977.1 U214.D3(IN+) U215.10(VIN+)
VDD_SD_DV_IN-: C812.1 R975.1 U214.D1(BUS) U214.D2(IN-) U215.8(VBUS) U215.9(VIN-)
VDD_SD_DV_N: R351.1 R975.2 TP294.1(TP)
VDD_SD_DV_P: R351.4 R977.2 TP296.1(TP)
VDD_SD_DV_REG: C247.1 R318.2 R324.2 R342.2 R351.3 TP98.1(TP)
VDD_TUSB321: C546.1 C548.2 D40.1(CATHODE) R8.2 R731.1 R739.1 R744.1 R753.1 U158.12(VDD) U166.2(S)
VDD_WAKE0: C943.1 R1045.2 R1051.2 U59.R27(VDD_WAKE0)
VDDA_LM5140: C221.2 U46.3(FB2) U46.28(FB1) U46.33(DEMB) U46.34(ILSET) U46.36(VDDA)
VDDA_LM5141: C321.2 U81.1(DEMB) U81.2(VDDA) U81.5(DITH)
VDDA_LM5143: C111.2 R832.1 U25.33(DEMB) U25.34(MODE) U25.36(VDDA)
VDDAR_CORE_0V85: C870.1 C873.1 C874.1 C875.1 C889.1 C894.1 C920.1 C930.1 C960.1 FL150.1 FL150.3 FL151.2 R556.1 TP191.1(TP) U59.AA22(VDDAR_CORE#AA22) U59.AD13(VDDAR_CORE#AD13) U59.AD16(VDDAR_CORE#AD16) U59.AD19(VDDAR_CORE#AD19) U59.AE9(VDDAR_CORE#AE9) U59.AE26(VDDAR_CORE#AE26) U59.P23(VDDAR_CORE#P23) U59.Y25(VDDAR_CORE#Y25)
VDDAR_CPU_0V85: C881.1 C887.1 C888.1 C895.1 C904.1 C916.1 C959.1 C990.1 C1003.1 C1026.1 C1031.1 FL122.1 FL122.3 FL137.1 FL137.3 FL141.1 FL141.3 FL154.1 FL154.3 FL193.1 FL193.3 FL194.2 R323.1 TP99.1(TP) U59.AA14(VDDAR_CPU#AA14) U59.AA16(VDDAR_CPU#AA16) U59.AA18(VDDAR_CPU#AA18) U59.AC10(VDDAR_CPU#AC10) U59.K19(VDDAR_CPU#K19) U59.L21(VDDAR_CPU#L21) U59.P13(VDDAR_CPU#P13) U59.R18(VDDAR_CPU#R18) U59.U12(VDDAR_CPU#U12) U59.U19(VDDAR_CPU#U19) U59.V9(VDDAR_CPU#V9) U59.V17(VDDAR_CPU#V17) U59.Y11(VDDAR_CPU#Y11)
VDDAR_MCU_0V85: C285.1 C984.1 C1005.1 C1036.1 FL42.2 U59.K25(VDDAR_MCU#K25) U59.L22(VDDAR_MCU#L22)
VDDC_1V2_XDS: C16.1 C17.1 C576.1 U170.87(VDDC#87) U170.115(VDDC#115)
VDDI_UFS: C107.1 U26.A9(VDDI)
VDDIM: C807.1 C808.1 U52.C2(VDDIM)
VDDIQ2_UFS: C113.1 U26.A8(VDDIQ2)
VDDIQ_UFS: C119.1 U26.A3(VDDIQ)
VDDOUT_1V8_CDCEL: C96.1 C97.1 C105.1 C109.1 C110.1 FL5.3(OUT) U23.6(VDDOUT#6) U23.10(VDDOUT#10) U23.13(VDDOUT#13)
VDDSHV0_MCU: C1034.1 C1067.1 R438.2 R452.2 U59.H27(VDDSHV0_MCU)
VDDSHV2_DV: C939.1 C957.1 C958.1 R425.2 R426.2 U59.N28(VDDSHV2#N28) U59.P28(VDDSHV2#P28)
VIN_MON_PORZ: R591.2 R600.1 U255.1(A)
VINPUT: C92.1 C106.1 C116.1 C124.1 C130.1 C199.1 C235.1 C280.1 C301.1 C667.1 C678.1 C1038.1 C1055.1 R3.1 R125.2 R148.2 R620.1 R829.1 TP31.1(TP) U25.25(VIN) U28.3(S) U45.5(D) U46.25(VIN) U49.5(D) U81.15(VIN) U178.5(D) U180.5(D) U237.5(D)
VINT_PMIC_1V8: C267.1 TP308.1(TP) U68.2(VOUT_LDOVINT)
2P_FTDI_RXR_OE#: R1225.1 U257.4(OUT) U259.15(1\O\E\)
AMUXOUT_A: TP130.1(TP) U68.1(AMUXOUT)
AOUT1_A: C1242.1 R1272.2 R1276.1 R1279.1 R1283.1
AOUT1_B: C1242.2 R1271.2 R1275.1 R1279.2 R1282.1
AOUT1_C: C1234.2 R1272.1 U267.6(-INB)
AOUT1_D: C1233.1 R1271.1 U267.5(+INB)
AOUT1_E: C1233.2 R1273.2 R1274.1 R1275.2
AOUT1_N: C1263.2 U154.32(VOUT1-)
AOUT1_O: C1229.1 C1234.1 R1276.2 U267.7(OUTB)
AOUT1_P: C1262.2 U154.31(VOUT1+)
AOUT1N: C1263.1 R1283.2
AOUT1P: C1262.1 R1282.2
AOUT2_A: C1193.1 R1219.1 R1226.1 R1237.1 R1239.2
AOUT2_B: C1193.2 R1222.1 R1226.2 R1236.1 R1238.2
AOUT2_C: C1202.2 R1239.1 U267.2(-INA)
AOUT2_D: C1201.1 R1238.1 U267.3(+INA)
AOUT2_E: C1201.2 R1229.1 R1230.2 R1236.2
AOUT2_N: C1194.2 U154.30(VOUT2-)
AOUT2_O: C1202.1 C1215.1 R1237.2 U267.1(OUTA)
AOUT2_P: C1195.2 U154.29(VOUT2+)
AOUT2N: C1194.1 R1219.2
AOUT2P: C1195.1 R1222.2
ATEST0: TP149.1(TP) U59.M30(RSVD_M30)
ATEST1: TP144.1(TP) U59.J29(RSVD_J29)
AUDIO_EXT_REFCLK1: U112.5(2B1) U154.41(SCKI)
AUDIO_EXT_REFCLK1/UART3_TXD: U58.46(4B2) U112.7(2A)
AUDIO_MUX1_OE#: C406.2 R608.1 U112.15(O\E\)
AUDIO_MUX2_OE#: C369.2 R560.1 U108.15(O\E\)
AUDIO_MUX_SEL: R609.1 R610.2 U43.14(P14) U108.1(S) U112.1(S)
BOARDID_EEPROM_A0: R1055.1 R1056.2 U72.1(A0) U73.1(A0)
BOARDID_EEPROM_A1: R1077.2 R1087.2 U72.2(A1) U73.2(A1)
BOARDID_EEPROM_A2: R1078.2 R1088.2 U72.3(A2) U73.3(A2)
BOARDID_EEPROM_WP: J56.25 R33.2 R1095.2 SW2.9 U72.7(WP) U73.7(WP)
BOOT_EEPROM_A1: R1178.2 R1182.2 U250.2(A1)
BOOT_EEPROM_A2: R1179.2 R1183.2 U250.3(A2)
BOOT_EEPROM_WP: R1066.1 R1151.2 U59.D16(WKUP_GPIO0_1) U250.7(WP)
BOOTBUF_ADDR: R1132.2 U243.26(ADDR)
BOOTMODEON: R1180.1 R1184.2 U233.22(O\E\) U244.14(2\O\E\) U244.15(1\O\E\) U248.14(2\O\E\) U248.15(1\O\E\)
BOOTMODEON_IN1: R1170.1 TP190.1(TP) U253.1(A)
BUF_1V8_BOOTMODE0: R1116.2 U248.13(1B1)
BUF_1V8_BOOTMODE1: R1117.2 U248.12(1B2)
BUF_1V8_BOOTMODE2: R1115.2 U248.11(2B1)
BUF_1V8_BOOTMODE3: R1114.2 U248.10(2B2)
BUF_3V3_BOOTMODE4: R1145.2 U244.13(1B1)
BUF_3V3_BOOTMODE5: R1142.2 U244.12(1B2)
BUF_3V3_BOOTMODE6: R1138.2 U244.11(2B1)
BUF_3V3_BOOTMODE7: R1137.2 U244.10(2B2)
BUF_MCU_BOOTMODE2: R1072.1 R1073.2 R1074.2 U233.21(B1)
BUF_MCU_BOOTMODE3: R1065.2 U233.20(B2)
BUF_MCU_BOOTMODE4: R1066.2 U233.19(B3)
BUF_MCU_BOOTMODE5: R1067.2 U233.18(B4)
BUF_MCU_BOOTMODE6: R1068.2 U233.17(B5)
BUF_MCU_BOOTMODE7: R1069.2 U233.16(B6)
BUF_MCU_BOOTMODE8: R1070.2 U233.15(B7)
BUF_MCU_BOOTMODE9: R1071.2 U233.14(B8)
C_DP0_AUX_N: C52.1 U59.AJ25(DP0_AUXN)
C_DP0_AUX_P: C51.1 U59.AJ24(DP0_AUXP)
C_DP0_TX0_N: C45.1 U59.AJ21(SERDES4_TX0_N)
C_DP0_TX0_P: C44.1 U59.AJ22(SERDES4_TX0_P)
C_DP0_TX1_N: C38.1 U59.AM18(SERDES4_TX1_N)
C_DP0_TX1_P: C37.1 U59.AM19(SERDES4_TX1_P)
C_DP0_TX2_N: C47.1 U59.AN20(SERDES4_TX2_N)
C_DP0_TX2_P: C46.1 U59.AN21(SERDES4_TX2_P)
C_DP0_TX3_N: C40.1 U59.AL22(SERDES4_TX3_N)
C_DP0_TX3_P: C39.1 U59.AL23(SERDES4_TX3_P)
C_DP1_AUX_N: C664.1 U187.35(AUXN)
C_DP1_AUX_P: C665.1 U187.34(AUXP)
C_DP1_TX0_N: C662.1 U187.38(ML0N)
C_DP1_TX0_P: C663.1 U187.37(ML0P)
C_DP1_TX1_N: C660.1 U187.40(ML1N)
C_DP1_TX1_P: C661.1 U187.39(ML1P)
C_DP1_TX2_N: C658.1 U187.45(ML2N)
C_DP1_TX2_P: C659.1 U187.44(ML2P)
C_DP1_TX3_N: C656.1 U187.47(ML3N)
C_DP1_TX3_P: C657.1 U187.46(ML3P)
C_PCIE0_TX0_N: C627.1 U59.AK11(SERDES1_TX0_N)
C_PCIE0_TX0_P: C628.1 U59.AK12(SERDES1_TX0_P)
C_PCIE0_TX1_N: C625.1 U59.AM9(SERDES1_TX1_N)
C_PCIE0_TX1_P: C626.1 U59.AM10(SERDES1_TX1_P)
C_PCIE0_TX2_N: C623.1 U59.AK8(SERDES1_TX2_N)
C_PCIE0_TX2_P: C624.1 U59.AK9(SERDES1_TX2_P)
C_PCIE0_TX3_N: C621.1 U59.AJ9(SERDES1_TX3_N)
C_PCIE0_TX3_P: C622.1 U59.AJ10(SERDES1_TX3_P)
C_PCIE1/HYP0_TX0_N: C689.1 U59.AN11(SERDES0_TX0_N)
C_PCIE1/HYP0_TX0_P: C690.1 U59.AN12(SERDES0_TX0_P)
C_PCIE1/HYP0_TX1_N: C687.1 U59.AJ19(SERDES0_TX1_N)
C_PCIE1/HYP0_TX1_P: C688.1 U59.AJ18(SERDES0_TX1_P)
CAN_STB: J54.102 R709.1 R794.1 U152.8(STB)
CAN_WKUP: D39.1(CATHODE) R658.2 R684.2
CANIO_RET_WAKE: C303.1 D37.2 R476.2 SW8.2 SW8.3 TP164.1(TP) U59.E19(MCU_SPI0_CS0)
CANUART_MUX1_SEL1: R405.1 R411.2 U58.56(S1) U173.16(P17)
CANUART_MUX2_SEL1: R805.2 U50.56(S1) U173.15(P16)
CANUART_MUX_SEL0: R40.2 R1025.2 R1032.1 SW2.2 U50.1(S0) U58.1(S0) U173.14(P15) U227.1(S)
CANUART_MUX_SEL2: R403.2 U50.55(S2) U58.55(S2)
CDCEL_XIN: C78.2 U23.1(XIN/CLK) Y1.2
CDCEL_XOUT: C79.2 U23.20(XOUT) Y1.1
CDCEL_Y1: R115.1 U23.17(Y1)
CDCEL_Y4: R126.1 U23.7(Y4)
CDCEL_Y5: R131.1 U23.8(Y5)
CDCEL_Y6: R134.1 U23.12(Y6)
CDCEL_Y7: R138.1 U23.11(Y7)
CDCI1_EEPROMSEL: R917.1 R921.2 U40.23(EEPROMSEL)
CDCI1_OE1: R931.2 U40.20(STATUS/GPIO1)
CDCI1_OE1/OE4: R224.2 R931.1 U40.11(OE/GPIO4) U43.12(P12)
CDCI1_OE2/OE3: R225.2 R230.1 R236.2 U40.19(SDA/GPIO2) U43.13(P13)
CDCI1_OE3: R227.2 R230.2 U40.12(SCL/GPIO3)
CDCI1_REFSEL: R920.1 U40.4(REFSEL)
CDCI1_XIN: C163.2 U40.1(XIN) Y4.2
CDCI1_XOUT: C162.2 U40.2(XOUT) Y4.1
CDCI1_Y0: TP49.1(TP) U40.7(Y0)
CDCI1_Y1N: R219.1 U40.21(Y1N)
CDCI1_Y1P: R214.1 U40.22(Y1P)
CDCI1_Y2N: R246.1 U40.17(Y2N)
CDCI1_Y2P: R242.1 U40.18(Y2P)
CDCI1_Y3N: R233.1 U40.13(Y3N)
CDCI1_Y3P: R238.1 U40.14(Y3P)
CDCI1_Y4N: R212.1 U40.9(Y4N)
CDCI1_Y4P: R217.1 U40.10(Y4P)
CDCI2_EEPROMSEL: R135.2 R141.1 U22.23(EEPROMSEL)
CDCI2_OE1: TP24.1(TP) U22.20(STATUS/GPIO1)
CDCI2_OE4: R65.2 R66.1 TP17.1(TP) U22.11(OE/GPIO4)
CDCI2_REFSEL: R76.1 U22.4(REFSEL)
CDCI2_RSTZ: R808.2 U22.8(RESETN/SYNC) U173.12(P13)
CDCI2_XIN: C99.2 U22.1(XIN) Y3.2
CDCI2_XOUT: C90.2 U22.2(XOUT) Y3.1
CDCI2_Y0: TP18.1(TP) U22.7(Y0)
CDCI2_Y2N: R122.1 U22.17(Y2N)
CDCI2_Y2P: R123.1 U22.18(Y2P)
CLKGEN_PCIE0_4L_REFCLK_N: R92.2 R246.2 R248.1
CLKGEN_PCIE0_4L_REFCLK_P: R77.2 R240.1 R242.2
CLKGEN_PCIE1_2L_REFCLK_N: R152.2 R211.1 R212.2
CLKGEN_PCIE1_2L_REFCLK_P: R155.2 R217.2 R218.1
CLKGEN_SERDES0_REFCLK_N: R170.2 R219.2 R221.1
CLKGEN_SERDES0_REFCLK_P: R171.2 R210.1 R214.2
CLKGEN_SERDES1_REFCLK_N: R166.2 R231.1 R233.2
CLKGEN_SERDES1_REFCLK_P: R176.2 R238.2 R239.1
CODEC_I2C_ADR0: R693.2 R694.1 U154.45(MS/ADR0/MD0)
CODEC_I2C_ADR1: R698.2 R699.1 U154.44(MDO/ADR1/MD1)
CODEC_MODE: R687.1 R688.2 U154.48(MODE)
CODEC_OVF: TP245.1(TP) U154.5(OVF)
CODEC_RSTZ: R695.2 TP231.1(TP) U132.2(P0) U154.4(RST#)
CODEC_SPARE1: TP230.1(TP) U132.3(P1)
CODEC_VREFAD1: C1227.1 U154.59(VREFAD1)
CODEC_VREFAD2: C484.1 U154.60(VREFAD2)
CODEC_ZERO: TP247.1(TP) U154.13(ZERO)
COMP1_LM5140: C195.1 R253.2 U46.29(COMP1)
COMP1_LM5143: C95.1 R117.2 U25.2(COMP2) U25.29(COMP1)
COMP2_LM5140: C239.1 R279.1 U46.2(COMP2)
COMP_LM5141: C306.1 R473.1 U81.20(COMP)
CON_DP0_AUX_N: D28.1(I/O) J9.17(AUX_CH_N) L18.2(IN2) R45.1
CON_DP0_AUX_P: D27.1(I/O) J9.15(AUX_CH_P) L18.3(OUT1) R44.2
CON_DP0_TX0_N: D20.1(I/O) J9.3(ML_L0_N) L14.2(IN2)
CON_DP0_TX0_P: D19.1(I/O) J9.1(ML_L0_P) L14.3(OUT1)
CON_DP0_TX1_N: D14.1(I/O) J9.6(ML_L1_N) L11.2(IN2)
CON_DP0_TX1_P: D13.1(I/O) J9.4(ML_L1_P) L11.3(OUT1)
CON_DP0_TX2_N: D26.1(I/O) J9.9(ML_L2_N) L16.2(IN2)
CON_DP0_TX2_P: D25.1(I/O) J9.7(ML_L2_P) L16.3(OUT1)
CON_DP0_TX3_N: D16.1(I/O) J9.12(ML_L3_N) L12.2(IN2)
CON_DP0_TX3_P: D15.1(I/O) J9.10(ML_L3_P) L12.3(OUT1)
CON_DP1_AUX_N: D24.1(I/O) J8.17(AUX_CH_N) L17.2(IN2) R43.1
CON_DP1_AUX_P: D23.1(I/O) J8.15(AUX_CH_P) L17.3(OUT1) R42.2
CON_DP1_TX0_N: D18.1(I/O) J8.3(ML_L0_N) L13.2(IN2)
CON_DP1_TX0_P: D17.1(I/O) J8.1(ML_L0_P) L13.3(OUT1)
CON_DP1_TX1_N: D10.1(I/O) J8.6(ML_L1_N) L9.2(IN2)
CON_DP1_TX1_P: D9.1(I/O) J8.4(ML_L1_P) L9.3(OUT1)
CON_DP1_TX2_N: D22.1(I/O) J8.9(ML_L2_N) L15.2(IN2)
CON_DP1_TX2_P: D21.1(I/O) J8.7(ML_L2_P) L15.3(OUT1)
CON_DP1_TX3_N: D12.1(I/O) J8.12(ML_L3_N) L10.2(IN2)
CON_DP1_TX3_P: D11.1(I/O) J8.10(ML_L3_P) L10.3(OUT1)
CON_HYP0_RXFLCLK: J10.27 R309.2 R311.2
CON_HYP0_RXFLDAT: J10.25 R298.2 R302.2
CON_HYP0_RXPMCLK: J10.39 R261.2 R263.2
CON_HYP0_RXPMDAT: J10.37 R257.2 R258.2
CON_HYP0_TXFLCLK: J10.29 R273.2 R275.2
CON_HYP0_TXFLDAT: J10.31 R267.2 R268.2
CON_HYP0_TXPMCLK: J10.33 R287.2 R291.2
CON_HYP0_TXPMDAT: J10.35 R281.2 R282.2
CON_PCIE0_4L_REFCLK_N: C66.2 J14.A14(REFCLK-) R83.2 R92.1
CON_PCIE0_4L_REFCLK_P: C63.2 J14.A13(REFCLK+) R77.1 R83.1
CON_PCIE1_2L_REFCLK_N: C125.2 J17.A14(REFCLK-) R152.1 R153.2
CON_PCIE1_2L_REFCLK_P: C129.2 J17.A13(REFCLK+) R153.1 R155.1
CON_PM1_SCL: J30.1 U269.3(1B) U274.1(IO1)
CON_PM1_SDA: J30.2 U269.6(2B) U274.2(IO2)
CON_PM2_SCL: J30.5 U269.11(4B) U274.5(IO4)
CON_PM2_SDA: J30.4 U269.8(3B) U274.4(IO3)
CONN_MMC1_SDCD: J53.9(CD1) R292.1 R903.2 U191.5(IO2)
CORE_0V8_IN+: C707.2 R904.1 U188.D3(IN+) U189.10(VIN+)
CORE_0V8_IN-: C707.1 R898.1 U188.D1(BUS) U188.D2(IN-) U189.8(VBUS) U189.9(VIN-)
CORE_RAM_0V85_IN+: C797.2 R969.1 U207.D3(IN+) U208.10(VIN+)
CORE_RAM_0V85_IN-: C797.1 R968.1 U207.D1(BUS) U207.D2(IN-) U208.8(VBUS) U208.9(VIN-)
CPU_AVS_IN+: C714.2 R919.1 U194.D3(IN+) U195.10(VIN+)
CPU_AVS_IN-: C714.1 R911.1 U194.D1(BUS) U194.D2(IN-) U195.8(VBUS) U195.9(VIN-)
CS1_LM5140: C202.2 R244.2 U46.27(CS1)
CS1_LM5143: C121.2 R151.2 U25.27(CS1)
CS2_LM5140: C234.1 R288.2 U46.4(CS2)
CS2_LM5143: C94.1 R111.2 U25.4(CS2)
CS_LM5141: L35.2 R449.1 U81.18(CS)
CSI0_RX0_N: J57.11 U59.AL32(CSI0_RXN0)
CSI0_RX0_P: J57.9 U59.AL31(CSI0_RXP0)
CSI0_RX1_N: J57.15 U59.AM31(CSI0_RXN1)
CSI0_RX1_P: J57.13 U59.AM30(CSI0_RXP1)
CSI0_RX2_N: J57.19 U59.AN30(CSI0_RXN2)
CSI0_RX2_P: J57.17 U59.AN29(CSI0_RXP2)
CSI0_RX3_N: J57.23 U59.AK33(CSI0_RXN3)
CSI0_RX3_P: J57.21 U59.AK32(CSI0_RXP3)
CSI0_RX_CALIB: R984.1 U59.AH31(CSI0_RXRCALIB)
CSI0_RXCLK_N: J57.7 U59.AH33(CSI0_RXCLKN)
CSI0_RXCLK_P: J57.5 U59.AH32(CSI0_RXCLKP)
CSI1_RX0_N: J57.31 U59.AF30(CSI1_RXN0)
CSI1_RX0_P: J57.29 U59.AG30(CSI1_RXP0)
CSI1_RX1_N: J57.35 U59.AE33(CSI1_RXN1)
CSI1_RX1_P: J57.33 U59.AF33(CSI1_RXP1)
CSI1_RX2_N: J57.39 U59.AE31(CSI1_RXN2)
CSI1_RX2_P: J57.37 U59.AF31(CSI1_RXP2)
CSI1_RX3_N: J57.28 U59.AF32(CSI1_RXN3)
CSI1_RX3_P: J57.26 U59.AG32(CSI1_RXP3)
CSI1_RX_CALIB: R981.1 U59.AJ33(CSI1_RXRCALIB)
CSI1_RXCLK_N: J57.27 U59.AE29(CSI1_RXCLKN)
CSI1_RXCLK_P: J57.25 U59.AF29(CSI1_RXCLKP)
CSI1_TX0_N: J10.11 U59.AK30(DSI1_TXN0)
CSI1_TX0_P: J10.9 U59.AK29(DSI1_TXP0)
CSI1_TX1_N: J10.15 U59.AL29(DSI1_TXN1)
CSI1_TX1_P: J10.13 U59.AL28(DSI1_TXP1)
CSI1_TX2_N: J10.19 U59.AM28(DSI1_TXN2)
CSI1_TX2_P: J10.17 U59.AM27(DSI1_TXP2)
CSI1_TX3_N: J10.23 U59.AN27(DSI1_TXN3)
CSI1_TX3_P: J10.21 U59.AN26(DSI1_TXP3)
CSI1_TXCLK_N: J10.7 U59.AJ31(DSI1_TXCLKN)
CSI1_TXCLK_P: J10.5 U59.AJ30(DSI1_TXCLKP)
CSI2_A_GPIO0_DV: J57.6 U80.4(1A1)
CSI2_A_GPIO1_DV: J57.8 U242.1(A1)
CSI2_A_GPIO2_DV: J57.18 U242.3(A2)
CSI2_A_GPIO3_DV: J57.20 U242.4(A3)
CSI2_A_GPIO4_DV: J57.22 U242.5(A4)
CSI2_A_REFCLK_DV: J57.10 U80.5(1A2)
CSI2_B_GPIO1_DV: J55.8 U242.6(A5)
CSI2_B_GPIO2_DV: J55.18 U242.7(A6)
CSI2_B_GPIO3_DV: J55.20 U242.8(A7)
CSI2_B_GPIO4_DV: J55.22 U242.9(A8)
CSI2_B_REFCLK_DV: J55.10 U80.6(2A1)
CSI2_EXP_A_GPIO0: U76.3(P1) U80.13(1B1)
CSI2_EXP_A_GPIO1: U76.4(P2) U242.20(B1)
CSI2_EXP_A_GPIO2: U50.31(11B2) U242.18(B2)
CSI2_EXP_A_GPIO3: U76.5(P3) U242.17(B3)
CSI2_EXP_A_GPIO4: U50.29(12B2) U242.16(B4)
CSI2_EXP_B_GPIO1: U76.7(P4) U242.15(B5)
CSI2_EXP_B_GPIO2: U76.8(P5) U242.14(B6)
CSI2_EXP_B_GPIO3: U76.9(P6) U242.13(B7)
CSI2_EXP_B_GPIO4: U76.10(P7) U242.12(B8)
CSI2_EXP_RSTZ: R469.2 U76.2(P0) U80.10(2B2)
CSI2_I2C_SCL_DV: J55.2 J57.2 R510.2 U88.3(SCL1)
CSI2_I2C_SDA_DV: J55.4 J57.4 R501.2 U88.4(SDA1)
CSI2_REFCLK: R131.2 U80.11(2B1) U80.12(1B2)
CSI2_RSTZ_DV: J55.14 J57.14 R471.1
CSI2_RX0_N: J55.11 U59.AC30(CSI2_RXN0)
CSI2_RX0_P: J55.9 U59.AD30(CSI2_RXP0)
CSI2_RX1_N: J55.15 U59.AB31(CSI2_RXN1)
CSI2_RX1_P: J55.13 U59.AC31(CSI2_RXP1)
CSI2_RX2_N: J55.19 U59.AC32(CSI2_RXN2)
CSI2_RX2_P: J55.17 U59.AD32(CSI2_RXP2)
CSI2_RX3_N: J55.23 U59.AB33(CSI2_RXN3)
CSI2_RX3_P: J55.21 U59.AC33(CSI2_RXP3)
CSI2_RX_CALIB: R918.1 U59.AH29(CSI2_RXRCALIB)
CSI2_RXCLK_N: J55.7 U59.AC29(CSI2_RXCLKN)
CSI2_RXCLK_P: J55.5 U59.AB29(CSI2_RXCLKP)
CSI_VIO_SEL: R35.2 SW2.7 U265.1(EN1)
CTRL_PM_I2C_OE#: Q1.1(G) R132.2 U173.9(P10)
DDR0_CA0: U54.H2(CA0_A) U54.R2(CA0_B) U59.AA3(DDR0_CA0)
DDR0_CA1: U54.J2(CA1_A) U54.P2(CA1_B) U59.Y4(DDR0_CA1)
DDR0_CA2: U54.H9(CA2_A) U54.R9(CA2_B) U59.AA4(DDR0_CA2)
DDR0_CA3: U54.H10(CA3_A) U54.R10(CA3_B) U59.AB3(DDR0_CA3)
DDR0_CA4: U54.H11(CA4_A) U54.R11(CA4_B) U59.Y3(DDR0_CA4)
DDR0_CA5: U54.J11(CA5_A) U54.P11(CA5_B) U59.AB5(DDR0_CA5)
DDR0_CAL0: R946.1 U59.R7(DDR0_CAL0)
DDR0_CK_C: U54.J9(CK_C_A) U54.P9(CK_C_B) U59.Y2(DDR0_CKN)
DDR0_CK_T: U54.J8(CK_T_A) U54.P8(CK_T_B) U59.AA1(DDR0_CKP)
DDR0_CKE0: U54.J4(CKE0_A) U54.P4(CKE0_B) U59.AB6(DDR0_CKE0)
DDR0_CKE1: U54.J5(CKE1_A) U54.P5(CKE1_B) U59.AB7(DDR0_CKE1)
DDR0_CSN0_0: U54.H4(CS0_A) U59.AA6(DDR0_CSN0_0)
DDR0_CSN0_1: U54.R4(CS0_B) U59.Y5(DDR0_CSN0_1)
DDR0_CSN1_0: U54.H3(CS1_A) U59.Y7(DDR0_CSN1_0)
DDR0_CSN1_1: U54.R3(CS1_B) U59.AA7(DDR0_CSN1_1)
DDR0_DM0_DBI0#: U54.C3(DMI0_A) U59.U6(DDR0_DM0)
DDR0_DM1_DBI1#: U54.C10(DMI1_A) U59.V2(DDR0_DM1)
DDR0_DM2_DBI2#: U54.Y3(DMI0_B) U59.AE2(DDR0_DM2)
DDR0_DM3_DBI3#: U54.Y10(DMI1_B) U59.AF6(DDR0_DM3)
DDR0_DQ0: U54.B2(DQ0_A) U59.R5(DDR0_DQ0)
DDR0_DQ1: U54.C2(DQ1_A) U59.R4(DDR0_DQ1)
DDR0_DQ2: U54.E2(DQ2_A) U59.R2(DDR0_DQ2)
DDR0_DQ3: U54.F2(DQ3_A) U59.T4(DDR0_DQ3)
DDR0_DQ4: U54.F4(DQ4_A) U59.U5(DDR0_DQ4)
DDR0_DQ5: U54.E4(DQ5_A) U59.T3(DDR0_DQ5)
DDR0_DQ6: U54.C4(DQ6_A) U59.T6(DDR0_DQ6)
DDR0_DQ7: U54.B4(DQ7_A) U59.T7(DDR0_DQ7)
DDR0_DQ8: U54.B11(DQ8_A) U59.V4(DDR0_DQ8)
DDR0_DQ9: U54.C11(DQ9_A) U59.V7(DDR0_DQ9)
DDR0_DQ10: U54.E11(DQ10_A) U59.W3(DDR0_DQ10)
DDR0_DQ11: U54.F11(DQ11_A) U59.V5(DDR0_DQ11)
DDR0_DQ12: U54.F9(DQ12_A) U59.W6(DDR0_DQ12)
DDR0_DQ13: U54.E9(DQ13_A) U59.U2(DDR0_DQ13)
DDR0_DQ14: U54.C9(DQ14_A) U59.W4(DDR0_DQ14)
DDR0_DQ15: U54.B9(DQ15_A) U59.U3(DDR0_DQ15)
DDR0_DQ16: U54.AA2(DQ0_B) U59.AD5(DDR0_DQ16)
DDR0_DQ17: U54.Y2(DQ1_B) U59.AC3(DDR0_DQ17)
DDR0_DQ18: U54.V2(DQ2_B) U59.AE3(DDR0_DQ18)
DDR0_DQ19: U54.U2(DQ3_B) U59.AB2(DDR0_DQ19)
DDR0_DQ20: U54.U4(DQ4_B) U59.AC4(DDR0_DQ20)
DDR0_DQ21: U54.V4(DQ5_B) U59.AD2(DDR0_DQ21)
DDR0_DQ22: U54.Y4(DQ6_B) U59.AC6(DDR0_DQ22)
DDR0_DQ23: U54.AA4(DQ7_B) U59.AD4(DDR0_DQ23)
DDR0_DQ24: U54.AA11(DQ8_B) U59.AG4(DDR0_DQ24)
DDR0_DQ25: U54.Y11(DQ9_B) U59.AG2(DDR0_DQ25)
DDR0_DQ26: U54.V11(DQ10_B) U59.AF3(DDR0_DQ26)
DDR0_DQ27: U54.U11(DQ11_B) U59.AE5(DDR0_DQ27)
DDR0_DQ28: U54.U9(DQ12_B) U59.AE6(DDR0_DQ28)
DDR0_DQ29: U54.V9(DQ13_B) U59.AG5(DDR0_DQ29)
DDR0_DQ30: U54.Y9(DQ14_B) U59.AF4(DDR0_DQ30)
DDR0_DQ31: U54.AA9(DQ15_B) U59.AH6(DDR0_DQ31)
DDR0_DQS0_N: U54.E3(DQS0_C_A) U59.T1(DDR0_DQS0N)
DDR0_DQS0_P: U54.D3(DQS0_T_A) U59.R1(DDR0_DQS0P)
DDR0_DQS1_N: U54.E10(DQS1_C_A) U59.W1(DDR0_DQS1N)
DDR0_DQS1_P: U54.D10(DQS1_T_A) U59.V1(DDR0_DQS1P)
DDR0_DQS2_N: U54.V3(DQS0_C_B) U59.AC1(DDR0_DQS2N)
DDR0_DQS2_P: U54.W3(DQS0_T_B) U59.AD1(DDR0_DQS2P)
DDR0_DQS3_N: U54.V10(DQS1_C_B) U59.AF1(DDR0_DQS3N)
DDR0_DQS3_P: U54.W10(DQS1_T_B) U59.AG1(DDR0_DQS3P)
DDR0_ODT_CA_A: R998.1 R1012.2 U54.G2(ODT_CA_A)
DDR0_ODT_CA_B: R970.1 R978.2 U54.T2(ODT_CA_B)
DDR0_RET: R378.1 U59.AC7(DDR0_RET)
DDR0_RST#: R965.1 U54.T11(RESET_N) U59.W7(DDR0_RESETN)
DDR0_ZQ0: R1019.2 U54.A5(ZQ0)
DDR0_ZQ1: R1020.2 U54.A8(ZQ1)
DDR1_CA0: U59.J4(DDR1_CA0) U71.H2(CA0_A) U71.R2(CA0_B)
DDR1_CA1: U59.H3(DDR1_CA1) U71.J2(CA1_A) U71.P2(CA1_B)
DDR1_CA2: U59.G2(DDR1_CA2) U71.H9(CA2_A) U71.R9(CA2_B)
DDR1_CA3: U59.J3(DDR1_CA3) U71.H10(CA3_A) U71.R10(CA3_B)
DDR1_CA4: U59.G3(DDR1_CA4) U71.H11(CA4_A) U71.R11(CA4_B)
DDR1_CA5: U59.H4(DDR1_CA5) U71.J11(CA5_A) U71.P11(CA5_B)
DDR1_CAL0: R396.1 U59.F8(DDR1_CAL0)
DDR1_CK_C: U59.H1(DDR1_CKN) U71.J9(CK_C_A) U71.P9(CK_C_B)
DDR1_CK_T: U59.J2(DDR1_CKP) U71.J8(CK_T_A) U71.P8(CK_T_B)
DDR1_CKE0: U59.E7(DDR1_CKE0) U71.J4(CKE0_A) U71.P4(CKE0_B)
DDR1_CKE1: U59.H6(DDR1_CKE1) U71.J5(CKE1_A) U71.P5(CKE1_B)
DDR1_CSN0_0: U59.G6(DDR1_CSN0_0) U71.H4(CS0_A)
DDR1_CSN0_1: U59.G7(DDR1_CSN0_1) U71.R4(CS0_B)
DDR1_CSN1_0: U59.H7(DDR1_CSN1_0) U71.H3(CS1_A)
DDR1_CSN1_1: U59.F6(DDR1_CSN1_1) U71.R3(CS1_B)
DDR1_DM0_DBI0#: U59.A3(DDR1_DM0) U71.C3(DMI0_A)
DDR1_DM1_DBI1#: U59.F3(DDR1_DM1) U71.C10(DMI1_A)
DDR1_DM2_DBI2#: U59.L2(DDR1_DM2) U71.Y3(DMI0_B)
DDR1_DM3_DBI3#: U59.P2(DDR1_DM3) U71.Y10(DMI1_B)
DDR1_DQ0: U59.A6(DDR1_DQ0) U71.B2(DQ0_A)
DDR1_DQ1: U59.C6(DDR1_DQ1) U71.C2(DQ1_A)
DDR1_DQ2: U59.A5(DDR1_DQ2) U71.E2(DQ2_A)
DDR1_DQ3: U59.C4(DDR1_DQ3) U71.F2(DQ3_A)
DDR1_DQ4: U59.B4(DDR1_DQ4) U71.F4(DQ4_A)
DDR1_DQ5: U59.B2(DDR1_DQ5) U71.E4(DQ5_A)
DDR1_DQ6: U59.C3(DDR1_DQ6) U71.C4(DQ6_A)
DDR1_DQ7: U59.B5(DDR1_DQ7) U71.B4(DQ7_A)
DDR1_DQ8: U59.E5(DDR1_DQ8) U71.B11(DQ8_A)
DDR1_DQ9: U59.D2(DDR1_DQ9) U71.C11(DQ9_A)
DDR1_DQ10: U59.E2(DDR1_DQ10) U71.E11(DQ10_A)
DDR1_DQ11: U59.F4(DDR1_DQ11) U71.F11(DQ11_A)
DDR1_DQ12: U59.D6(DDR1_DQ12) U71.F9(DQ12_A)
DDR1_DQ13: U59.E4(DDR1_DQ13) U71.E9(DQ13_A)
DDR1_DQ14: U59.D3(DDR1_DQ14) U71.C9(DQ14_A)
DDR1_DQ15: U59.D5(DDR1_DQ15) U71.B9(DQ15_A)
DDR1_DQ16: U59.M3(DDR1_DQ16) U71.AA2(DQ0_B)
DDR1_DQ17: U59.K4(DDR1_DQ17) U71.Y2(DQ1_B)
DDR1_DQ18: U59.M2(DDR1_DQ18) U71.V2(DQ2_B)
DDR1_DQ19: U59.L5(DDR1_DQ19) U71.U2(DQ3_B)
DDR1_DQ20: U59.J5(DDR1_DQ20) U71.U4(DQ4_B)
DDR1_DQ21: U59.K3(DDR1_DQ21) U71.V4(DQ5_B)
DDR1_DQ22: U59.L4(DDR1_DQ22) U71.Y4(DQ6_B)
DDR1_DQ23: U59.K6(DDR1_DQ23) U71.AA4(DQ7_B)
DDR1_DQ24: U59.N6(DDR1_DQ24) U71.AA11(DQ8_B)
DDR1_DQ25: U59.P4(DDR1_DQ25) U71.Y11(DQ9_B)
DDR1_DQ26: U59.N3(DDR1_DQ26) U71.V11(DQ10_B)
DDR1_DQ27: U59.M5(DDR1_DQ27) U71.U11(DQ11_B)
DDR1_DQ28: U59.M6(DDR1_DQ28) U71.U9(DQ12_B)
DDR1_DQ29: U59.P5(DDR1_DQ29) U71.V9(DQ13_B)
DDR1_DQ30: U59.N4(DDR1_DQ30) U71.Y9(DQ14_B)
DDR1_DQ31: U59.P6(DDR1_DQ31) U71.AA9(DQ15_B)
DDR1_DQS0_N: U59.C1(DDR1_DQS0N) U71.E3(DQS0_C_A)
DDR1_DQS0_P: U59.B1(DDR1_DQS0P) U71.D3(DQS0_T_A)
DDR1_DQS1_N: U59.F1(DDR1_DQS1N) U71.E10(DQS1_C_A)
DDR1_DQS1_P: U59.E1(DDR1_DQS1P) U71.D10(DQS1_T_A)
DDR1_DQS2_N: U59.K1(DDR1_DQS2N) U71.V3(DQS0_C_B)
DDR1_DQS2_P: U59.L1(DDR1_DQS2P) U71.W3(DQS0_T_B)
DDR1_DQS3_N: U59.N1(DDR1_DQS3N) U71.V10(DQS1_C_B)
DDR1_DQS3_P: U59.P1(DDR1_DQS3P) U71.W10(DQS1_T_B)
DDR1_ODT_CA_A: R1054.2 R1064.1 U71.G2(ODT_CA_A)
DDR1_ODT_CA_B: R1121.2 R1127.1 U71.T2(ODT_CA_B)
DDR1_RET: R404.1 U59.G8(DDR1_RET)
DDR1_RST#: R1120.1 U59.G5(DDR1_RESETN) U71.T11(RESET_N)
DDR1_ZQ0: R1041.2 U71.A5(ZQ0)
DDR1_ZQ1: R1040.2 U71.A8(ZQ1)
DDR3_IO_PLL_REFCLK_TEST0P: R1247.2 TP295.1(TP) U59.W31(SPI0_D1)
DDR3_IO_PLL_TESTOUT0P: R1251.2 TP293.1(TP) U59.V30(SPI0_D0)
DIR1: R1144.1 U244.2(1DIR) U244.3(2DIR) U248.2(1DIR) U248.3(2DIR)
DIR2: R1109.1 U233.2(DIR)
DLL_0V8_IN+: C371.2 R562.1 U99.D3(IN+) U100.10(VIN+)
DLL_0V8_IN-: C371.1 R558.1 U99.D1(BUS) U99.D2(IN-) U100.8(VBUS) U100.9(VIN-)
DP0_AUX_N: C52.2 L18.1(IN1)
DP0_AUX_P: C51.2 L18.4(OUT2)
DP0_CONFIG1: J9.13(CONFIG1) R757.1
DP0_CONFIG2: J9.14(CONFIG2) R754.1
DP0_HPD: J9.18(HPD) R759.2 U167.2(A)
DP0_HPD_BUF: U59.Y33(SPI0_CS0) U167.4(Y)
DP0_PWR_SW_EN: R798.1 U18.2(P0) U174.5(EN)
DP0_TX0_N: C45.2 L14.1(IN1)
DP0_TX0_P: C44.2 L14.4(OUT2)
DP0_TX1_N: C38.2 L11.1(IN1)
DP0_TX1_P: C37.2 L11.4(OUT2)
DP0_TX2_N: C47.2 L16.1(IN1)
DP0_TX2_P: C46.2 L16.4(OUT2)
DP0_TX3_N: C40.2 L12.1(IN1)
DP0_TX3_P: C39.2 L12.4(OUT2)
DP1_AUX_N: C664.2 L17.1(IN1)
DP1_AUX_P: C665.2 L17.4(OUT2)
DP1_CONFIG1: J8.13(CONFIG1) R758.1
DP1_CONFIG2: J8.14(CONFIG2) R755.1
DP1_HPD: J8.18(HPD) R760.2 U168.2(A)
DP1_HPD_BUF: R776.2 U168.4(Y)
DP1_PWR_SW_EN: R786.1 U18.3(P1) U169.5(EN)
DP1_TX0_N: C662.2 L13.1(IN1)
DP1_TX0_P: C663.2 L13.4(OUT2)
DP1_TX1_N: C660.2 L9.1(IN1)
DP1_TX1_P: C661.2 L9.4(OUT2)
DP1_TX2_N: C658.2 L15.1(IN1)
DP1_TX2_P: C659.2 L15.4(OUT2)
DP1_TX3_N: C656.2 L10.1(IN1)
DP1_TX3_P: C657.2 L10.4(OUT2)
DSI0_TX0_N: U59.AL26(DSI0_TXN0) U187.20(DA0N)
DSI0_TX0_P: U59.AL25(DSI0_TXP0) U187.19(DA0P)
DSI0_TX1_N: U59.AK27(DSI0_TXN1) U187.22(DA1N)
DSI0_TX1_P: U59.AK26(DSI0_TXP1) U187.21(DA1P)
DSI0_TX2_N: U59.AM25(DSI0_TXN2) U187.28(DA2N)
DSI0_TX2_P: U59.AM24(DSI0_TXP2) U187.27(DA2P)
DSI0_TX3_N: U59.AN24(DSI0_TXN3) U187.30(DA3N)
DSI0_TX3_P: U59.AN23(DSI0_TXP3) U187.29(DA3P)
DSI0_TX_CALIB: R1018.1 U59.AH25(DSI0_TXRCALIB)
DSI0_TXCLK_N: U59.AJ28(DSI0_TXCLKN) U187.25(DACN)
DSI0_TXCLK_P: U59.AJ27(DSI0_TXCLKP) U187.24(DACP)
DSI1_TX_CALIB: R979.1 U59.AH27(DSI1_TXRCALIB)
EDP_ADDR: R915.1 U187.1(ADDR)
EDP_GPIO1: R893.2 R894.1 U187.58(GPIO1)
EDP_GPIO2: R883.2 R884.1 U187.56(GPIO2)
EDP_GPIO3: R864.2 R874.1 U187.54(GPIO3)
EDP_GPIO4: R889.2 R890.1 U187.57(GPIO4)
EDP_I2C4_SCL: R113.2 U20.3(SCL1) U187.15(SCL)
EDP_I2C4_SDA: R112.2 U20.4(SDA1) U187.16(SDA)
EDP_IRQ: R999.2 U187.61(IRQ) U220.2(A)
EDP_REFCLK: R857.1 R858.2 TP258.1(TP) U187.51(REFCLK)
EDP_TEST1: R897.2 U187.60(TEST1)
EDP_TEST2: R880.1 R881.2 U187.55(TEST2)
EDP_TEST3: C668.2 U187.50(TEST3)
EMMC_RSTZ: R966.2 TP289.1(TP) U52.K5(RST_N) U213.4(Y)
EN1_LM5140: R255.1 U46.31(EN1)
EN1_LM5143: R148.1 U25.31(EN1)
EN2_LM5140: R271.1 R1308.1 U46.40(EN2)
EN2_LM5143: R125.1 U25.40(EN2)
EN_3V3_VIO: R337.2 R401.2 R546.2 R932.1 R1308.2 U53.3(EN2) U62.3(ON) U68.19(GPIO9) U201.4(EN) U281.3(IN0)
EN_DDR_RET_1V1: Q4.2(G1) R378.2 R404.2 R557.1 U68.24(GPIO6)
EN_DDR_VDD1: Q3.3(D2) R534.1 U85.4(EN)
EN_DRV_OUT: R433.2 TP150.1(TP) U68.29(EN_DRV)
EN_EFUSE_VPP: R407.1 R414.1 R416.2 U67.4(EN)
EN_GPIO_RET_3V3: R1063.1 U68.23(GPIO5) U70.2(G1) U279.6(IN2)
EN_GPIORET_VIO: R437.2 U75.3(ON) U279.4(Y)
EN_GPIORET_WKLG: R409.2 U66.4(EN) U70.3(D2)
EN_LM5141_ON: R481.1 R1305.1 U81.23(EN)
EN_SD_3V3: U53.1(EN1) U281.4(Y)
EN_TPS61240: R662.2 U139.4(EN)
EVM_PDN_TEST: R663.2 SW16.3 U268.1(S)
EVM_PMIC_EN: R652.2 SW16.1 U268.11(3B1)
EVM_SVS_EN: R660.2 SW16.2 U268.14(4B1)
EXP_3V3: C597.1 C630.1 C654.1 C691.1 C809.1 C815.1 C1162.1 C1164.1 C1168.1 C1170.1 C1171.1 J14.A9(+3.3V#A9) J14.A10(+3.3V#A10) J14.B8(+3.3V#B8) J17.A9(+3.3V#A9) J17.A10(+3.3V#A10) J17.B8(+3.3V#B8) J55.30 J55.32 J55.34 J55.36 J56.2 J56.4 J56.6 J57.30 J57.32 J57.34 J57.36 R181.4 R181.6 R825.1 R872.1
EXP_3V3_N: R181.5 TP32.1(TP)
EXP_3V3_P: R181.2 TP36.1(TP)
EXP_EEPROM_A0: J56.19 R1177.2
EXP_EEPROM_A1: J56.21 R1171.2
EXP_EEPROM_A2: J56.23 R1168.2
EXP_MUX2: J56.34 U43.15(P15)
EXP_MUX3: J56.36 U43.16(P16)
EXP_REFCLK: J56.22 R138.2
EXP_RSTZ: J54.118 TP48.1(TP) U39.4(Y)
EXT_I2C_SCL: J37.1 R1277.1 U268.2(1B1)
EXT_I2C_SDA: J37.3 R1278.1 U268.5(2B1)
EXT_MIPI_EMU0: R321.2 U47.11(3B1)
EXT_MIPI_EMU1: R314.2 U47.14(4B1)
EXT_MIPI_TCK: R375.1 R381.2 U47.2(1B1)
EXT_MIPI_TDI: R374.1 R944.2 U206.5(2B1)
EXT_MIPI_TDO: R383.2 U206.2(1B1)
EXT_MIPI_TMS: R389.2 R394.2 U206.11(3B1)
EXT_MIPI_TRST#: R371.1 R373.1 U47.5(2B1)
FB_LM5141: R465.2 R466.1 U81.19(FB)
FB_MCU_V2V5: R641.1 R643.2 U138.8(FB)
FB_V1V0: R607.1 R611.2 U125.8(FB)
FB_V1V1: R1264.1 R1265.2 U266.8(FB)
FB_V1V2: R865.1 R866.2 U186.8(FB)
FB_V2V5: R1244.1 R1248.2 U260.8(FB)
FB_V3V3_DP0: R791.2 R793.1 U174.8(FB)
FB_V3V3_DP1: R766.2 R769.1 U169.8(FB)
FT2232_EECLK: R669.1 TP329.1(TP) U144.62(EECLK) U147.2(CLK)
FT2232_EECS: R670.1 TP330.1(TP) U144.63(EECS) U147.1(CS)
FT2232_EEDIN: R668.2 TP327.1(TP) U144.61(EEDATA) U147.3(DI)
FT2232_EEDOUT: R667.1 R668.1 TP328.1(TP) U147.4(DO)
FT2232_NR: C1251.1 U276.4(NR)
FT2232_PWREN#: R725.2 U144.60(PWREN#)
FT2232_REF: R703.2 U144.6(REF)
FT2232_RESET#: C514.1 R701.1 U144.14(RESET#)
FT2232_SUSPEND#: TP223.1(TP) U144.36(SUSPEND#)
FT2232_UART0_RTS#: U144.18(ADBUS2) U270.12(1B2)
FT2232_UART0_RXD: U144.17(ADBUS1) U270.11(2B1)
FT2232_UART0_TXD: U144.16(ADBUS0) U270.13(1B1)
FT2232_UART1_CTS#: U144.41(BDBUS3) U259.10(2B2)
FT2232_UART1_RTS#: U144.40(BDBUS2) U259.12(1B2)
FT2232_UART1_RXD: U144.39(BDBUS1) U259.11(2B1)
FT2232_UART1_TXD: U144.38(BDBUS0) U259.13(1B1)
FT2232_VPHY: C510.1 C1243.2 L40.2 U144.4(VPHY)
FT2232_VPLL: C512.1 C1245.1 L43.2 U144.9(VPLL)
FT2232_XIN: C519.2 U144.2(OSCI) Y8.1
FT2232_XOUT: C525.2 U144.3(OSCO) Y8.2
FT4232_EECLK: R1269.1 U145.62(EECLK) U275.2(CLK)
FT4232_EECS: R1270.1 U145.63(EECS) U275.1(CS)
FT4232_EEDIN: R1268.2 U145.61(EEDATA) U275.3(DI)
FT4232_EEDOUT: R1266.1 R1268.1 U275.4(DO)
FT4232_NR: C1253.1 U277.4(NR)
FT4232_PWREN#: R727.2 U145.60(P\W\R\E\N\)
FT4232_REF: R704.2 U145.6(REF)
FT4232_RESET#: C517.1 R702.1 U145.14(R\E\S\E\T\)
FT4232_SUSPEND#: TP224.1(TP) U145.36(S\U\S\P\E\N\D\)
FT4232_UART0_CTS#: U145.19(ADBUS3) U273.10(2B2)
FT4232_UART0_RTS#: U145.18(ADBUS2) U273.12(1B2)
FT4232_UART0_RXD: U145.17(ADBUS1) U273.11(2B1)
FT4232_UART0_TXD: U145.16(ADBUS0) U273.13(1B1)
FT4232_UART1_RXD: U145.27(BDBUS1) U264.11(2B1)
FT4232_UART1_TXD: U145.26(BDBUS0) U264.13(1B1)
FT4232_UART2_RXD: U145.39(CDBUS1) U264.10(2B2)
FT4232_UART2_TXD: U145.38(CDBUS0) U264.12(1B2)
FT4232_UART3_RTS#: U143.12(1B2) U145.53(DDBUS2)
FT4232_UART3_RXD: U143.11(2B1) U145.52(DDBUS1)
FT4232_UART3_TXD: U143.13(1B1) U145.48(DDBUS0)
FT4232_VPHY: C511.1 C1244.2 L41.2 U145.4(VPHY)
FT4232_VPLL: C515.1 C1246.1 L42.2 U145.9(VPLL)
FT4232_XIN: C509.2 U145.2(OSCI) Y7.1
FT4232_XOUT: C523.2 U145.3(OSCO) Y7.2
GATE: U16.6(GATE) U21.4(GATE)
GESI_EXP_PHY_RSTZ: R200.2 R204.1 U39.2(B) U43.17(P17)
GESI_GPIO_RGMII1_RST#: J56.29 R778.1
GESI_MCAN4_RX: J54.55 R954.2
GESI_MCAN4_TX: J54.53 R958.2
GESI_MDIO0_MDC: J54.97 R935.1
GESI_MDIO0_MDIO: J54.99 R933.1
GESI_RGMII1_INT#: J56.15 R962.2
GESI_RGMII1_RD0: J54.69 R1005.2
GESI_RGMII1_RD1: J54.77 R1004.2
GESI_RGMII1_RD2: J54.75 R1002.2
GESI_RGMII1_RD3: J54.79 R1000.2
GESI_RGMII1_RX_CTL: J54.71 R1003.2
GESI_RGMII1_RXC: J54.73 R1001.2
GESI_RGMII1_TD0: J54.72 R989.2
GESI_RGMII1_TD1: J54.70 R990.2
GESI_RGMII1_TD2: J54.78 R986.2
GESI_RGMII1_TD3: J54.76 R985.2
GESI_RGMII1_TX_CTL: J54.74 R987.2
GESI_RGMII1_TXC: J54.80 R988.2
GESI_RMII8_CLKOUT: R367.2 TP117.1(TP)
GESI_RMII8_CRS_DV: J56.64 R335.2
GESI_RMII8_PHY_INTN: J56.56 R963.2
GESI_RMII8_REF_CLK: J54.54 R365.2
GESI_RMII8_RX_ER: J56.58 R333.2
GESI_RMII8_RXD0: J56.44 R332.2
GESI_RMII8_RXD1: J56.48 R334.2
GESI_RMII8_TX_EN: J56.62 R364.2
GESI_RMII8_TXD0: J56.60 R363.2
GESI_RMII8_TXD1: J56.46 R366.2
GESI_SPI5_CLK: J54.105 R1059.2
GESI_SPI5_CS0: J54.59 R1101.2
GESI_SPI5_CS1: J54.57 R1093.2
GESI_SPI5_D0: J54.101 R1075.2
GESI_SPI5_D1: J54.103 R1085.2
GESI_UART8_RXD: J56.7 R582.2
GESI_UART8_TXD: J56.9 R577.2
GESI_UART9_RXD: J56.88 R1113.2
GESI_UART9_TXD: J56.90 R1108.2
GPIO0_14: TP90.1(TP) U50.54(1B1)
GPIO0_15: TP85.1(TP) U50.52(2B1)
GPIO0_29: TP126.1(TP) U58.7(3B3)
GPIO0_30: TP121.1(TP) U58.10(4B3)
GPIO_EDP_ENABLE: R913.1 U18.4(P2)
GPIO_LIN_EN: J54.110 R1189.2 R1195.1 U109.2(EN1) U109.5(EN2) U173.7(P06)
GPIO_MCU_RGMII1_RST#: R586.1 R587.2 R1145.1 U59.A19(WKUP_GPIO0_56) U111.2(B)
GPIO_ONAND_RESET#: R1140.1 U241.40(C1)
GPIO_PRG1_RGMII_RST: J54.66 R941.1
GPIO_RGMII1_RST#: R561.1 R567.2 R777.1 U107.2(B)
GPIO_USD_PWR_EN: R199.2 U34.3(ON) U173.3(P02)
H_MAIN_WK0N: R645.1 U59.T30(PMIC_WAKE0)
H_MCU_INTN: R446.2 R448.1 TP158.1(TP) U68.14(NINT)
H_MCU_PORZ: R1062.1 TP220.1(TP) U68.25(NRSTOUT) U258.1(A)
H_MCU_WK1N: R646.1 U59.A20(WKUP_GPIO0_49)
H_SOC_PORZ: R1033.1 TP123.1(TP) U68.53(GPIO11) U252.1(A)
H_WKUP_I2C0_SCL: U35.13(SCL) U42.13(SCL) U68.31(SCL_I2C1/SCK_SPI) U87.16(SCL) U89.16(SCL) U268.4(1A)
H_WKUP_I2C0_SDA: U35.12(SDA) U42.12(SDA) U68.30(SDA_I2C1/SDI_SPI) U87.15(SDA) U89.15(SDA) U268.7(2A)
HB1: C201.2 D34.1(CATHODE) U46.20(HB1)
HB2: C232.1 D35.1(CATHODE) U46.11(HB2)
HB_LM5141: C302.2 D38.1(CATHODE) U81.11(HB)
HCPS_A_CPU_FSEL_PH1: R194.2 R195.1 U35.16(FSEL)
HCPS_A_CPU_FSEL_PH2: R188.2 R189.1 U36.16(FSEL)
HCPS_A_CPU_FSEL_PH3: R191.2 R192.1 U37.16(FSEL)
HCPS_A_CPU_PG: C705.1 R907.2 TP38.1(TP)
HCPS_A_CPU_VSEL: R196.2 R197.1 U35.15(VSEL)
HCPS_A_SYNC_OUT_PH1: U35.14(SYNC_OUT) U36.11(MODE/SYNC)
HCPS_A_SYNC_OUT_PH2: R190.1 U36.14(SYNC_OUT) U37.11(MODE/SYNC)
HCPS_A_SYNC_OUT_PH3: R193.1 U37.14(SYNC_OUT)
HCPS_B_CORE_FSEL_PH1: R228.1 R234.2 U42.16(FSEL)
HCPS_B_CORE_FSEL_PH2: R265.1 R269.2 U48.16(FSEL)
HCPS_B_CORE_PG: C171.1 R213.2 TP51.1(TP)
HCPS_B_CORE_VSEL: R216.1 R223.2 U42.15(VSEL)
HCPS_B_SY_OUT_PH2: R262.1 U48.14(SYNC_OUT)
HCPS_B_SYNC_OUT_PH1: U42.14(SYNC_OUT) U48.11(MODE/SYNC)
HO1: R252.2 U46.22(HO1)
HO2: R277.1 U46.9(HO2)
HO_LM5141: R464.1 U81.13(HO)
HOL1: R252.1 U45.4(G) U46.23(HOL1)
HOL2: R277.2 U46.8(HOL2) U49.4(G)
HOL_LM5141: R464.2 U81.14(HOL) U237.4(G)
HYP0_RXFLCLK: R309.1 U50.3(1B3)
HYP0_RXFLDAT: R298.1 U50.5(2B3)
HYP0_RXPMCLK: R261.1 U50.22(9B3)
HYP0_RXPMCLK_MUX: R264.2 U50.21(9A)
HYP0_RXPMDAT: R257.1 U50.24(10B3)
HYP0_TXFLCLK: R273.1 U50.12(5B3)
HYP0_TXFLDAT: R267.1 U50.14(6B3)
HYP0_TXPMCLK: R287.1 U50.7(3B3)
HYP0_TXPMCLK_MUX: R294.2 U50.6(3A)
HYP0_TXPMDAT: R281.1 U50.10(4B3)
HYP0_TXPMDAT_MUX: R283.2 U50.9(4A)
HYP1_RXFLCLK: J10.20 R346.2
HYP1_RXFLCLK_MUX: U58.21(9A) U59.H33(MCASP0_AXR2)
HYP1_RXFLCLK_R: R346.1 U58.22(9B3)
HYP1_RXFLDAT: J10.22 U58.3(1B3)
HYP1_RXPMCLK: J10.8 U58.12(5B3)
HYP1_RXPMDAT: J10.10 U58.14(6B3)
HYP1_TXFLCLK: J10.18 U58.26(11B3)
HYP1_TXFLDAT: J10.14 U58.28(12B3)
HYP1_TXPMCLK: J10.4 U58.5(2B3)
HYP1_TXPMDAT: J10.2 U58.20(8B3)
I2C0_IOEXP_INT#: R229.2 R384.2 U43.22(I\N\T\) U173.32(I\N\T\)
I2C0_SCL: R227.1 R303.2 U22.12(SCL/GPIO3) U23.18(S2/SCL) U43.19(SCL) U59.AA30(I2C0_SCL) U173.29(SCL) U181.12(SCL) U256.6(SCL)
I2C0_SDA: R225.1 R297.2 U22.19(SDA/GPIO2) U23.19(S1/SDA) U43.20(SDA) U59.Y30(I2C0_SDA) U173.30(SDA) U181.13(SDA) U256.5(SDA)
I2C1_SCL: R95.1 R96.2 U58.31(11B2)
I2C1_SCL_MUX: R328.1 U58.25(11A) U59.L31(ECAP0_IN_APWM_OUT)
I2C1_SDA: R90.2 R91.1 U58.29(12B2)
I2C1_SDA_MUX: R327.1 U58.27(12A) U59.J33(EXT_REFCLK1)
I2C3_SCL: R1280.2 U58.33(10B2) U132.12(SCL) U154.42(MC/SCL/FMT)
I2C3_SCL_MUX: R339.1 U58.23(10A) U59.N33(MCAN0_TX)
I2C3_SDA: R1281.2 U50.33(10B2) U132.13(SDA) U154.43(MDI/SDA/DEMP)
I2C3_SDA_MUX: R259.2 R260.1 U50.23(10A)
I2C4_SCL: R809.2 U18.12(SCL) U20.6(SCL2) U59.R33(MCAN14_TX)
I2C4_SDA: R810.2 U18.13(SDA) U20.5(SDA2) U59.T32(MCAN13_RX)
I2C5_SCL: R1147.2 U59.R29(MCAN15_TX) U76.12(SCL) U88.6(SCL2)
I2C5_SDA: R1143.2 U59.R30(MCAN14_RX) U76.13(SDA) U88.5(SDA2)
IFORCE: TP161.1(TP) U59.L30(RSVD_L30)
IOEXP1_A0: R250.2 R251.1 U43.18(ADDR)
IOEXP2_A0: R771.1 R773.1 U173.26(ADDR)
IOEXP3_ADDR: R628.2 R638.1 U132.16(ADDR)
IOEXP3_INT#: R616.1 U132.11(I\N\T\)
IOEXP4_ADDR: R97.2 R98.1 U18.16(ADDR)
IOEXP4_INT#: R72.1 U18.11(I\N\T\)
IOEXP5_ADDR: R453.1 R459.2 U76.16(ADDR)
IOEXP5_INT#: R345.1 R443.1 U76.11(I\N\T\)
JTAG_MUX1_OE#: C772.2 R951.1 U206.15(O\E\)
JTAG_MUX2_OE#: C204.2 R256.1 U47.15(O\E\)
JTAG_MUX_SEL: R290.1 R952.2 R953.1 U47.1(S) U206.1(S)
JTAG_RESETZ: R376.1 R588.1 R1156.2 R1157.1
L_TPS61240: L37.2 U142.5(L)
L_TPS61240_1: L36.2 U139.5(L)
LEOA_OSC32KCAP: C977.1 U68.40(OSC32KCAP)
LEOA_OSC32KIN: C941.2 U68.38(OSC32KIN) Y10.2
LEOA_OSC32KOUT: C917.2 U68.39(OSC32KOUT) Y10.1
LIN1_DATA: C377.1 J28.2 SW13.3 U109.13(LIN1)
LIN1_RXD: R596.1 R602.2 U109.1(RXD1)
LIN1_TXD: R597.2 R603.2 U109.3(TXD1)
LIN2_DATA: C379.1 J28.3 SW13.4 U109.9(LIN2)
LIN2_RXD: R598.1 R604.2 U109.4(RXD2)
LIN2_TXD: R599.2 R605.2 U109.7(TXD2)
LIN_UART6_RXD: R581.1 R582.1 U58.53(1B2)
LIN_UART6_TXD: R576.1 R577.1 U58.51(2B2)
LIN_UART9_RXD: R1112.1 R1113.1 U58.44(5B2)
LIN_UART9_TXD: R1107.1 R1108.1 U58.42(6B2)
LINE_OUT2_L: C1229.2 J29.5B R1263.1
LINE_OUT2_R: C1215.2 J29.2B R1252.1
LJCB_ATEST0: TP275.1(TP) U59.AH7(RSVD_AH7)
LJCB_ATEST1: TP269.1(TP) U59.AH8(RSVD_AH8)
LM5060_EN: J6.2 R830.2 R845.1 SW1.2 U182.5(EN)
LM5060_EN_HIGH: J6.1 R780.2 SW1.3
LM5060_EN_LOW: J6.3 SW1.1
LM5060_GATE: C643.2 U28.1(G) U182.10(GATE)
LM5060_NPGD: R830.1 R831.1 U182.8(NPGD)
LM5060_OUT: R829.2 U182.9(OUT)
LM5060_OVP: R850.2 R851.1 U182.3(OVP)
LM5060_SENSE: R846.2 U182.1(SENSE)
LM5060_TIMER: C650.1 U182.7(TIMER)
LM5060_ULVO: R847.2 R849.1 U182.4(UVLO)
LM5140/LM5143/LM5141_PG: R1190.2 R1191.2 R1192.2 R1193.2 U255.3(B)
LM5140_LO1: R254.1 R940.1 U44.4(G)
LM5140_LO2: R272.2 R950.2 U51.4(G)
LM5140_PG1: R939.1 R1153.1 R1193.1 U46.24(PG1)
LM5140_PG1/LM5140_PG2: R1153.2 R1155.2 U247.1(A)
LM5140_PG2: R956.1 R1155.1 U46.7(PG2)
LM5140_SW1: C201.1 L23.2 U44.5(D) U45.1(S1) U45.2(S2) U45.3(S3) U46.21(SW1)
LM5140_SW2: C232.2 L29.1 U46.10(SW2) U49.1(S1) U49.2(S2) U49.3(S3) U51.5(D)
LM5141_PG: R1131.1 R1191.1 U81.21(PG)
LM5143_FB: R832.2 R833.2 R834.2 U25.28(FB1)
LM5143_HB1: C122.2 D32.1(CATHODE) U25.20(HB1)
LM5143_HB2: C100.1 D31.1(CATHODE) U25.11(HB2)
LM5143_HO1: R149.2 U25.22(HO1)
LM5143_HO2: R118.1 U25.9(HO2)
LM5143_HOL1: R149.1 U25.23(HOL1) U180.4(G)
LM5143_HOL2: R118.2 U25.8(HOL2) U178.4(G)
LM5143_LO1: U25.18(LO1) U25.19(LOL1) U27.4(G)
LM5143_LO2: U24.4(G) U25.12(LOL2) U25.13(LO2)
LM5143_PG1: R828.1 R1192.1 U25.24(PG1)
LM5143_PG2: R817.1 R1190.1 U25.7(PG2)
LM5143_SW1: C122.1 L22.2 U25.21(SW1) U27.5(D) U180.1(S1) U180.2(S2) U180.3(S3)
LM5143_SW2: C100.2 L21.1 U24.5(D) U25.10(SW2) U178.1(S1) U178.2(S2) U178.3(S3)
LO1: R254.2 U46.18(LO1)
LO2: R272.1 U46.13(LO2)
LO_LM5141: R482.1 U81.8(LO)
LOL1: R940.2 U46.19(LOL1)
LOL2: R950.1 U46.12(LOL2)
LOL_LM5141: R488.1 U81.7(LOL)
LSM6DSRX_CS: R1043.2 R1047.2 U228.12(CS)
LSM6DSRX_INT: R1028.2 R1029.2 U228.4(INT1)
LSM6DSRX_INT2: TP140.1(TP) U228.9(INT2)
LSM6DSRX_SA0: R1030.2 U228.1(SDO/SA0)
MAIN_ATEST: TP160.1(TP) U59.L28(RSVD_L28)
MAIN_PWRGRP_IRQN: R206.2 R487.1 R1294.1 R1298.1 R1300.1 U35.4(EN) U36.4(EN) U37.4(EN) U42.4(EN) U48.4(EN) U216.3(D) U234.2(A)
MAIN_PWRGRP_IRQN_BUF: R1089.1 U234.4(Y)
MAIN_RET_WAKE: C160.1 D33.1 R202.2 SW3.2 SW3.3 TP39.1(TP) U59.P32(GPIO0_11)
MAIN_SVS_SLEEPN: R546.1 U87.7(NSLEEP)
MAX6818_CH#: R539.2 U98.11(C\H\)
MAX6818_EN#: R568.2 U98.1(E\N\)
MCAN3_EN: R1267.1 U148.6(EN)
MCAN3_FAULT#: TP250.1(TP) U148.8(NFAULT)
MCAN3_H: J41.1 R712.1 U148.13(CANH)
MCAN3_L: J41.3 R711.2 U148.12(CANL)
MCAN3_PWR_ON_HV: R676.2 R684.1 TP239.1(TP) U148.7(INH)
MCAN3_RX: J32.2 R677.1 U108.3(1B2)
MCAN3_RX_MUX: U58.18(8A) U59.J32(MCASP0_AXR4)
MCAN3_STB#: R792.1 U155.2(A)
MCAN3_STBN: U148.14(NSTB) U155.4(Y)
MCAN3_T: C530.1 R711.1 R712.2
MCAN3_TX: J32.1 U112.3(1B2) U148.1(TXD)
MCAN3_TX_MUX: U58.15(7A) U59.F31(MCASP0_AXR3)
MCAN3_WAKE: J41.4 R723.1 R724.2 R726.2
MCAN4_H: J45.1 R720.1 U152.7(CANH)
MCAN4_L: J45.3 R719.2 U152.6(CANL)
MCAN4_RX: J36.2 R682.1 R955.2
MCAN4_RX_MUX: U50.18(8A) U59.K33(MCASP0_AXR6)
MCAN4_T: C541.1 R719.1 R720.2
MCAN4_TX: J36.1 R959.2 U152.1(TXD)
MCAN4_TX_MUX: U50.15(7A) U59.H30(MCASP0_AXR5)
MCAN5_H: J44.1 R718.1 U151.7(CANH)
MCAN5_L: J44.3 R717.2 U151.6(CANL)
MCAN5_RX: J35.2 R681.1 U112.13(4B2)
MCAN5_RX_MUX: R304.2 U50.4(2A)
MCAN5_STB: R708.1 R788.1 U151.8(STB)
MCAN5_T: C540.1 R717.1 R718.2
MCAN5_TX: J35.1 U112.10(3B2) U151.1(TXD)
MCAN5_TX_MUX: R315.2 U50.2(1A)
MCAN16_H: J46.1 R722.1 U153.7(CANH)
MCAN16_L: J46.3 R721.2 U153.6(CANL)
MCAN16_RX: R683.1 U59.U30(MCAN16_RX)
MCAN16_STB: R710.2 U153.8(STB)
MCAN16_T: C542.1 R721.1 R722.2
MCAN16_TX: U59.G30(MCAN16_TX) U153.1(TXD)
MCASP0_ACLKX: TP212.1(TP) U112.11(3B1) U154.7(BCKAD) U154.36(BCKDA)
MCASP0_ACLKX/MCAN5_TX: U50.53(1B2) U112.9(3A)
MCASP0_AFSX: TP217.1(TP) U112.14(4B1) U154.6(LRCKAD) U154.35(LRCKDA)
MCASP0_AFSX/MCAN5_RX: U50.51(2B2) U112.12(4A)
MCASP0_AXR3: U112.2(1B1) U154.37(DIN1)
MCASP0_AXR3/MCAN3_TX: U58.40(7B2) U112.4(1A)
MCASP0_AXR4: R705.2 U108.2(1B1)
MCASP0_AXR4/MCAN3_RX: U58.37(8B2) U108.4(1A)
MCASP0_AXR4_R: R705.1 U154.8(DOUT1)
MCASP4_AXR1/TRC_DATA16_MUX: U50.25(11A) U59.G29(MCAN0_RX)
MCASP4_AXR3/TRC_DATA5_MUX: U50.27(12A) U59.H31(MCAN1_RX)
MCU_0V85_IN+: C263.2 R393.1 U60.10(VIN+) U61.D3(IN+)
MCU_0V85_IN-: C263.1 R388.1 U60.8(VBUS) U60.9(VIN-) U61.D1(BUS) U61.D2(IN-)
MCU_1V8+: C389.2 R572.1 U118.10(VIN+) U119.D3(IN+)
MCU_1V8-: C389.1 R573.1 U118.8(VBUS) U118.9(VIN-) U119.D1(BUS) U119.D2(IN-)
MCU_ADC0_AIN0: J27.4 U59.E26(MCU_ADC0_AIN0)
MCU_ADC0_AIN1: J27.5 U59.F25(MCU_ADC0_AIN1)
MCU_ADC0_AIN2: J27.11 U59.F23(MCU_ADC0_AIN2)
MCU_ADC0_AIN3: C940.1 J27.2 U59.A28(MCU_ADC0_AIN3)
MCU_ADC0_AIN4: J27.9 U59.E24(MCU_ADC0_AIN4)
MCU_ADC0_AIN5: J27.15 U59.D27(MCU_ADC0_AIN5)
MCU_ADC0_AIN6: J27.6 U59.A26(MCU_ADC0_AIN6)
MCU_ADC0_AIN7: J27.3 U59.B27(MCU_ADC0_AIN7)
MCU_ADC1_AIN0: J27.17 J56.83 U59.C32(MCU_ADC1_AIN0)
MCU_ADC1_AIN1: J27.18 J56.85 U59.B33(MCU_ADC1_AIN1)
MCU_ADC1_AIN2: J56.87 U59.B31(MCU_ADC1_AIN2)
MCU_ADC1_AIN3: C925.1 J56.89 U59.B29(MCU_ADC1_AIN3)
MCU_ADC1_AIN4: J56.91 U59.D31(MCU_ADC1_AIN4)
MCU_ADC1_AIN5: J56.93 R385.2
MCU_ADC1_AIN6: J56.95 R392.2
MCU_ADC1_AIN7: J56.97 R379.2
MCU_ADC_EXT_TRIGGER0: J27.16 R1099.2
MCU_ADC_EXT_TRIGGER1: J56.103 R1098.2
MCU_BOOTMODE00: R414.2 R419.1 R420.2 TP142.1(TP)
MCU_BOOTMODE01: R422.1 R423.2 R428.2 TP146.1(TP)
MCU_BOOTMODE02: R475.2 SW7.1 U233.3(A1) U243.1(P00)
MCU_BOOTMODE03: R468.2 SW7.2 U233.4(A2) U243.2(P01)
MCU_BOOTMODE04: R461.2 SW7.3 U233.5(A3) U243.3(P02)
MCU_BOOTMODE05: R455.2 SW7.4 U233.6(A4) U243.4(P03)
MCU_BOOTMODE06: R451.2 SW7.5 U233.7(A5) U243.5(P04)
MCU_BOOTMODE07: R442.2 SW7.6 U233.8(A6) U243.6(P05)
MCU_BOOTMODE08: R436.2 SW7.7 U233.9(A7) U243.7(P06)
MCU_BOOTMODE09: R431.2 SW7.8 U233.10(A8) U243.8(P07)
MCU_CAN0_STB: R706.1 R1074.1 U59.E14(MCU_SPI0_D1) U149.8(STB)
MCU_CAN1_STB: R707.1 R1067.1 U59.D18(WKUP_GPIO0_2) U150.8(STB)
MCU_ENET_RSTZ: U111.4(Y) U261.43(RESET_N)
MCU_ETH_EARTH: C1247.2 C1248.2 J39.15(SH1) J39.16(SH2) J40.15(SH1) J40.16(SH2) R696.2 R697.2
MCU_I2C0_SCL: R1149.2 U55.1(SCL) U59.D22(MCU_I2C0_SCL) U68.32(GPIO1) U82.1(SCL) U250.6(SCL)
MCU_I2C0_SDA: R1150.2 U55.6(SDA) U59.A21(MCU_I2C0_SDA) U68.33(GPIO2) U82.6(SDA) U250.5(SDA)
MCU_I3C0_SCL: J25.3 R1038.1 U59.B19(WKUP_GPIO0_8) U228.13(SCL)
MCU_I3C0_SDA: J25.2 R1034.1 R1080.1 U59.A15(WKUP_GPIO0_9) U228.14(SDA)
MCU_I3C0_SDAPULLEN: R1080.2 TP148.1(TP) U59.B21(WKUP_GPIO0_11)
MCU_MCAN0_H: J42.1 R714.1 U149.7(CANH)
MCU_MCAN0_L: J42.3 R713.2 U149.6(CANL)
MCU_MCAN0_RX: J33.2 R679.1 U59.C18(MCU_MCAN0_RX)
MCU_MCAN0_T: C538.1 R713.1 R714.2
MCU_MCAN0_TX: J33.1 U59.E22(MCU_MCAN0_TX) U149.1(TXD)
MCU_MCAN1_H: J43.1 R716.1 U150.7(CANH)
MCU_MCAN1_L: J43.3 R715.2 U150.6(CANL)
MCU_MCAN1_RX: J34.2 R680.1 U59.D20(WKUP_GPIO0_5)
MCU_MCAN1_T: C539.1 R715.1 R716.2
MCU_MCAN1_TX: J34.1 U59.E16(WKUP_GPIO0_4) U150.1(TXD)
MCU_MDIO0_MDC: U59.E12(MCU_MDIO0_MDC) U261.16(MDC)
MCU_MDIO0_MDIO: R470.2 U59.F13(MCU_MDIO0_MDIO) U261.17(MDIO)
MCU_ONAND_CLK: R533.1 TP166.1(TP) U241.42(C0) U245.B2(CLK)
MCU_ONAND_CS0#: R519.2 U241.37(C2) U245.C2(C\S\)
MCU_ONAND_D0: R518.2 U241.33(C4) U245.D3(IO0)
MCU_ONAND_D1: R507.2 U241.35(C3) U245.D2(IO1)
MCU_ONAND_D2/WP: R527.2 U241.26(C7) U245.C4(IO2/W\P\)
MCU_ONAND_D3: R508.2 U241.31(C5) U245.D4(IO3)
MCU_ONAND_D4: R516.2 U241.24(C8) U245.D5(IO4)
MCU_ONAND_D5: R495.2 U241.22(C9) U245.E3(IO5)
MCU_ONAND_D6: R494.2 U241.20(C10) U245.E2(IO6)
MCU_ONAND_D7: R493.2 U241.18(C11) U245.E1(IO7)
MCU_ONAND_DS: R532.2 R540.1 U241.28(C6)
MCU_OSPI0/ONAND_RESET#: U59.F10(MCU_OSPI0_CSN2) U241.3(A1)
MCU_OSPI0_CLK: R543.1 TP177.1(TP) U241.41(B0) U246.B2(CK)
MCU_OSPI0_CS0#: R525.1 U241.38(B2) U246.C2(CS#)
MCU_OSPI0_D0: R517.2 U241.34(B4) U246.D3(DQ0)
MCU_OSPI0_D1: R506.2 U241.36(B3) U246.D2(DQ1)
MCU_OSPI0_D2: R523.2 U241.27(B7) U246.C4(DQ2)
MCU_OSPI0_D3: R513.2 U241.32(B5) U246.D4(DQ3)
MCU_OSPI0_D4: R500.2 U241.25(B8) U246.D5(DQ4)
MCU_OSPI0_D5: R491.2 U241.23(B9) U246.E3(DQ5)
MCU_OSPI0_D6: R490.2 U241.21(B10) U246.E2(DQ6)
MCU_OSPI0_D7: R489.2 U241.19(B11) U246.E1(DQ7)
MCU_OSPI0_DQS: R526.2 R542.2 R552.2 U241.29(B6)
MCU_OSPI0_LBCLKO: TP165.1(TP) U59.D10(MCU_OSPI0_LBCLKO)
MCU_OSPI0_RESET_OUT0: R1160.1 U241.39(B1)
MCU_OSPI0_RESET_OUT0_R: R1160.2 R1162.1 U97.2(B)
MCU_OSPI1_CLK: R457.2 R458.2 U79.B2(C)
MCU_OSPI1_CLK_R: R458.1 U59.B7(MCU_OSPI1_CLK)
MCU_OSPI1_CS0: R1133.1 U59.A8(MCU_OSPI1_CSN0) U79.C2(S#)
MCU_OSPI1_D0: R1125.1 U59.B8(MCU_OSPI1_D0) U79.D3(DQ0)
MCU_OSPI1_D1: R1124.1 U59.B11(MCU_OSPI1_D1) U79.D2(DQ1)
MCU_OSPI1_D2: R1130.1 U59.A11(MCU_OSPI1_D2) U79.C4(W#/DQ2)
MCU_OSPI1_D3: R1126.1 U59.A10(MCU_OSPI1_D3) U79.D4(DQ3/HOLD#)
MCU_OSPI1_DQS: R477.2 U59.B9(MCU_OSPI1_DQS)
MCU_OSPI1_LBCLKO: R477.1 U59.B10(MCU_OSPI1_LBCLKO)
MCU_PERIPH_1V8_RSTZ: TP193.1(TP) U79.A4(RESET#/DNU) U103.4(Y)
MCU_PERIPH_RSTZ: R559.2 R565.2 R626.2 R1139.1 R1159.1 R1181.1 U103.2(A) U257.2(IN A)
MCU_PERIPH_RSTZ_R: R1158.1 R1159.2 U97.1(A)
MCU_PORZ: TP221.1(TP) U59.C24(MCU_PORZ) U104.3(A) U124.4(Y)
MCU_PORZ_OE: R569.2 U104.5(OE)
MCU_PORZ_OUT: R559.1 R566.1 R1123.1 TP197.1(TP) U104.4(B) U111.1(A) U254.2(B)
MCU_PWRGRP_IRQN: R504.1 R512.1 R1299.1 TP127.1(TP) U68.42(GPIO10)
MCU_RESETSTATZ: R447.1 R565.1 TP157.1(TP) U59.E21(MCU_RESETSTATZ)
MCU_RESETZ: TP189.1(TP) U59.E20(MCU_RESETZ) U101.4(Y)
MCU_RGMII1_100MBPS: J40.14 R1290.1 U133.3(DRAIN)
MCU_RGMII1_1000MBPS: J40.13 R1287.1 U271.3(DRAIN)
MCU_RGMII1_ACT_LED: J40.12 U263.3(DRAIN)
MCU_RGMII1_CLK_OUT: TP228.1(TP) U261.18(CLK_OUT)
MCU_RGMII1_D0_N: J40.10(MX0-) U261.2(TD_M_A)
MCU_RGMII1_D0_P: J40.9(MX0+) U261.1(TD_P_A)
MCU_RGMII1_D1_N: J40.8(MX1-) U261.5(TD_M_B)
MCU_RGMII1_D1_P: J40.7(MX1+) U261.4(TD_P_B)
MCU_RGMII1_D2_N: J40.6(MX2-) U261.8(TD_M_C)
MCU_RGMII1_D2_P: J40.5(MX2+) U261.7(TD_P_C)
MCU_RGMII1_D3_N: J40.4(MX3-) U261.11(TD_M_D)
MCU_RGMII1_D3_P: J40.3(MX3+) U261.10(TD_P_D)
MCU_RGMII1_GPIO0_100: R622.1 R630.2 U133.1(GATE) U261.39(GPIO_0)
MCU_RGMII1_GPIO1: R1231.1 R1234.2 U261.40(GPIO_1)
MCU_RGMII1_INT#: R1246.1 U59.D19(WKUP_GPIO0_3) U261.44(INT/PWDN)
MCU_RGMII1_LED0: R650.2 R655.1 U261.47(LED0)
MCU_RGMII1_LED1_1000: R1255.1 R1260.2 U261.46(LED1) U271.1(GATE)
MCU_RGMII1_LED2_ACT: R1250.2 R1253.1 U261.45(LED2) U263.1(GATE)
MCU_RGMII1_LED2_ANODE: J40.11 R1286.1
MCU_RGMII1_RBIAS: R1258.2 U261.12(RBIAS)
MCU_RGMII1_RD0: R1204.1 U59.E13(MCU_RGMII1_RD0)
MCU_RGMII1_RD0_R: R1198.1 R1204.2 R1216.2 U261.33(RX_D0/SGMII_COP)
MCU_RGMII1_RD1: R1210.1 U59.D14(MCU_RGMII1_RD1)
MCU_RGMII1_RD1_R: R1210.2 U261.34(RX_D1/SGMII_CON)
MCU_RGMII1_RD2: R1203.1 U59.D12(MCU_RGMII1_RD2)
MCU_RGMII1_RD2_R: R1197.1 R1203.2 R1215.2 U261.35(RX_D2/SGMII_SOP)
MCU_RGMII1_RD3: R1209.1 U59.D13(MCU_RGMII1_RD3)
MCU_RGMII1_RD3_R: R1209.2 U261.36(RX_D3/SGMII_SON)
MCU_RGMII1_RX_CTL: R1206.1 U59.C12(MCU_RGMII1_RX_CTL)
MCU_RGMII1_RX_CTL_R: R1206.2 R1220.2 R1223.1 U261.38(RX_CTRL)
MCU_RGMII1_RXC: R1211.1 U59.C14(MCU_RGMII1_RXC)
MCU_RGMII1_RXC_R: R1211.2 U261.32(RX_CLK)
MCU_RGMII1_TD0: U59.B13(MCU_RGMII1_TD0) U261.28(TX_D0/SGMII_SIN)
MCU_RGMII1_TD1: U59.A13(MCU_RGMII1_TD1) U261.27(TX_D1/SGMII_SIP)
MCU_RGMII1_TD2: U59.B12(MCU_RGMII1_TD2) U261.26(TX_D2)
MCU_RGMII1_TD3: U59.A12(MCU_RGMII1_TD3) U261.25(TX_D3)
MCU_RGMII1_TX_CTL: U59.B14(MCU_RGMII1_TX_CTL) U261.37(TX_CTRL)
MCU_RGMII1_TXC: U59.A14(MCU_RGMII1_TXC) U261.29(GTX_CLK)
MCU_RGMII1_XIN: C1207.2 U261.15(X_I) Y12.2
MCU_RGMII1_XOUT: C1218.2 U261.14(X_O) Y12.1
MCU_SAFETY_ERRZ: R1081.1 TP315.1(TP) U59.C22(MCU_SAFETY_ERRORN)
MCU_SVS_SLEEPN: R528.1 R531.2 U89.7(NSLEEP)
MCU_UART0_CTS#: R1068.1 U59.D15(WKUP_GPIO0_14) U259.5(1A2)
MCU_UART0_RTS#: R1069.1 U59.C16(WKUP_GPIO0_15) U259.7(2A2)
MCU_UART0_RXD: R1071.1 U59.D21(WKUP_GPIO0_13) U259.4(1A1)
MCU_UART0_TXD: R1070.1 R1196.2 U59.D17(WKUP_GPIO0_12) U259.6(2A1)
MCU_WK1N: R645.2 R646.2 R647.1 U134.2(A)
MCUIO_1V8_IN+: C386.2 R583.1 U105.D3(IN+) U106.10(VIN+)
MCUIO_1V8_IN-: C386.1 R579.1 U105.D1(BUS) U105.D2(IN-) U106.8(VBUS) U106.9(VIN-)
MCUIO_3V3_IN+: C398.2 R601.1 U114.D3(IN+) U115.10(VIN+)
MCUIO_3V3_IN-: C398.1 R592.1 U114.D1(BUS) U114.D2(IN-) U115.8(VBUS) U115.9(VIN-)
MDIO0_MDC: R349.2 R935.2 U59.H29(MCASP1_AXR0)
MDIO0_MDIO: R344.2 R926.2 R933.2 U59.N32(MCASP1_AFSX)
MIC1_L: J29.5A R644.2 R656.1
MIC1_L_N: C447.2 R642.2 R651.2 U154.51(VIN1-)
MIC1_L_P: C447.1 R625.2 R632.2 R636.2 U154.52(VIN1+)
MIC1_R: J29.2A R665.1 R675.2
MIC1_R_N: C491.1 R672.2 R691.2 R692.2 U154.53(VIN2-)
MIC1_R_P: C491.2 R674.2 R685.2 U154.54(VIN2+)
MIC1L_A: C434.2 R625.1 U135.1(OUTA)
MIC1L_AC: C432.1 R617.1
MIC1L_B: C434.1 R617.2 R632.1 U135.2(-INA)
MIC1L_BIAS: C459.2 R656.2 R657.2
MIC1L_BIAS_AC: C440.1 C459.1 R640.2 U141.6(-INB)
MIC1L_C: C452.1 R636.1 R642.1 U135.6(-INB)
MIC1L_D: C452.2 R651.1 U135.7(OUTB)
MIC1L_PRE: C440.2 R634.1 R640.1 U141.7(OUTB)
MIC1L_PRE_BP: C432.2 R633.2 R644.1
MIC1L_PREAMP: R633.1 R634.2 R637.2
MIC1R_A: C506.2 R691.1 U146.1(OUTA)
MIC1R_AC: C503.1 R700.1
MIC1R_B: C506.1 R692.1 R700.2 U146.2(-INA)
MIC1R_BIAS: C479.2 R665.2 R666.2
MIC1R_BIAS_AC: C479.1 C499.1 R678.2 U141.2(-INA)
MIC1R_C: C488.1 R672.1 R674.1 U146.6(-INB)
MIC1R_D: C488.2 R685.1 U146.7(OUTB)
MIC1R_PRE: C499.2 R678.1 R690.1 U141.1(OUTA)
MIC1R_PRE_BP: C503.2 R675.1 R689.2
MIC1R_PREAMP: R686.2 R689.1 R690.2
MIPI_DETECT: J23.58 R290.2
MIPI_EMU0: J23.38 R321.1
MIPI_EMU1: J23.40 R314.1
MIPI_NTRSTPU: J23.9 R360.2 R371.2
MIPI_RTCK: J23.7 R372.2
MIPI_TCK: J23.3 R372.1 R375.2
MIPI_TDI: J23.5 R374.2
MIPI_TDO: J23.4 R383.1
MIPI_TGTDET#: J23.15 R354.1
MIPI_TGTRST#: J23.6 R376.2
MIPI_TMS: J23.2 R389.1
MIPI_TRC_CLK[0]: J23.13 R355.2
MIPI_TRC_DATA_00: J23.17 R348.2
MIPI_TRC_DATA_01: J23.19 R347.2
MIPI_TRC_DATA_02: J23.21 R341.2
MIPI_TRC_DATA_03: J23.23 R340.2
MIPI_TRC_DATA_04: J23.25 R330.2
MIPI_TRC_DATA_05: J23.27 R329.2
MIPI_TRC_DATA_06: J23.29 R326.2
MIPI_TRC_DATA_07: J23.31 R325.2
MIPI_TRC_DATA_08: J23.33 R320.2
MIPI_TRC_DATA_09: J23.35 R319.2
MIPI_TRC_DATA_10: J23.18 R350.1
MIPI_TRC_DATA_11: J23.20 R343.1
MIPI_TRC_DATA_30: J23.37 R313.2
MIPI_TRC_DATA_31: J23.39 R312.2
MIPI_TRC_DATA_32: J23.41 R306.2
MIPI_TRC_DATA_33: J23.43 R305.2
MIPI_TRC_DATA_34: J23.45 R301.2
MIPI_TRC_DATA_35: J23.47 R300.2
MIPI_TRC_DATA_36: J23.49 R296.2
MIPI_TRC_DATA_37: J23.51 R295.2
MIPI_TRC_DATA_38: J23.53 R286.2
MIPI_TRC_DATA_39: J23.55 R285.2
MIPI_TRST_PD: J23.8 R361.1 R373.2
MIPI_VREF_DEBUG: J23.1 R380.2 R387.2
MIPI_VREF_TRACE: J23.12 R356.2
MMC0_CALPAD: R948.1 U59.AH2(MMC0_CALPAD)
MMC0_CLK: TP101.1(TP) U52.M6(CLK) U59.AJ2(MMC0_CLK)
MMC0_CMD: R961.2 TP291.1(TP) U52.M5(CMD) U59.AL2(MMC0_CMD)
MMC0_DAT0: R307.2 TP94.1(TP) U52.A3(DAT0) U59.AM1(MMC0_DAT0)
MMC0_DAT1: R293.2 TP83.1(TP) U52.A4(DAT1) U59.AK3(MMC0_DAT1)
MMC0_DAT2: R278.2 TP79.1(TP) U52.A5(DAT2) U59.AL1(MMC0_DAT2)
MMC0_DAT3: R322.2 TP100.1(TP) U52.B2(DAT3) U59.AK1(MMC0_DAT3)
MMC0_DAT4: R317.2 TP97.1(TP) U52.B3(DAT4) U59.AJ3(MMC0_DAT4)
MMC0_DAT5: R299.2 TP87.1(TP) U52.B4(DAT5) U59.AH3(MMC0_DAT5)
MMC0_DAT6: R284.2 TP80.1(TP) U52.B5(DAT6) U59.AJ4(MMC0_DAT6)
MMC0_DAT7: R274.2 TP76.1(TP) U52.B6(DAT7) U59.AK2(MMC0_DAT7)
MMC0_DS: R967.1 R976.2 U59.AJ1(MMC0_DS)
MMC0_DS_R: R967.2 TP292.1(TP) U52.H5(DS)
MMC1_CLK: J53.5(CLK) R368.2 TP57.1(TP) U200.5(IO2)
MMC1_CLK_R: R368.1 TP116.1(TP) U59.D33(MMC1_CLK)
MMC1_CMD: J53.3(CMD) R934.2 TP60.1(TP) U59.E32(MMC1_CMD) U200.3(IO1)
MMC1_DAT0: J53.7(DAT0) R922.2 TP53.1(TP) U59.F28(MMC1_DAT0) U197.3(IO1)
MMC1_DAT1: J53.8(DAT1) R916.2 TP44.1(TP) U59.F29(MMC1_DAT1) U197.5(IO2)
MMC1_DAT2: J53.1(DAT2) R937.2 TP66.1(TP) U59.E30(MMC1_DAT2) U202.3(IO1)
MMC1_DAT3: J53.2(CD/DAT3) R936.2 TP64.1(TP) U59.F30(MMC1_DAT3) U202.5(IO2)
MMCO_VCTRL_TP: TP73.1(TP) U59.AH4(MMC0_VCTRL_TP)
MON1_ER_VSYS: C1019.1 R1100.1 R1105.2 U59.G26(VMON1_ER_VSYS)
MON3_IR_VEXT1V8: C1027.1 R1097.2 U59.K30(VMON3_IR_VEXT1P8)
MON4_IR_VEXT1V8: C970.1 R1050.2 U59.M26(VMON4_IR_VEXT1P8)
MON5_IR_VEXT1V8: C965.1 R1046.2 U59.M29(VMON5_IR_VEXT3P3)
MUX_USB0_DATA_N: R56.1 U12.7(D-)
MUX_USB0_DATA_P: R57.1 U12.8(D+)
ONAND_RST#: U86.4(Y) U245.A4(R\E\S\E\T\)
OSC0: C554.2 U170.88(OSC0) Y9.1
OSC0_REFCLK: R134.2 R399.2
OSC1: C553.2 U170.89(OSC1) Y9.3
OSC1_XI: R395.1 R399.1 U59.B23(OSC1_XI)
OSC1_XO: R402.1 U59.A22(OSC1_XO)
OSPI0_INT#/ECC_FAIL: R541.1 U59.E11(MCU_OSPI0_CSN3) U246.A5(INT#)
