# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CS2_LM5140: length 4.4
  TOP w0.127: U46.4 215.31,100.68 214.81,100.18 C234.1 214.81,99.17 215.58,98.4 R288.2
CS2_LM5143: length 3.8
  TOP w0.127: U25.4 204.47,154.33 205.07,154.92 C94.1 205.07,156.24 205.18,156.35 R111.2
CS_LM5141: length 30.9
  TOP w0.254: v2(204.6,60.79) 205.01,60.79 205.51,60.29 U81.18
  L12-SIGNAL5 w0.203: v2(204.6,60.79) 205.42,59.98 208.29,59.98 211.57,63.25 218.56,63.25 219.45,64.14 230.51,64.14 230.72,63.94 v2(230.72,63.07)
CSI0_RX0_N: length 257
  L3-SIGNAL1 w0.084: v3(108.72,92.63) v5(108.44,92.86)
  L4-GND2 w0.084: v5(108.44,92.86) v6(108.74,93.12)
  L5-SIGNAL2 w0.102: v2(211.03,26.92) 211.14,26.82 arc(211.19,26.74) 211.21,26.65 211.21,26.48 arc(211.2,26.45) 211.18,26.41 211.12,26.35 arc(211.05,26.31) 210.97,26.29 209.39,26.29 arc(209.03,26.22) 208.73,26.02 207.2,24.49 arc(206.86,24.26) 206.47,24.18 206,24.18 arc(205.37,24.06) 204.84,23.7 204.63,23.49 arc(204.38,23.33) 204.09,23.27 196.01,23.27 arc(195.28,23.57) 194.98,24.3 194.98,47.23 arc(195.1,47.87) 195.47,48.41 199.28,52.22 arc(199.6,52.71) 199.72,53.28 199.72,60.7 arc(199.8,61.11) 200.03,61.45 arc(200.32,61.83) 200.5,62.26 arc(200.54,62.49) 200.56,62.73 200.56,65.48 arc(200.62,65.8) 200.8,66.07 201.43,66.7 arc(201.63,67) 201.7,67.36 201.7,73.06 arc(201.51,73.52) 201.05,73.71 200.68,73.71 arc(200.31,74.08) 200.68,74.44 201.11,74.44 arc(201.83,75.17) 201.11,75.89 200.68,75.89 arc(200.31,76.26) 200.68,76.63 201.11,76.63 arc(201.83,77.35) 201.11,78.08 200.68,78.08 arc(200.31,78.44) 200.68,78.81 201.11,78.81 arc(201.83,79.54) 201.11,80.26 200.68,80.26 arc(200.31,80.63) 200.68,81 200.98,81 arc(201.49,81.21) 201.7,81.72 201.7,83.57 arc(201.52,84.47) 201.01,85.24 199.15,87.09 arc(198.95,87.4) 198.88,87.75 198.88,94.17 arc(199.03,94.93) 199.46,95.58 200.75,96.86 arc(201.33,97.73) 201.54,98.76 201.54,117.87 arc(200.9,121.1) 199.07,123.84 195.84,127.06 arc(193.56,128.59) 190.87,129.12 164.17,129.12 arc(161.53,128.6) 159.29,127.1 154.95,122.76 arc(153.41,121.73) 151.59,121.37 113.06,121.37 arc(112.43,121.24) 111.89,120.88 111.29,120.29 arc(110.89,119.68) 110.74,118.96 110.74,108.44 arc(110.7,108.21) 110.57,108.02 109.86,107.31 arc(109.71,107.09) 109.66,106.83 109.66,103.62 arc(109.61,103.39) 109.48,103.2 109.14,102.85 arc(108.96,102.59) 108.9,102.27 108.9,98.15 arc(108.88,98.07) 108.84,98 108.6,97.76 arc(108.44,97.53) 108.39,97.27 108.39,94.63 arc(108.5,94.1) 108.8,93.65 108.93,93.51 arc(108.96,93.48) 108.96,93.44 108.96,93.38 arc(108.96,93.34) 108.93,93.31 v6(108.74,93.12)
  BOTTOM w0.127: J57.11 211.18,30.77 211.18,27.29 arc(211.14,27.09) v2(211.03,26.92)
  vias: v1(108.71,92.63)
CSI0_RX0_P: length 257
  L3-SIGNAL1 w0.084: v3(109.52,92.63) v5(109.24,92.86)
  L4-GND2 w0.084: v5(109.24,92.86) v6(109.54,93.12)
  L5-SIGNAL2 w0.102: v6(109.54,93.12) 109.35,93.31 arc(109.33,93.34) 109.32,93.38 109.32,93.44 arc(109.28,93.61) 109.18,93.76 109.05,93.9 arc(108.82,94.23) 108.75,94.63 108.75,97.27 arc(108.77,97.4) 108.85,97.51 109.09,97.75 arc(109.21,97.94) 109.25,98.15 109.25,102.27 arc(109.29,102.45) 109.39,102.6 109.73,102.94 arc(109.94,103.26) 110.02,103.62 110.02,106.83 arc(110.04,106.95) 110.11,107.06 110.82,107.77 arc(111.03,108.08) 111.1,108.44 111.1,118.96 arc(111.21,119.54) 111.54,120.04 112.14,120.63 arc(112.56,120.91) 113.06,121.01 151.59,121.01 arc(153.55,121.4) 155.2,122.51 159.54,126.85 arc(161.66,128.27) 164.17,128.76 190.87,128.76 arc(193.42,128.26) 195.59,126.81 198.82,123.58 arc(200.57,120.96) 201.18,117.87 201.18,98.76 arc(201,97.87) 200.5,97.11 199.21,95.83 arc(198.7,95.07) 198.52,94.17 198.52,87.75 arc(198.62,87.26) 198.9,86.84 200.76,84.99 arc(201.19,84.34) 201.35,83.57 201.35,81.72 arc(201.24,81.46) 200.98,81.35 200.68,81.35 arc(199.96,80.63) 200.68,79.91 201.11,79.91 arc(201.47,79.54) 201.11,79.17 200.68,79.17 arc(199.96,78.44) 200.68,77.72 201.11,77.72 arc(201.47,77.35) 201.11,76.98 200.68,76.98 arc(199.96,76.26) 200.68,75.54 201.11,75.54 arc(201.47,75.17) 201.11,74.8 200.68,74.8 arc(199.96,74.08) 200.68,73.35 201.05,73.35 arc(201.26,73.27) 201.35,73.06 201.35,67.36 arc(201.3,67.14) 201.18,66.95 200.55,66.32 arc(200.29,65.94) 200.2,65.48 200.2,62.73 arc(200.19,62.54) 200.15,62.36 200.15,62.35 arc(200.01,62) 199.78,61.7 arc(199.47,61.24) 199.36,60.7 199.36,53.28 arc(199.28,52.84) 199.03,52.48 195.21,48.66 arc(194.77,48) 194.62,47.23 194.62,24.3 arc(195.03,23.32) 196.01,22.91 204.09,22.91 arc(204.52,23) 204.89,23.24 205.1,23.45 arc(205.51,23.73) 206,23.83 206.47,23.83 arc(207,23.93) 207.45,24.23 208.98,25.76 arc(209.17,25.89) 209.39,25.93 210.97,25.93 arc(211.19,25.98) 211.37,26.1 211.43,26.16 arc(211.53,26.31) 211.56,26.48 211.56,26.65 arc(211.58,26.74) 211.64,26.82 v2(211.74,26.92)
  BOTTOM w0.127: J57.9 211.7,30.77 211.7,27.02 arc(211.71,26.97) v2(211.74,26.92)
  vias: v1(109.51,92.63)
CSI0_RX1_N: length 257.1
  L3-SIGNAL1 w0.084: v3(109.52,93.43) v5(109.24,93.66)
  L4-GND2 w0.084: v5(109.24,93.66) v6(109.54,93.92)
  L5-SIGNAL2 w0.102: v2(209.56,25.22) 209.66,25.12 arc(209.72,25.04) 209.74,24.94 209.74,24.88 arc(209.72,24.82) 209.69,24.77 208.38,23.46 arc(208.11,23.28) 207.79,23.22 206.57,23.22 arc(205.68,22.85) 205.32,21.96 205.32,21.39 arc(205.18,21.05) 204.83,20.9 194.05,20.9 arc(192.77,21.44) 192.24,22.72 192.24,24.95 arc(192.3,25.25) 192.46,25.51 192.79,25.83 arc(192.96,26.09) 193.02,26.39 193.02,28.83 arc(192.81,29.34) 192.3,29.55 190.75,29.55 arc(190.38,29.92) 190.75,30.29 192.3,30.29 arc(193.02,31.02) 192.3,31.74 190.75,31.74 arc(190.38,32.11) 190.75,32.48 192.3,32.48 arc(192.81,32.69) 193.02,33.2 193.02,34.29 arc(193.05,34.41) 193.12,34.52 193.45,34.85 arc(193.61,35.09) 193.66,35.36 193.66,47.49 arc(193.91,48.72) 194.6,49.75 197.45,52.6 arc(197.76,53.07) 197.87,53.63 197.87,64.82 arc(198.01,65.48) 198.38,66.04 198.97,66.62 arc(199.25,67.05) 199.35,67.54 199.35,71.32 arc(199.12,72.47) 198.47,73.45 198.41,73.51 arc(197.65,74.64) 197.38,75.99 197.38,95.34 arc(197.61,96.47) 198.25,97.43 199.32,98.5 arc(199.82,99.24) 199.99,100.12 199.99,118.96 arc(199.61,120.87) 198.53,122.48 194.5,126.52 arc(193.86,126.94) 193.11,127.09 164.01,127.09 arc(162.04,126.7) 160.36,125.58 155.97,121.19 arc(154.79,120.4) 153.4,120.12 115,120.12 arc(112.98,119.29) 112.15,117.27 112.15,103.3 arc(112.1,103.04) 111.95,102.82 111.78,102.65 arc(111.64,102.44) 111.59,102.19 111.59,99.33 arc(111.54,99.05) 111.38,98.82 110.05,97.49 arc(109.67,96.92) 109.53,96.25 109.53,94.78 arc(109.57,94.61) 109.67,94.46 109.67,94.46 arc(109.74,94.36) 109.76,94.23 109.76,94.14 arc(109.7,93.98) v6(109.54,93.92)
  BOTTOM w0.127: J57.15 209.68,30.77 209.68,25.53 arc(209.65,25.36) v2(209.56,25.22)
  vias: v1(109.51,93.43)
CSI0_RX1_P: length 257.1
  L3-SIGNAL1 w0.084: v3(110.32,93.43) v5(110.04,93.66)
  L4-GND2 w0.084: v5(110.04,93.66) v6(110.34,93.92)
  L5-SIGNAL2 w0.102: v2(210.27,25.22) 210.17,25.13 arc(210.11,25.04) 210.09,24.93 210.09,24.88 arc(210.05,24.68) 209.94,24.52 208.63,23.21 arc(208.25,22.95) 207.79,22.86 206.57,22.86 arc(205.93,22.6) 205.67,21.96 205.67,21.39 arc(205.43,20.79) 204.83,20.55 194.05,20.55 arc(192.52,21.19) 191.88,22.72 191.88,24.95 arc(191.97,25.39) 192.21,25.76 192.54,26.09 arc(192.63,26.23) 192.67,26.39 192.67,28.83 arc(192.56,29.09) 192.3,29.2 190.75,29.2 arc(190.03,29.92) 190.75,30.65 192.3,30.65 arc(192.67,31.02) 192.3,31.38 190.75,31.38 arc(190.03,32.11) 190.75,32.83 192.3,32.83 arc(192.56,32.94) 192.67,33.2 192.67,34.29 arc(192.72,34.55) 192.86,34.77 193.2,35.1 arc(193.28,35.22) 193.31,35.36 193.31,47.49 arc(193.58,48.85) 194.35,50.01 197.2,52.85 arc(197.44,53.21) 197.52,53.63 197.52,64.82 arc(197.68,65.61) 198.13,66.29 198.72,66.88 arc(198.92,67.18) 198.99,67.54 198.99,71.32 arc(198.79,72.34) 198.22,73.2 198.16,73.26 arc(197.32,74.51) 197.03,75.99 197.03,95.34 arc(197.28,96.6) 198,97.68 199.07,98.75 arc(199.49,99.38) 199.64,100.12 199.64,118.96 arc(199.29,120.73) 198.28,122.23 194.25,126.26 arc(193.73,126.61) 193.11,126.74 164.01,126.74 arc(162.17,126.37) 160.62,125.33 156.22,120.94 arc(154.93,120.07) 153.4,119.77 115,119.77 arc(113.24,119.04) 112.5,117.27 112.5,103.3 arc(112.43,102.9) 112.2,102.57 112.03,102.4 arc(111.97,102.3) 111.95,102.19 111.95,99.33 arc(111.86,98.92) 111.63,98.57 110.3,97.23 arc(110,96.78) 109.89,96.25 109.89,94.78 arc(109.9,94.75) 109.92,94.71 109.92,94.71 arc(110.07,94.49) 110.12,94.23 110.12,94.14 arc(110.18,93.98) v6(110.34,93.92)
  BOTTOM w0.127: J57.13 210.2,30.77 210.2,25.38 arc(210.22,25.29) v2(210.27,25.22)
  vias: v1(110.31,93.43)
CSI0_RX2_N: length 257
  L3-SIGNAL1 w0.084: v3(110.32,94.23) v5(110.04,94.46)
  L4-GND2 w0.084: v5(110.04,94.46) v6(110.34,94.72)
  L5-SIGNAL2 w0.102: v6(110.34,94.72) 110.38,94.76 arc(110.48,94.9) 110.51,95.07 110.51,95.34 arc(110.58,95.66) 110.76,95.94 113.07,98.25 arc(113.27,98.55) 113.34,98.9 113.34,116.86 arc(113.91,118.23) 115.27,118.79 155.09,118.79 arc(155.87,118.95) 156.53,119.39 161.07,123.92 arc(162.38,124.8) 163.92,125.11 167.3,125.11 arc(167.66,125.18) 167.97,125.38 168.12,125.53 arc(168.4,125.72) 168.73,125.79 192.2,125.79 arc(193.28,125.57) 194.19,124.96 197.47,121.69 arc(198.09,120.75) 198.31,119.65 198.31,102.86 arc(198.09,101.77) 197.48,100.85 196.61,99.98 arc(196,99.07) 195.79,98.01 195.79,85.99 arc(195.62,85.15) 195.15,84.43 194.6,83.89 arc(194.28,83.4) 194.17,82.83 194.17,73.19 arc(194.36,72.24) 194.89,71.43 195.39,70.94 arc(196.06,69.94) 196.29,68.75 196.29,62.09 arc(196.19,61.57) 195.89,61.12 195.74,60.97 arc(195.57,60.72) 195.51,60.42 195.51,54.72 arc(195.38,54.05) 195,53.49 193.74,52.22 arc(193.38,51.69) 193.25,51.05 193.25,50.46 arc(193.15,49.94) 192.85,49.5 192.68,49.32 arc(192.44,48.97) 192.36,48.56 192.36,45.93 arc(192.12,45.34) 191.53,45.1 188.76,45.1 arc(188.39,44.73) 188.76,44.36 191.64,44.36 arc(192.15,44.15) 192.36,43.64 192.36,37.11 arc(192.2,36.29) 191.74,35.6 191.22,35.09 189.09,32.95 arc(188.77,32.47) 188.65,31.9 188.65,23.78 arc(188.86,22.74) 189.45,21.85 191.56,19.74 arc(192.64,19.02) 193.91,18.77 197.78,18.77 arc(198.14,18.7) 198.46,18.49 198.91,18.04 arc(199.11,17.9) 199.35,17.86 205.53,17.86 arc(206.37,18.21) 206.72,19.05 206.72,21.52 arc(206.67,21.75) v2(206.54,21.95)
  BOTTOM w0.127: J57.19 208.18,30.77 208.18,26.08 arc(208.07,25.52) 207.75,25.04 207.23,24.52 arc(206.79,23.86) 206.64,23.1 206.64,22.18 arc(206.61,22.05) v2(206.54,21.95)
  vias: v1(110.31,94.23)
CSI0_RX2_P: length 257
  L3-SIGNAL1 w0.084: v3(111.12,94.23) v5(110.84,94.46)
  L4-GND2 w0.084: v5(110.84,94.46) v6(111.14,94.72)
  L5-SIGNAL2 w0.102: v6(111.14,94.72) 110.95,94.91 arc(110.89,95) 110.87,95.11 110.87,95.34 arc(110.91,95.53) 111.01,95.69 113.32,98 arc(113.6,98.42) 113.7,98.9 113.7,116.86 arc(114.16,117.97) 115.27,118.43 155.09,118.43 arc(156.01,118.62) 156.78,119.13 161.32,123.67 arc(162.51,124.47) 163.92,124.75 167.3,124.75 arc(167.8,124.85) 168.22,125.13 168.37,125.28 arc(168.54,125.39) 168.73,125.43 192.2,125.43 arc(193.14,125.25) 193.94,124.71 197.21,121.44 arc(197.76,120.62) 197.96,119.65 197.96,102.86 arc(197.77,101.91) 197.23,101.1 196.35,100.23 arc(195.67,99.21) 195.44,98.01 195.44,85.99 arc(195.3,85.28) 194.9,84.68 194.35,84.14 arc(193.95,83.54) 193.81,82.83 193.81,73.19 arc(194.03,72.1) 194.64,71.18 195.14,70.69 arc(195.73,69.8) 195.94,68.75 195.94,62.09 arc(195.86,61.7) 195.64,61.37 195.49,61.22 arc(195.24,60.86) 195.16,60.42 195.16,54.72 arc(195.05,54.19) 194.75,53.74 193.48,52.47 arc(193.05,51.82) 192.9,51.05 192.9,50.46 arc(192.82,50.07) 192.6,49.75 192.43,49.57 arc(192.12,49.11) 192.01,48.56 192.01,45.93 arc(191.87,45.59) 191.53,45.45 188.76,45.45 arc(188.03,44.73) 188.76,44 191.64,44 arc(191.9,43.9) 192.01,43.64 192.01,37.11 arc(191.87,36.43) 191.48,35.85 188.84,33.2 arc(188.44,32.61) 188.3,31.9 188.3,23.78 arc(188.53,22.6) 189.2,21.6 191.31,19.49 arc(192.5,18.7) 193.91,18.42 197.78,18.42 arc(198.01,18.37) 198.2,18.24 198.65,17.79 arc(198.97,17.58) 199.35,17.5 205.53,17.5 arc(206.62,17.95) 207.08,19.05 207.08,21.52 arc(207.12,21.75) v2(207.25,21.95)
  BOTTOM w0.127: J57.17 208.7,30.77 208.7,26.08 arc(208.55,25.32) 208.12,24.68 207.6,24.15 arc(207.27,23.67) 207.16,23.1 207.16,22.18 arc(207.18,22.05) v2(207.25,21.95)
  vias: v1(111.11,94.23)
CSI0_RX3_N: length 256.9
  L3-SIGNAL1 w0.084: v3(107.92,91.83) v5(107.64,92.06)
  L4-GND2 w0.084: v5(107.64,92.06) v6(107.94,92.32)
  L5-SIGNAL2 w0.102: v6(107.94,92.32) 108.02,92.39 arc(108.09,92.51) 108.12,92.64 108.12,92.69 arc(108.12,92.7) 108.12,92.7 arc(108.11,92.74) 108.1,92.78 arc(108.08,92.81) 108.06,92.84 107.63,93.27 arc(107.38,93.63) 107.3,94.06 107.3,99.06 arc(107.13,99.47) 106.72,99.63 105.94,99.63 arc(105.22,100.36) 105.94,101.08 106.83,101.08 arc(107.09,101.19) 107.2,101.45 107.2,102.8 arc(107.28,103.24) 107.53,103.61 108.14,104.22 arc(108.34,104.52) 108.41,104.87 108.41,113.54 arc(108.33,113.94) 108.1,114.28 arc(107.89,114.6) 107.81,114.98 107.81,118.14 arc(108.15,119.83) 109.1,121.26 arc(110.63,122.28) 112.43,122.64 150.28,122.64 arc(152.53,123.09) 154.45,124.36 158.51,128.43 arc(160.69,129.88) 163.26,130.4 191.44,130.4 arc(194.17,129.85) 196.48,128.31 199.85,124.94 arc(202.02,121.69) 202.78,117.86 202.78,97.48 arc(202.7,97.08) 202.47,96.73 arc(202.27,96.42) 202.19,96.06 202.19,86.44 arc(202.22,86.3) 202.3,86.18 202.75,85.73 arc(202.99,85.37) 203.07,84.95 203.07,83.53 arc(203.18,83.27) 203.44,83.16 203.73,83.16 arc(204.24,82.95) 204.45,82.44 204.45,82.4 arc(204.25,81.91) 203.76,81.71 203.44,81.71 arc(203.07,81.34) 203.44,80.98 203.73,80.98 arc(204.24,80.76) 204.45,80.25 204.45,80.22 arc(204.25,79.73) 203.76,79.53 203.44,79.53 arc(203.18,79.42) 203.07,79.16 203.07,63.41 arc(203,63.06) 202.8,62.76 201.98,61.94 arc(201.78,61.64) 201.71,61.29 201.71,58.09 arc(201.71,58.02) 201.7,57.95 arc(201.58,57.52) 201.33,57.16 arc(201.07,56.77) 200.97,56.31 200.97,51.67 arc(200.81,50.83) 200.33,50.12 197.72,47.51 arc(197.42,47.06) 197.32,46.53 197.32,39.66 arc(197.37,39.42) 197.51,39.21 198.86,37.86 arc(199.03,37.74) 199.25,37.69 199.96,37.69 arc(200.51,37.46) 200.74,36.91 200.74,36.23 arc(200.66,35.8) 200.41,35.43 199.13,34.15 arc(198.62,33.94) 198.11,34.15 197.98,34.28 arc(197.72,34.4) 197.46,34.31 arc(197.44,34.29) 197.43,34.28 arc(197.33,34.03) 197.43,33.79 197.59,33.63 arc(197.8,33.12) 197.59,32.61 197.32,32.34 arc(196.79,31.55) 196.6,30.61 196.6,26.34 arc(196.96,25.48) 197.82,25.12 206.26,25.12 arc(206.6,25.26) 206.74,25.6 206.74,25.89 arc(206.69,26.12) v2(206.56,26.31)
  BOTTOM w0.127: J57.23 206.68,30.77 206.68,26.61 arc(206.65,26.45) v2(206.56,26.31)
  vias: v1(107.91,91.83)
CSI0_RX3_P: length 257
  L3-SIGNAL1 w0.084: v3(108.72,91.83) v5(108.44,92.06)
  L4-GND2 w0.084: v5(108.44,92.06) v6(108.74,92.32)
  L5-SIGNAL2 w0.102: v6(108.74,92.32) 108.6,92.46 arc(108.51,92.58) 108.48,92.73 108.47,92.73 arc(108.43,92.92) 108.31,93.09 107.88,93.52 arc(107.71,93.77) 107.65,94.06 107.65,99.06 arc(107.38,99.72) 106.72,99.99 105.94,99.99 arc(105.57,100.36) 105.94,100.73 106.83,100.73 arc(107.34,100.94) 107.55,101.45 107.55,102.8 arc(107.61,103.1) 107.79,103.36 108.4,103.97 arc(108.67,104.38) 108.76,104.87 108.76,113.54 arc(108.66,114.08) 108.35,114.53 arc(108.22,114.74) 108.17,114.98 108.17,118.14 arc(108.48,119.69) 109.36,121.01 arc(110.77,121.95) 112.43,122.28 150.28,122.28 arc(152.67,122.76) 154.7,124.11 158.76,128.18 arc(160.83,129.56) 163.26,130.04 191.44,130.04 arc(194.03,129.53) 196.23,128.06 199.6,124.69 arc(201.69,121.55) 202.43,117.86 202.43,97.48 arc(202.37,97.21) 202.22,96.98 arc(201.94,96.56) 201.84,96.06 201.84,86.44 arc(201.89,86.16) 202.05,85.92 202.5,85.47 arc(202.66,85.24) 202.71,84.95 202.71,83.53 arc(202.93,83.02) 203.44,82.8 203.73,82.8 arc(203.99,82.7) 204.1,82.44 204.1,82.4 arc(204,82.17) 203.76,82.07 203.44,82.07 arc(202.71,81.34) 203.44,80.62 203.73,80.62 arc(203.99,80.51) 204.1,80.25 204.1,80.22 arc(204,79.98) 203.76,79.88 203.44,79.88 arc(202.93,79.67) 202.71,79.16 202.71,63.41 arc(202.67,63.2) 202.55,63.02 201.73,62.19 arc(201.45,61.78) 201.35,61.29 201.35,58.09 arc(201.35,58.04) 201.35,57.99 arc(201.26,57.68) 201.07,57.41 arc(200.74,56.9) 200.62,56.31 200.62,51.67 arc(200.48,50.97) 200.08,50.37 197.47,47.76 arc(197.09,47.2) 196.96,46.53 196.96,39.66 arc(197.04,39.28) 197.25,38.95 198.6,37.6 arc(198.9,37.41) 199.25,37.34 199.96,37.34 arc(200.26,37.21) 200.39,36.91 200.39,36.23 arc(200.33,35.94) 200.16,35.68 198.88,34.4 arc(198.62,34.29) 198.36,34.4 198.23,34.53 arc(197.74,34.75) 197.23,34.58 197.22,34.57 197.18,34.53 arc(196.97,34.03) 197.18,33.54 197.34,33.38 arc(197.44,33.12) 197.34,32.86 197.07,32.59 arc(196.46,31.68) 196.25,30.61 196.25,26.34 arc(196.71,25.23) 197.82,24.77 206.26,24.77 arc(206.85,25.01) 207.09,25.6 207.09,25.89 arc(207.14,26.12) v2(207.27,26.31)
  BOTTOM w0.127: J57.21 207.2,30.77 207.2,26.48 arc(207.22,26.39) v2(207.27,26.31)
  vias: v1(108.71,91.83)
CSI0_RX_CALIB: length 17.9
  L3-SIGNAL1 w0.089: v3(109.52,90.23) v5(109.24,90.46)
  L4-GND2 w0.102: v5(109.24,90.46) v7(108.93,90.16)
  L13-GND5 w0.102: v7(108.93,90.16) 108.72,89.94 v9(108.64,89.87)
  L14-SIGNAL6 w0.089: v9(108.64,89.87) 102.98,89.87 102.07,88.95 96.05,88.95 95.08,87.99 v11(93.94,87.99)
  BOTTOM w0.127: R984.1 93.73,87.99 v11(93.94,87.99)
  vias: v1(109.51,90.23)
CSI0_RXCLK_N: length 257.1
  L3-SIGNAL1 w0.084: v3(107.92,90.23) v5(107.64,90.46)
  L4-GND2 w0.084: v5(107.64,90.46) v6(107.89,90.72)
  L5-SIGNAL2 w0.102: v2(212.56,28.58) 212.63,28.51 arc(212.71,28.39) 212.73,28.25 212.73,28.14 arc(212.68,28.02) 212.56,27.97 209.05,27.97 arc(208.59,27.87) 208.19,27.61 arc(207.86,27.39) 207.48,27.31 206.36,27.31 arc(205.83,27.21) 205.39,26.91 204.99,26.51 arc(204.71,26.33) 204.38,26.26 199.25,26.26 arc(198.46,26.59) 198.13,27.39 198.13,30.39 arc(198.3,31.27) 198.8,32.02 201.49,34.71 arc(201.84,35.23) 201.96,35.84 201.96,40.35 arc(202.07,40.88) 202.37,41.33 204.57,43.53 arc(205.1,44.32) 205.29,45.26 205.29,51.45 arc(205.19,51.98) 204.89,52.43 203.68,53.63 arc(203.35,54.13) 203.23,54.71 203.23,59.57 arc(203.34,60.1) 203.64,60.55 204.76,61.68 arc(205.44,62.68) 205.67,63.87 205.67,83.2 arc(205.37,84.74) 204.5,86.04 203.88,86.65 arc(203.76,86.84) 203.72,87.06 203.72,92.23 arc(203.78,92.57) 203.98,92.86 204.02,92.91 arc(204.42,93.5) 204.56,94.2 204.56,96.37 arc(204.46,96.87) 204.18,97.29 arc(204.09,97.42) 204.05,97.59 204.05,117.88 arc(203.19,122.24) 200.72,125.94 197.56,129.09 arc(194.76,130.97) 191.46,131.62 162.88,131.62 arc(160.18,131.08) 157.88,129.55 153.86,125.53 arc(152.06,124.33) 149.94,123.91 112.62,123.91 arc(110.18,123.42) 108.11,122.04 107.98,121.91 arc(106.77,120.1) 106.35,117.97 106.35,108.93 arc(106.41,108.62) 106.58,108.36 106.75,108.19 arc(106.91,107.95) 106.97,107.67 106.97,105.32 arc(106.9,104.96) 106.69,104.65 104.25,102.21 arc(104.06,101.93) 104,101.59 104,95.72 arc(104.1,95.22) 104.38,94.8 106.72,92.46 arc(106.94,92.12) 107.02,91.73 107.02,91.36 arc(107.06,91.13) 107.19,90.94 107.27,90.86 arc(107.28,90.86) 107.29,90.85 107.48,90.66 arc(107.53,90.57) 107.55,90.48 arc(107.58,90.41) 107.65,90.38 107.74,90.38 arc(107.85,90.42) 107.89,90.52 v6(107.89,90.72)
  BOTTOM w0.127: J57.7 212.68,30.77 212.68,28.89 arc(212.65,28.72) v2(212.56,28.58)
  vias: v1(107.91,90.23)
CSI0_RXCLK_P: length 257.1
  L3-SIGNAL1 w0.084: v3(108.72,90.23) v5(108.44,90.46)
  L4-GND2 w0.084: v5(108.44,90.46) v6(108.69,90.72)
  L5-SIGNAL2 w0.102: v2(213.27,28.58) 213.12,28.43 arc(213.1,28.39) 213.09,28.36 213.09,28.14 arc(212.93,27.77) 212.56,27.61 209.05,27.61 arc(208.72,27.54) 208.44,27.36 arc(208,27.06) 207.48,26.96 206.36,26.96 arc(205.97,26.88) 205.64,26.66 205.24,26.26 arc(204.85,26) 204.38,25.91 199.25,25.91 arc(198.21,26.34) 197.77,27.39 197.77,30.39 arc(197.97,31.41) 198.55,32.27 201.24,34.96 arc(201.51,35.37) 201.61,35.84 201.61,40.35 arc(201.74,41.01) 202.12,41.58 204.32,43.78 arc(204.78,44.46) 204.94,45.26 204.94,51.45 arc(204.86,51.84) 204.63,52.17 203.43,53.38 arc(203.02,53.99) 202.88,54.71 202.88,59.57 arc(203.01,60.24) 203.39,60.81 204.51,61.93 arc(205.11,62.82) 205.32,63.87 205.32,83.2 arc(205.04,84.6) 204.25,85.79 203.63,86.4 arc(203.43,86.7) 203.36,87.06 203.36,92.23 arc(203.46,92.71) 203.73,93.11 203.77,93.16 arc(204.09,93.63) 204.2,94.2 204.2,96.37 arc(204.13,96.73) 203.93,97.04 arc(203.76,97.29) 203.7,97.59 203.7,117.88 arc(202.86,122.1) 200.46,125.69 197.31,128.84 arc(194.62,130.64) 191.46,131.27 162.88,131.27 arc(160.31,130.76) 158.13,129.3 154.11,125.28 arc(152.2,124) 149.94,123.55 112.62,123.55 arc(110.32,123.09) 108.36,121.79 108.23,121.66 arc(107.1,119.97) 106.7,117.97 106.7,108.93 arc(106.74,108.76) 106.84,108.61 107,108.44 arc(107.24,108.09) 107.32,107.67 107.32,105.32 arc(107.22,104.82) 106.94,104.4 104.5,101.96 arc(104.39,101.79) 104.35,101.59 104.35,95.72 arc(104.42,95.36) 104.63,95.05 106.97,92.71 arc(107.27,92.26) 107.37,91.73 107.37,91.36 arc(107.39,91.27) 107.44,91.19 107.52,91.11 arc(107.56,91.09) 107.59,91.08 108.44,91.08 arc(108.62,91.01) 108.69,90.84 v6(108.69,90.72)
  BOTTOM w0.127: J57.5 213.2,30.77 213.2,28.73 arc(213.22,28.64) v2(213.27,28.58)
  vias: v1(108.71,90.23)
CSI1_RX0_N: length 301.1
  L3-SIGNAL1 w0.084: v3(110.32,88.63) v5(110.04,88.86)
  L4-GND2 w0.084: v5(110.04,88.86) v6(109.73,89.17)
  L5-SIGNAL2 w0.102: v2(203.59,28.63) 203.72,28.63 arc(203.86,28.69) 203.91,28.82 203.91,30.2 arc(204.2,30.9) 204.9,31.19 207.69,31.19 arc(208.71,31.39) 209.58,31.98 211.25,33.64 arc(211.67,34.27) 211.82,35.01 211.82,39.66 arc(212.02,40.66) 212.58,41.51 arc(212.82,41.87) 212.91,42.29 212.91,43.34 arc(213.34,45.53) 214.58,47.39 216.55,49.36 arc(216.66,49.62) 216.55,49.88 215.18,51.25 arc(214.96,51.77) 215.18,52.28 215.18,52.28 arc(215.69,52.49) 216.2,52.28 217.29,51.18 arc(217.81,51.18) 217.81,51.7 216.72,52.8 arc(216.51,53.31) 216.72,53.82 arc(217.23,54.03) 217.74,53.82 219.12,52.45 arc(219.38,52.34) 219.64,52.45 220.39,53.2 arc(220.8,53.8) 220.94,54.52 220.94,77.67 arc(220.87,78.03) 220.66,78.33 219.97,79.02 arc(219.94,79.06) 219.91,79.1 arc(219.62,79.57) 219.53,80.11 219.53,88.4 arc(219.12,89.38) 218.14,89.79 216.77,89.79 arc(215.34,90.38) 214.74,91.82 214.74,92.98 arc(214.38,94.8) 213.35,96.34 210.62,99.07 arc(210,99.99) 209.79,101.09 209.79,106.53 arc(209.66,107.13) 209.32,107.65 arc(208.9,108.28) 208.75,109.04 208.75,127.18 arc(208.6,127.9) 208.19,128.51 207.97,128.73 arc(207.64,129.23) 207.52,129.82 207.52,132.85 arc(206.47,135.39) 203.93,136.44 180.63,136.44 arc(180.05,136.56) 179.55,136.89 arc(178.43,137.64) 177.11,137.9 160.44,137.9 arc(158.79,137.57) 157.4,136.64 151.96,131.2 arc(150.83,130.45) 149.49,130.18 134.81,130.18 arc(134.76,130.18) 134.71,130.17 arc(134.63,130.13) 134.56,130.08 arc(134.2,129.83) 133.77,129.75 116.34,129.75 arc(115.83,129.85) 115.4,130.14 arc(114.92,130.46) 114.34,130.58 106.14,130.58 arc(105.45,130.44) 104.88,130.06 102.56,127.74 arc(101.58,126.28) 101.24,124.55 101.24,109.15 arc(101.07,108.32) 100.6,107.61 99.15,106.16 arc(98.81,105.65) 98.69,105.04 98.69,91.12 arc(98.85,90.31) 99.3,89.63 102.98,85.95 arc(103.32,85.73) 103.71,85.65 104.02,85.65 arc(104.14,85.7) 104.2,85.83 104.2,85.88 arc(104.36,86.04) 104.53,85.88 arc(104.7,85.7) 104.88,85.88 arc(105.06,86.06) 105.24,85.88 arc(105.41,85.7) 105.59,85.88 arc(105.77,86.06) 105.95,85.88 arc(106.13,85.7) 106.3,85.88 arc(106.49,86.07) 106.68,85.88 106.68,85.83 arc(106.74,85.7) 106.86,85.65 107.2,85.65 arc(108.81,86.32) 109.48,87.94 arc(109.57,88.39) 109.83,88.78 110.3,89.24 arc(110.32,89.29) 110.31,89.34 110.29,89.4 arc(110.25,89.44) 110.2,89.46 109.53,89.46 arc(109.38,89.31) 109.53,89.17 v6(109.73,89.17)
  BOTTOM w0.127: J57.31 203.68,30.77 203.68,28.86 arc(203.66,28.74) v2(203.59,28.63)
  vias: v1(110.31,88.63)
CSI1_RX0_P: length 301.1
  L3-SIGNAL1 w0.084: v3(110.32,89.43) v5(110.04,89.66)
  L4-GND2 w0.084: v5(110.04,89.66) v6(109.73,89.97)
  L5-SIGNAL2 w0.102: v6(109.73,89.97) 109.8,89.9 arc(109.89,89.84) 110,89.81 110.2,89.81 arc(110.45,89.74) 110.62,89.53 110.64,89.48 arc(110.67,89.22) 110.55,88.99 110.08,88.53 arc(109.9,88.26) 109.84,87.94 arc(109.06,86.07) 107.2,85.29 103.71,85.29 arc(103.18,85.4) 102.73,85.7 99.05,89.38 arc(98.52,90.18) 98.33,91.12 98.33,105.04 arc(98.48,105.78) 98.9,106.41 100.35,107.86 arc(100.74,108.45) 100.88,109.15 100.88,124.55 arc(101.25,126.41) 102.31,127.99 104.62,130.31 arc(105.32,130.77) 106.14,130.93 114.34,130.93 arc(115.05,130.79) 115.65,130.39 arc(115.97,130.18) 116.34,130.1 133.77,130.1 arc(134.06,130.16) 134.31,130.33 arc(134.45,130.44) 134.61,130.51 arc(134.71,130.53) 134.81,130.54 149.49,130.54 arc(150.69,130.77) 151.71,131.46 157.15,136.89 arc(158.66,137.9) 160.44,138.25 177.11,138.25 arc(178.57,137.96) 179.8,137.14 arc(180.18,136.89) 180.63,136.8 203.93,136.8 arc(206.72,135.64) 207.88,132.85 207.88,129.82 arc(207.97,129.37) 208.23,128.98 208.44,128.76 arc(208.93,128.04) 209.1,127.18 209.1,109.04 arc(209.22,108.42) 209.57,107.9 arc(209.99,107.27) 210.14,106.53 210.14,101.09 arc(210.33,100.13) 210.87,99.32 213.6,96.59 arc(214.71,94.93) 215.1,92.98 215.1,91.82 arc(215.59,90.64) 216.77,90.15 218.14,90.15 arc(219.37,89.63) 219.88,88.4 219.88,80.11 arc(219.96,79.69) 220.17,79.33 arc(220.2,79.3) 220.23,79.27 220.92,78.58 arc(221.2,78.17) 221.29,77.67 221.29,54.52 arc(221.12,53.67) 220.64,52.95 219.89,52.2 arc(219.38,51.98) 218.87,52.2 217.49,53.57 arc(217.23,53.68) 216.97,53.57 arc(216.86,53.31) 216.97,53.05 218.07,51.95 arc(218.07,50.93) 217.04,50.93 215.95,52.03 arc(215.69,52.13) 215.43,52.03 arc(215.32,51.77) 215.43,51.5 216.8,50.13 arc(217.01,49.62) 216.8,49.11 216.63,48.94 214.83,47.14 arc(213.67,45.4) 213.26,43.34 213.26,42.29 arc(213.15,41.73) 212.84,41.26 arc(212.35,40.53) 212.17,39.66 212.17,35.01 arc(212,34.14) 211.5,33.39 209.84,31.72 arc(208.85,31.07) 207.69,30.84 204.9,30.84 arc(204.46,30.65) 204.27,30.2 204.27,28.7 arc(204.28,28.66) v2(204.3,28.63)
  BOTTOM w0.127: J57.29 204.2,30.77 204.2,28.86 arc(204.23,28.74) v2(204.3,28.63)
  vias: v1(110.31,89.43)
CSI1_RX1_N: length 301.2
  TOP w0.127: U59.AE33 107.5,87.86 v3(107.46,87.86)
  L3-SIGNAL1 w0.084: v3(107.46,87.86) v5(107.22,87.58)
  L4-GND2 w0.084: v5(107.22,87.58) v6(106.84,87.96)
  L5-SIGNAL2 w0.102: v2(202.09,28.63) 202.17,28.63 arc(202.34,28.7) 202.41,28.88 202.41,31.52 arc(202.68,32.17) 203.33,32.44 207.36,32.44 arc(208.39,32.86) 208.82,33.9 208.82,37.47 arc(209.12,38.99) 209.99,40.28 210.44,40.74 arc(211.22,41.9) 211.49,43.26 211.49,44.73 arc(211.69,45.77) 212.28,46.65 212.48,46.85 arc(212.92,47.5) 213.07,48.28 213.07,59.28 arc(213.26,59.73) 213.71,59.92 214.82,59.92 arc(215.18,59.77) 215.32,59.41 215.32,55.93 arc(215.48,55.55) 215.86,55.4 217.28,55.4 arc(217.6,55.53) 217.74,55.86 217.74,61.21 arc(217.38,62.08) 216.52,62.43 216.01,62.43 arc(215.45,62.66) 215.22,63.22 215.22,73.8 arc(215.43,74.32) 215.95,74.53 218.56,74.53 arc(218.93,74.9) 218.56,75.26 215.95,75.26 arc(215.22,75.99) 215.95,76.71 218.56,76.71 arc(218.93,77.08) 218.56,77.45 215.95,77.45 arc(215.43,77.66) 215.22,78.17 215.22,78.69 arc(215.34,79.27) 215.67,79.76 217.19,81.29 arc(217.52,81.77) 217.63,82.34 217.63,87.07 arc(217.35,87.74) 216.69,88.01 216.34,88.01 arc(215.8,88.12) 215.34,88.42 214.64,89.13 213.84,89.93 arc(213.45,90.51) 213.31,91.19 213.31,92.02 arc(212.98,93.7) 212.03,95.12 209.59,97.56 arc(208.05,99.87) 207.5,102.6 207.5,125.79 arc(207.34,126.63) 206.87,127.33 206.05,128.14 arc(205.5,128.96) 205.31,129.93 205.31,132.08 arc(204.39,134.29) 202.18,135.21 179.67,135.21 arc(178.98,135.35) 178.4,135.74 178.1,136.03 arc(177.79,136.24) 177.42,136.31 161.37,136.31 arc(159.3,135.9) 157.54,134.72 152.47,129.66 arc(151.21,128.82) 149.71,128.52 107.46,128.52 arc(107.09,128.44) 106.78,128.23 103.86,125.31 arc(102.93,123.92) 102.6,122.29 102.6,108.42 arc(102.46,107.71) 102.06,107.11 101.07,106.12 arc(100.79,105.71) 100.69,105.21 100.69,90.29 arc(100.73,90.09) 100.85,89.91 101.15,89.61 arc(101.24,89.58) 101.32,89.61 arc(101.4,89.64) 101.48,89.61 101.57,89.52 arc(101.6,89.44) 101.57,89.36 arc(101.53,89.28) 101.57,89.19 101.66,89.11 arc(101.74,89.07) 101.82,89.11 arc(101.9,89.14) 101.98,89.11 102.07,89.02 arc(102.11,88.94) 102.07,88.86 arc(102.04,88.77) 102.07,88.69 102.16,88.6 arc(102.24,88.57) 102.32,88.6 arc(102.41,88.64) 102.49,88.6 102.57,88.52 arc(102.61,88.43) 102.57,88.35 arc(102.54,88.27) 102.57,88.19 102.69,88.07 arc(102.77,88.04) 102.84,88.07 arc(102.92,88.11) 102.99,88.07 103.09,87.97 arc(103.12,87.9) 103.09,87.82 arc(103.06,87.75) 103.09,87.67 103.24,87.52 arc(103.49,87.36) 103.77,87.3 105.44,87.3 arc(105.55,87.34) 105.59,87.45 105.59,87.48 arc(105.74,87.63) 105.9,87.48 105.9,87.45 arc(106.05,87.3) 106.2,87.45 106.2,87.48 arc(106.35,87.63) 106.51,87.48 106.51,87.45 arc(106.55,87.34) 106.66,87.3 106.94,87.3 arc(107.08,87.36) 107.15,87.51 107.15,87.83 arc(107.11,87.92) 107.02,87.96 v6(106.84,87.96)
  BOTTOM w0.127: J57.35 202.18,30.77 202.18,28.86 arc(202.16,28.74) v2(202.09,28.63)
CSI1_RX1_P: length 301.2
  TOP w0.127: v3(107.46,88.66) 107.47,88.65 U59.AF33
  L3-SIGNAL1 w0.084: v3(107.46,88.66) v5(107.25,88.34)
  L4-GND2 w0.084: v6(107.63,87.96) v5(107.25,88.34)
  L5-SIGNAL2 w0.102: v6(107.63,87.96) 107.6,87.94 arc(107.53,87.82) 107.5,87.69 107.5,87.51 arc(107.34,87.11) 106.94,86.94 103.77,86.94 arc(103.35,87.03) 102.99,87.27 100.6,89.66 arc(100.41,89.95) 100.34,90.29 100.34,105.21 arc(100.46,105.84) 100.82,106.37 101.81,107.36 arc(102.13,107.85) 102.25,108.42 102.25,122.29 arc(102.6,124.06) 103.61,125.57 106.53,128.49 arc(106.96,128.77) 107.46,128.87 149.71,128.87 arc(151.07,129.14) 152.22,129.91 157.29,134.98 arc(159.16,136.23) 161.37,136.67 177.46,136.67 arc(177.93,136.58) 178.32,136.31 178.65,135.99 arc(179.12,135.67) 179.67,135.56 202.18,135.56 arc(204.65,134.54) 205.67,132.08 205.67,129.93 arc(205.83,129.1) 206.3,128.39 207.12,127.58 arc(207.67,126.76) 207.86,125.79 207.86,102.6 arc(208.37,100.01) 209.84,97.81 212.28,95.37 arc(213.31,93.83) 213.67,92.02 213.67,91.19 arc(213.78,90.65) 214.09,90.18 214.89,89.38 215.59,88.68 arc(215.94,88.45) 216.34,88.37 216.69,88.37 arc(217.6,87.99) 217.98,87.07 217.98,82.34 arc(217.84,81.64) 217.44,81.04 215.92,79.51 arc(215.67,79.14) 215.58,78.69 215.58,78.17 arc(215.69,77.91) 215.95,77.8 218.56,77.8 arc(219.29,77.08) 218.56,76.36 215.95,76.36 arc(215.58,75.99) 215.95,75.62 218.56,75.62 arc(219.29,74.9) 218.56,74.17 215.95,74.17 arc(215.69,74.06) 215.58,73.8 215.58,63.22 arc(215.7,62.92) 216.01,62.79 216.52,62.79 arc(217.63,62.33) 218.09,61.21 218.09,55.86 arc(217.85,55.28) 217.28,55.04 215.86,55.04 arc(215.23,55.3) 214.97,55.93 214.97,59.41 arc(214.92,59.52) 214.82,59.56 213.71,59.56 arc(213.51,59.48) 213.43,59.28 213.43,48.28 arc(213.25,47.37) 212.73,46.6 212.53,46.4 arc(212.02,45.63) 211.84,44.73 211.84,43.26 arc(211.54,41.76) 210.69,40.49 210.24,40.03 arc(209.45,38.86) 209.18,37.47 209.18,33.9 arc(208.64,32.61) 207.36,32.08 203.33,32.08 arc(202.94,31.91) 202.77,31.52 202.77,28.7 arc(202.78,28.66) v2(202.8,28.63)
  BOTTOM w0.127: J57.33 202.7,30.77 202.7,28.86 arc(202.73,28.74) v2(202.8,28.63)
CSI1_RX2_N: length 301
  L3-SIGNAL1 w0.084: v3(109.52,87.83) v5(109.24,88.06)
  L4-GND2 w0.084: v5(109.24,88.06) v6(108.93,88.37)
  L5-SIGNAL2 w0.102: v2(200.59,28.63) arc(200.77,28.56) 200.84,28.38 200.84,27.79 arc(200.74,27.54) 200.49,27.43 199.78,27.43 arc(199.47,27.56) 199.35,27.86 199.35,29.72 arc(199.43,30.13) 199.66,30.48 199.77,30.58 202.67,33.48 202.85,33.66 arc(203.26,33.94) 203.75,34.04 206.87,34.04 arc(207.4,34.26) 207.63,34.8 207.63,38.53 arc(207.76,39.21) 208.15,39.79 208.92,40.56 arc(209.35,41.21) 209.51,41.98 209.51,45.44 arc(209.57,45.75) 209.74,46 211.76,48.02 arc(212.02,48.41) 212.11,48.87 212.11,61.52 arc(212.24,62.16) 212.61,62.71 213.24,63.35 arc(213.84,64.25) 214.05,65.31 214.05,66.25 arc(213.84,66.76) 213.33,66.97 209.98,66.97 arc(209.61,67.34) 209.98,67.71 213.33,67.71 arc(214.05,68.43) 213.33,69.16 209.98,69.16 arc(209.61,69.52) 209.98,69.89 213.33,69.89 arc(213.84,70.1) 214.05,70.62 214.05,78.23 arc(213.97,78.65) 213.73,79.01 213.64,79.1 211.62,81.13 arc(211.47,81.35) 211.41,81.62 211.41,82.39 arc(211.52,82.65) 211.78,82.76 215.35,82.76 arc(216.07,83.48) 215.35,84.21 211.78,84.21 arc(211.41,84.57) 211.78,84.94 215.76,84.94 arc(216.48,85.67) 215.76,86.39 211.78,86.39 arc(211.52,86.5) 211.41,86.76 211.41,89.79 arc(211.27,90.49) 210.87,91.09 210.73,91.23 arc(210.6,91.43) 210.55,91.67 210.55,94.16 arc(210.36,95.12) 209.81,95.94 207.38,98.37 arc(206.77,99.28) 206.56,100.35 206.56,124.93 arc(206.31,126.2) 205.59,127.27 204.5,128.36 arc(204.23,128.76) 204.14,129.23 204.14,130.81 arc(203.9,132) 203.22,133.01 arc(201.81,133.95) 200.15,134.28 178.2,134.28 arc(177.94,134.33) 177.72,134.48 177.64,134.56 arc(177,134.99) 176.25,135.14 162.55,135.14 arc(159.52,134.53) 156.96,132.82 152.9,128.76 arc(151.65,127.92) 150.17,127.63 110.61,127.63 arc(109.37,127.38) 108.31,126.67 104.76,123.13 arc(103.92,121.86) 103.62,120.37 103.62,107.38 arc(103.55,107.02) 103.35,106.72 102.12,105.49 arc(101.7,104.87) 101.56,104.13 101.56,91.39 arc(101.67,90.81) 102,90.31 102.53,89.79 arc(102.87,89.56) 103.26,89.48 105.15,89.48 arc(105.43,89.43) 105.66,89.27 106.15,88.78 arc(106.53,88.53) 106.97,88.44 108.75,88.44 arc(108.85,88.42) v6(108.93,88.37)
  BOTTOM w0.127: J57.39 200.68,30.77 200.68,28.86 arc(200.66,28.74) v2(200.59,28.63)
  vias: v1(109.51,87.83)
CSI1_RX2_P: length 301
  L3-SIGNAL1 w0.084: v3(109.52,88.63) v5(109.24,88.86)
  L4-GND2 w0.084: v5(109.24,88.86) v6(108.93,89.17)
  L5-SIGNAL2 w0.102: v6(108.93,89.17) 109.02,89.17 arc(109.13,89.12) 109.18,89.01 arc(109.12,88.86) 108.97,88.8 106.97,88.8 arc(106.66,88.86) 106.4,89.03 105.91,89.52 arc(105.56,89.76) 105.15,89.84 103.26,89.84 arc(103,89.89) 102.78,90.04 102.26,90.56 arc(102,90.94) 101.91,91.39 101.91,104.13 arc(102.03,104.73) 102.37,105.24 103.6,106.47 arc(103.88,106.88) 103.98,107.38 103.98,120.37 arc(104.24,121.73) 105.01,122.88 108.56,126.42 arc(109.5,127.05) 110.61,127.27 150.17,127.27 arc(151.78,127.59) 153.15,128.51 157.21,132.57 arc(159.66,134.2) 162.55,134.78 176.25,134.78 arc(176.86,134.66) 177.39,134.31 177.47,134.23 arc(177.8,134) 178.2,133.93 200.15,133.93 arc(201.68,133.62) 202.97,132.76 arc(203.57,131.86) 203.78,130.81 203.78,129.23 arc(203.9,128.63) 204.25,128.11 205.34,127.02 arc(205.98,126.06) 206.2,124.93 206.2,100.35 arc(206.44,99.14) 207.13,98.12 209.56,95.68 arc(210.03,94.98) 210.19,94.16 210.19,91.67 arc(210.27,91.3) 210.48,90.98 210.62,90.84 arc(210.94,90.36) 211.06,89.79 211.06,86.76 arc(211.27,86.25) 211.78,86.03 215.76,86.03 arc(216.12,85.67) 215.76,85.3 211.78,85.3 arc(211.06,84.57) 211.78,83.85 215.35,83.85 arc(215.71,83.48) 215.35,83.11 211.78,83.11 arc(211.27,82.9) 211.06,82.39 211.06,81.62 arc(211.14,81.22) 211.36,80.88 213.39,78.85 213.48,78.76 arc(213.64,78.52) 213.7,78.23 213.7,70.62 arc(213.59,70.36) 213.33,70.25 209.98,70.25 arc(209.25,69.52) 209.98,68.8 213.33,68.8 arc(213.7,68.43) 213.33,68.06 209.98,68.06 arc(209.25,67.34) 209.98,66.62 213.33,66.62 arc(213.59,66.51) 213.7,66.25 213.7,65.31 arc(213.51,64.38) 212.99,63.6 212.35,62.96 arc(211.91,62.3) 211.76,61.52 211.76,48.87 arc(211.69,48.55) 211.51,48.27 209.49,46.26 arc(209.24,45.88) 209.15,45.44 209.15,41.98 arc(209.03,41.35) 208.67,40.81 207.9,40.04 arc(207.43,39.35) 207.27,38.53 207.27,34.8 arc(207.15,34.51) 206.87,34.39 203.75,34.39 arc(203.12,34.27) 202.59,33.91 199.41,30.73 arc(199.1,30.27) 198.99,29.72 198.99,27.86 arc(199.22,27.31) 199.78,27.08 200.49,27.08 arc(200.99,27.29) 201.2,27.79 201.2,28.39 arc(201.22,28.52) v2(201.3,28.63)
  BOTTOM w0.127: J57.37 201.2,30.77 201.2,28.86 arc(201.23,28.74) v2(201.3,28.63)
  vias: v1(109.51,88.63)
CSI1_RX3_N: length 301
  L3-SIGNAL1 w0.084: v3(108.72,88.63) v5(108.44,88.86)
  L4-GND2 w0.084: v5(108.44,88.86) v6(108.13,89.17)
  L5-SIGNAL2 w0.102: v6(108.13,89.17) 108.06,89.24 arc(107.98,89.3) 107.88,89.33 arc(107.86,89.33) 107.83,89.33 107.53,89.33 arc(107.27,89.38) 107.06,89.53 106.04,90.54 arc(105.82,90.69) 105.55,90.75 104.37,90.75 arc(103.94,90.83) 103.58,91.07 103.14,91.51 arc(102.87,91.92) 102.78,92.39 102.78,102.98 arc(102.91,103.63) 103.27,104.18 104.47,105.37 arc(104.76,105.81) 104.86,106.33 104.86,119 arc(105.19,120.63) 106.12,122.02 108.09,123.99 arc(110.67,125.72) 113.72,126.32 150.72,126.32 arc(152.55,126.68) 154.09,127.72 157.9,131.53 arc(159.87,132.84) 162.18,133.3 167.03,133.3 arc(167.32,133.36) 167.56,133.52 167.64,133.6 arc(167.94,133.8) 168.29,133.87 175.71,133.87 arc(176.39,133.73) 176.98,133.34 arc(177.38,133.07) 177.86,132.97 194.32,132.97 arc(195.72,132.69) 196.92,131.9 199.17,129.65 arc(199.7,129.29) 200.33,129.17 201.41,129.17 arc(201.91,129.07) 202.34,128.78 202.89,128.23 204.69,126.43 arc(205.13,125.78) 205.28,125.01 205.28,99.02 arc(205.32,98.83) 205.43,98.66 205.5,98.59 arc(205.71,98.28) 205.78,97.91 205.78,93.34 arc(205.89,93.08) 206.15,92.97 207.62,92.97 arc(208.34,92.24) 207.62,91.52 206.15,91.52 arc(205.89,91.41) 205.78,91.15 205.78,90.32 arc(205.89,90.06) 206.15,89.95 208.5,89.95 arc(209.23,89.23) 208.5,88.51 206.15,88.51 arc(205.89,88.4) 205.78,88.14 205.78,86.74 arc(206.04,86.1) 206.68,85.84 209.44,85.84 arc(210.16,85.12) 209.44,84.39 207.32,84.39 arc(206.95,84.02) 207.32,83.66 209.44,83.66 arc(210.16,82.93) 209.44,82.21 207.32,82.21 arc(206.95,81.84) 207.32,81.47 209.44,81.47 arc(210.16,80.75) 209.44,80.02 207.32,80.02 arc(207.06,79.92) 206.95,79.66 206.95,77.24 arc(207.06,76.98) 207.32,76.87 211.65,76.87 arc(212.38,76.15) 211.65,75.42 207.32,75.42 arc(206.95,75.06) 207.32,74.69 211.65,74.69 arc(212.38,73.96) 211.65,73.24 207.32,73.24 arc(207.06,73.13) 206.95,72.87 206.95,65.75 arc(207.06,65.49) 207.32,65.38 210.97,65.38 arc(211.69,64.66) 210.97,63.94 207.32,63.94 arc(207.06,63.83) 206.95,63.57 206.95,60.28 arc(207.09,59.96) 207.41,59.82 207.96,59.82 arc(208.48,59.6) 208.7,59.08 208.7,56.59 arc(208.77,56.43) 208.93,56.36 209.64,56.36 arc(210.15,56.15) 210.36,55.65 210.36,51.73 arc(210.2,50.95) 209.76,50.29 209.15,49.68 arc(209.04,49.42) 209.15,49.16 209.56,48.75 arc(209.77,48.24) 209.56,47.73 arc(209.05,47.52) 208.54,47.73 208.13,48.14 arc(207.87,48.25) 207.61,48.14 207.21,47.75 arc(206.98,47.39) 206.89,46.97 206.89,41.86 arc(206.47,40.84) 205.44,40.41 204.89,40.41 arc(204.63,40.36) 204.4,40.21 204.04,39.85 arc(203.89,39.63) 203.84,39.37 203.84,38.89 arc(203.87,38.77) 203.93,38.67 204,38.6 arc(204.3,38.16) 204.4,37.64 arc(204.53,37.34) 204.83,37.21 204.96,37.21 arc(205.18,37.3) 205.27,37.51 205.27,38 arc(205.22,38.23) v2(205.09,38.43)
  BOTTOM w0.127: J57.28 205.18,36.54 205.18,38.2 arc(205.16,38.32) v2(205.09,38.43)
  vias: v1(108.71,88.63)
CSI1_RX3_P: length 301
  L3-SIGNAL1 w0.084: v3(108.72,89.43) v5(108.44,89.66)
  L4-GND2 w0.084: v5(108.44,89.66) v6(108.13,89.97)
  L5-SIGNAL2 w0.102: v6(108.13,89.97) 108.23,89.97 arc(108.36,89.83) 108.23,89.69 107.53,89.69 arc(107.41,89.71) 107.31,89.78 106.82,90.27 106.3,90.79 arc(105.95,91.02) 105.55,91.1 104.37,91.1 arc(104.08,91.16) 103.83,91.32 103.39,91.77 arc(103.2,92.05) 103.13,92.39 103.13,102.98 arc(103.23,103.49) 103.52,103.93 104.72,105.12 arc(105.09,105.68) 105.22,106.33 105.22,119 arc(105.52,120.5) 106.37,121.77 108.34,123.74 arc(110.81,125.39) 113.72,125.97 150.72,125.97 arc(152.68,126.36) 154.34,127.46 158.15,131.28 arc(160,132.51) 162.18,132.95 167.03,132.95 arc(167.46,133.03) 167.82,133.27 167.89,133.35 arc(168.08,133.47) 168.29,133.51 175.71,133.51 arc(176.26,133.4) 176.72,133.09 arc(177.25,132.74) 177.86,132.62 194.32,132.62 arc(195.59,132.37) 196.66,131.65 198.92,129.4 arc(199.56,128.96) 200.33,128.81 201.41,128.81 arc(201.78,128.74) 202.09,128.53 202.64,127.98 204.44,126.18 arc(204.8,125.64) 204.92,125.01 204.92,99.02 arc(204.99,98.69) 205.18,98.41 205.25,98.34 arc(205.38,98.14) 205.43,97.91 205.43,93.34 arc(205.64,92.82) 206.15,92.61 207.62,92.61 arc(207.98,92.24) 207.62,91.88 206.15,91.88 arc(205.64,91.66) 205.43,91.15 205.43,90.32 arc(205.64,89.81) 206.15,89.6 208.5,89.6 arc(208.87,89.23) 208.5,88.86 206.15,88.86 arc(205.64,88.65) 205.43,88.14 205.43,86.74 arc(205.79,85.85) 206.68,85.49 209.44,85.49 arc(209.81,85.12) 209.44,84.75 207.32,84.75 arc(206.6,84.02) 207.32,83.3 209.44,83.3 arc(209.81,82.93) 209.44,82.56 207.32,82.56 arc(206.6,81.84) 207.32,81.12 209.44,81.12 arc(209.81,80.75) 209.44,80.38 207.32,80.38 arc(206.81,80.17) 206.6,79.66 206.6,77.24 arc(206.81,76.73) 207.32,76.52 211.65,76.52 arc(212.02,76.15) 211.65,75.78 207.32,75.78 arc(206.6,75.06) 207.32,74.33 211.65,74.33 arc(212.02,73.96) 211.65,73.6 207.32,73.6 arc(206.81,73.38) 206.6,72.87 206.6,65.75 arc(206.81,65.24) 207.32,65.03 210.97,65.03 arc(211.34,64.66) 210.97,64.29 207.32,64.29 arc(206.81,64.08) 206.6,63.57 206.6,60.28 arc(206.84,59.71) 207.41,59.47 207.96,59.47 arc(208.23,59.35) 208.35,59.08 208.35,56.59 arc(208.52,56.18) 208.93,56.01 209.64,56.01 arc(209.9,55.9) 210,55.65 210,51.73 arc(209.87,51.09) 209.51,50.54 208.9,49.93 arc(208.69,49.42) 208.9,48.91 209.31,48.5 arc(209.42,48.24) 209.31,47.98 arc(209.05,47.87) 208.79,47.98 208.38,48.39 arc(207.87,48.6) 207.36,48.39 206.96,48 arc(206.65,47.52) 206.54,46.97 206.54,41.86 arc(206.22,41.09) 205.44,40.77 204.89,40.77 arc(204.49,40.69) 204.15,40.46 203.79,40.1 arc(203.57,39.76) 203.49,39.37 203.49,38.89 arc(203.54,38.63) 203.68,38.42 203.75,38.35 arc(203.97,38.02) 204.05,37.64 arc(204.28,37.08) 204.83,36.85 204.96,36.85 arc(205.43,37.05) 205.62,37.51 205.62,38 arc(205.67,38.23) v2(205.8,38.43)
  BOTTOM w0.127: J57.26 205.7,36.54 205.7,38.2 arc(205.73,38.32) v2(205.8,38.43)
  vias: v1(108.71,89.43)
CSI1_RX_CALIB: length 17
  L3-SIGNAL1 w0.089: v3(107.92,91.03) v5(107.64,91.26)
  L4-GND2 w0.102: v5(107.64,91.26) v7(107.94,91.57)
  L13-GND5 w0.102: v9(107.65,91.28) 107.73,91.35 v7(107.94,91.57)
  L14-SIGNAL6 w0.089: v11(93.01,88.41) 94.86,88.41 95.64,89.18 101.33,89.18 102.95,90.81 107.18,90.81 v9(107.65,91.28)
  vias: v1(107.91,91.03)
CSI1_RXCLK_N: length 301.1
  L3-SIGNAL1 w0.084: v3(111.12,87.83) v5(110.84,88.06)
  L4-GND2 w0.084: v5(110.84,88.06) v6(110.53,87.76)
  L5-SIGNAL2 w0.102: v6(110.53,87.76) 110.53,86.94 arc(110.49,86.83) 110.38,86.79 110.19,86.79 arc(110.04,86.63) 110.19,86.48 110.38,86.48 arc(110.49,86.44) 110.53,86.33 110.53,86.03 arc(110.5,85.84) 110.39,85.69 109.94,85.24 108.86,84.16 arc(108.46,83.89) 107.98,83.8 107.44,83.8 arc(107.33,83.84) 107.28,83.96 arc(107.23,84.08) 107.11,84.13 107.09,84.13 arc(106.97,84.08) 106.92,83.96 arc(106.87,83.84) 106.76,83.8 106.73,83.8 arc(106.61,83.84) 106.57,83.96 arc(106.52,84.08) 106.4,84.13 106.38,84.13 arc(106.26,84.08) 106.21,83.96 arc(106.16,83.84) 106.05,83.8 106.02,83.8 arc(105.9,83.84) 105.85,83.96 arc(105.81,84.08) 105.69,84.13 105.66,84.13 arc(105.55,84.08) 105.5,83.96 arc(105.45,83.84) 105.33,83.8 105.31,83.8 arc(105.19,83.84) 105.14,83.96 arc(105.1,84.08) 104.98,84.13 104.95,84.13 arc(104.84,84.08) 104.79,83.96 arc(104.74,83.84) 104.62,83.8 104.6,83.8 arc(104.48,83.84) 104.43,83.96 arc(104.38,84.08) 104.27,84.13 104.24,84.13 arc(104.13,84.08) 104.08,83.96 arc(104.03,83.84) 103.91,83.8 103.89,83.8 arc(103.77,83.84) 103.72,83.96 arc(103.67,84.08) 103.56,84.13 103.53,84.13 arc(103.41,84.08) 103.37,83.96 arc(103.32,83.84) 103.2,83.8 102.61,83.8 arc(101.71,83.98) 100.94,84.49 97.3,88.13 arc(96.82,88.85) 96.65,89.71 96.65,91.32 96.65,93.36 arc(96.59,93.63) 96.44,93.86 96.26,94.04 arc(96.21,94.11) 96.2,94.19 96.2,105.54 arc(96.25,105.78) 96.38,105.98 97.37,106.98 arc(97.48,107.04) 97.6,107.07 97.78,107.07 arc(98.06,107.12) 98.3,107.28 99.36,108.34 arc(99.71,108.86) 99.83,109.47 99.83,124.65 arc(100.24,126.71) 101.4,128.45 104.56,131.61 arc(105.2,132.03) 105.94,132.18 120.98,132.18 arc(121.49,132.08) 121.92,131.79 122.06,131.66 arc(122.76,131.19) 123.59,131.02 132.82,131.02 arc(133.17,131.09) 133.46,131.28 arc(133.69,131.44) 133.97,131.49 149.11,131.49 arc(150.15,131.7) 151.03,132.29 157.32,138.59 arc(158.28,139.22) 159.4,139.45 178.84,139.45 arc(179.45,139.32) 179.96,138.98 180.67,138.27 arc(181.14,137.96) 181.69,137.85 205.54,137.85 arc(206.51,137.65) 207.34,137.1 208.81,135.64 arc(209.33,134.86) 209.51,133.94 209.51,129.83 arc(209.65,129.12) 210.05,128.52 210.75,127.82 arc(211.17,127.19) 211.32,126.45 211.32,102.64 arc(211.62,101.12) 212.48,99.84 221.43,90.88 arc(221.87,90.22) 222.03,89.44 222.03,83.11 arc(222.23,82.09) 222.81,81.22 222.9,81.14 arc(223.36,80.44) 223.53,79.61 223.53,75.89 arc(223.52,75.72) 223.48,75.56 arc(223.36,75.24) 223.15,74.98 arc(222.66,74.24) 222.49,73.38 222.49,55.82 arc(221.99,53.3) 220.56,51.17 216.03,46.64 arc(216.03,46.64) 216.03,46.64 arc(215.26,45.49) 214.99,44.14 214.99,42.65 arc(214.76,41.49) 214.1,40.51 arc(213.49,39.59) 213.28,38.51 213.28,35.65 arc(212.88,33.64) 211.73,31.93 210.62,30.81 arc(209.45,30.03) 208.08,29.76 206.06,29.76 arc(205.61,29.57) 205.41,29.11 205.41,28.83 arc(205.36,28.69) 205.22,28.63 v2(205.09,28.63)
  BOTTOM w0.127: J57.27 205.18,30.77 205.18,28.86 arc(205.16,28.74) v2(205.09,28.63)
  vias: v1(111.11,87.83)
CSI1_RXCLK_P: length 301.1
  L3-SIGNAL1 w0.084: v3(111.12,88.63) v5(110.84,88.86)
  L4-GND2 w0.084: v5(110.84,88.86) v6(110.53,88.56)
  L5-SIGNAL2 w0.102: v6(110.53,88.56) 110.81,88.27 arc(110.87,88.19) 110.89,88.1 110.89,86.03 arc(110.82,85.71) 110.64,85.44 110.19,84.99 109.38,84.18 109.11,83.91 arc(108.59,83.56) 107.98,83.44 102.61,83.44 arc(101.57,83.65) 100.69,84.24 97.05,87.88 arc(96.49,88.72) 96.29,89.71 96.29,91.32 96.29,93.36 arc(96.26,93.5) 96.18,93.61 96.01,93.79 arc(95.89,93.97) 95.84,94.19 95.84,105.54 arc(95.92,105.92) 96.13,106.24 97.12,107.23 arc(97.34,107.37) 97.6,107.42 97.78,107.42 arc(97.93,107.45) 98.05,107.54 99.11,108.6 arc(99.38,109) 99.47,109.47 99.47,124.65 arc(99.91,126.84) 101.15,128.7 104.31,131.86 arc(105.06,132.36) 105.94,132.54 120.98,132.54 arc(121.63,132.41) 122.17,132.04 122.31,131.91 arc(122.9,131.51) 123.59,131.38 132.82,131.38 arc(133.03,131.42) 133.21,131.54 arc(133.56,131.77) 133.97,131.85 149.11,131.85 arc(150.01,132.03) 150.77,132.54 157.07,138.84 arc(158.14,139.55) 159.4,139.8 178.84,139.8 arc(179.58,139.65) 180.22,139.23 180.93,138.52 arc(181.28,138.29) 181.69,138.2 205.54,138.2 arc(206.65,137.98) 207.59,137.35 209.06,135.89 arc(209.65,135) 209.86,133.94 209.86,129.83 arc(209.98,129.26) 210.3,128.77 211,128.07 arc(211.5,127.33) 211.67,126.45 211.67,102.64 arc(211.95,101.26) 212.73,100.09 221.68,91.13 arc(222.2,90.36) 222.39,89.44 222.39,83.11 arc(222.56,82.22) 223.06,81.47 223.15,81.39 arc(223.69,80.57) 223.88,79.61 223.88,75.89 arc(223.87,75.68) 223.83,75.47 arc(223.66,75.07) 223.4,74.72 arc(222.99,74.11) 222.84,73.38 222.84,55.82 arc(222.31,53.17) 220.81,50.92 216.28,46.38 arc(215.59,45.35) 215.35,44.14 215.35,42.65 arc(215.09,41.36) 214.36,40.25 arc(213.82,39.45) 213.63,38.51 213.63,35.65 arc(213.2,33.5) 211.99,31.68 210.87,30.56 arc(209.59,29.71) 208.08,29.41 206.06,29.41 arc(205.86,29.32) 205.77,29.11 205.77,28.7 arc(205.78,28.66) v2(205.8,28.63)
  BOTTOM w0.127: J57.25 205.7,30.77 205.7,28.86 arc(205.73,28.74) v2(205.8,28.63)
  vias: v1(111.11,88.63)
CSI1_TX0_N: length 122.6
  TOP w0.127: v3(73.07,184.95) 73.07,186.32 J10.11
  L3-SIGNAL1 w0.084: v3(110.32,91.83) v5(110.04,92.06) ; v5(73.54,175.88) arc(73.63,176.02) 73.66,176.18 73.66,182.28 arc(73.6,182.58) 73.43,182.83 arc(73.24,183.13) 73.17,183.48 73.17,184.72 arc(73.14,184.85) v3(73.07,184.95)
  L4-GND2 w0.084: v5(110.04,92.06) v7(109.73,92.37) ; v5(73.54,175.88) v7(73.47,175.46)
  L12-SIGNAL5 w0.102: v7(109.73,92.37) 109.58,92.52 arc(109.55,92.54) 109.51,92.55 109.36,92.55 arc(109.11,92.59) 108.91,92.73 108.8,92.84 108.52,93.11 arc(108.42,93.16) 108.32,93.11 arc(108.22,93.07) 108.11,93.11 108.1,93.12 arc(108.06,93.23) 108.1,93.33 arc(108.15,93.43) 108.1,93.54 107.74,93.89 arc(107.43,94.36) 107.32,94.91 107.32,97.8 arc(107.24,98.24) 106.99,98.6 103.38,102.21 arc(102.88,102.97) 102.7,103.85 102.7,112.08 arc(102.39,113.67) 101.49,115.01 89.96,126.54 arc(89.53,127.19) 89.38,127.94 89.38,130.26 arc(89.25,130.9) 88.89,131.44 84.45,135.89 arc(84.12,136.37) 84.01,136.95 84.01,137.37 arc(83.91,137.89) 83.61,138.34 76.66,145.29 arc(75.85,146.49) 75.57,147.91 75.57,152.21 arc(75.84,152.86) 76.49,153.13 77.87,153.13 arc(78.22,153.27) 78.36,153.62 78.36,153.71 arc(78.21,154.09) 77.83,154.25 76.49,154.25 arc(75.57,155.16) 76.49,156.08 77.87,156.08 arc(78.22,156.22) 78.36,156.57 78.36,156.66 arc(78.21,157.04) 77.83,157.19 76.49,157.19 arc(75.57,158.11) 76.49,159.02 77.87,159.02 arc(78.22,159.17) 78.36,159.52 78.36,159.61 arc(78.21,159.98) 77.83,160.14 76.49,160.14 arc(75.84,160.41) 75.57,161.05 75.57,163.85 arc(75.42,164.61) 74.99,165.26 74.37,165.88 arc(73.84,166.67) 73.65,167.61 73.65,175.1 arc(73.62,175.27) 73.52,175.41 v7(73.47,175.46)
  vias: v1(110.31,91.83)
CSI1_TX0_P: length 122.6
  TOP w0.127: J10.9 73.59,186.32 v3(73.59,184.95)
  L3-SIGNAL1 w0.084: v3(111.12,91.83) v5(110.84,92.06) ; v5(74.12,175.88) arc(74.03,176.02) 73.99,176.18 73.99,182.28 arc(73.91,182.7) 73.67,183.07 arc(73.54,183.25) 73.5,183.48 73.5,184.72 arc(73.52,184.85) v3(73.59,184.95)
  L4-GND2 w0.084: v5(110.84,92.06) v7(110.53,92.37) ; v7(74.19,175.46) v5(74.12,175.88)
  L12-SIGNAL5 w0.102: v7(110.53,92.37) 110.28,92.62 arc(109.97,92.83) 109.6,92.9 109.36,92.9 arc(109.25,92.92) 109.16,92.98 109.05,93.09 108,94.15 arc(107.76,94.5) 107.68,94.91 107.68,97.8 arc(107.57,98.37) 107.24,98.86 103.64,102.46 arc(103.21,103.1) 103.06,103.85 103.06,112.08 arc(102.72,113.8) 101.74,115.26 90.21,126.79 arc(89.86,127.32) 89.74,127.94 89.74,130.26 arc(89.58,131.04) 89.14,131.7 84.7,136.14 arc(84.45,136.51) 84.37,136.95 84.37,137.37 arc(84.24,138.03) 83.86,138.59 76.91,145.54 arc(76.18,146.63) 75.93,147.91 75.93,152.21 arc(76.09,152.61) 76.49,152.77 77.87,152.77 arc(78.47,153.02) 78.72,153.62 78.72,153.71 arc(78.46,154.34) 77.83,154.6 76.49,154.6 arc(75.93,155.16) 76.49,155.72 77.87,155.72 arc(78.47,155.97) 78.72,156.57 78.72,156.66 arc(78.46,157.29) 77.83,157.55 76.49,157.55 arc(75.93,158.11) 76.49,158.67 77.87,158.67 arc(78.47,158.92) 78.72,159.52 78.72,159.61 arc(78.46,160.23) 77.83,160.5 76.49,160.5 arc(76.09,160.66) 75.93,161.05 75.93,163.85 arc(75.75,164.75) 75.24,165.51 74.62,166.13 arc(74.17,166.81) 74.01,167.61 74.01,175.1 arc(74.04,175.27) 74.14,175.41 v7(74.19,175.46)
CSI1_TX1_N: length 122.5
  TOP w0.127: J10.15 71.57,186.32 v3(71.57,184.95)
  L3-SIGNAL1 w0.084: v3(111.12,92.63) v5(110.84,92.86) ; v3(71.57,184.95) arc(71.64,184.85) 71.67,184.72 71.67,183.34 arc(71.73,183.02) 71.91,182.76 72.01,182.65 arc(72.14,182.46) 72.19,182.22 72.19,178.97 arc(72.16,178.81) v5(72.07,178.67)
  L4-GND2 w0.084: v5(72.07,178.67) v7(72,178.25) ; v5(110.84,92.86) v7(110.53,93.17)
  L12-SIGNAL5 w0.102: v7(110.53,93.17) 110.38,93.32 arc(110.35,93.34) 110.31,93.35 110.16,93.35 arc(109.91,93.39) 109.71,93.53 109.56,93.68 arc(109.47,93.72) 109.38,93.68 arc(109.29,93.65) 109.2,93.68 109.16,93.72 arc(109.12,93.81) 109.16,93.9 arc(109.2,93.99) 109.16,94.08 108.86,94.38 arc(108.64,94.7) 108.57,95.09 108.57,98.46 arc(108.38,99.39) 107.85,100.19 105.09,102.95 arc(104.71,103.52) 104.57,104.19 104.57,114.25 arc(104.4,115.12) 103.91,115.86 91.62,128.14 arc(91.14,128.87) 90.97,129.73 90.97,131.03 arc(90.88,131.44) 90.65,131.79 86.46,135.98 arc(86.11,136.51) 85.98,137.14 85.98,137.92 arc(85.88,138.41) 85.61,138.82 80.62,143.8 arc(80.21,144.42) 80.07,145.14 80.07,147.81 arc(80.18,148.36) 80.49,148.83 80.6,148.94 arc(80.89,149.37) 80.99,149.88 80.99,161.04 arc(80.9,161.25) 80.68,161.34 79.87,161.34 arc(79.24,161.6) 78.98,162.23 78.98,162.97 arc(79.23,163.58) 79.84,163.83 80.75,163.83 arc(80.92,163.9) 80.99,164.06 80.99,169.95 arc(81.27,171.34) 82.05,172.51 arc(82.3,172.88) 82.38,173.31 82.38,176.6 arc(81.76,178.1) 80.27,178.71 77.55,178.71 arc(76.8,178.57) 76.17,178.14 76.06,178.04 74.72,176.7 arc(74.43,176.5) 74.07,176.43 72.93,176.43 arc(72.45,176.63) 72.25,177.12 72.25,177.97 arc(72.24,178.01) 72.22,178.04 v7(72,178.25)
  vias: v1(111.11,92.63)
