# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR0_DQ2: length 31.5
  L3-SIGNAL1 w0.127: v5(132.39,79.93) v3(132.72,79.83)
  L3-SIGNAL1 w0.129: v3(154.33,85.48) 154.72,85.78 v5(154.73,85.79)
  L4-GND2 w0.146: v6(155.06,86.15) v5(154.73,85.79) ; v6(132.65,79.68) v5(132.39,79.93)
  L5-SIGNAL2 w0.152: v6(132.65,79.68) 133.13,79.2 134.4,79.2 134.5,79.3 143.14,79.3 145.03,81.2 145.03,81.82 145.3,82.09 146.61,82.09 146.79,81.92 146.79,81.72 146.95,81.56 147.35,81.56 147.47,81.67 147.47,82 147.63,82.17 148.23,82.17 148.44,81.96 148.44,81.69 148.57,81.56 148.76,81.56 148.9,81.69 148.9,81.96 149.03,82.09 149.22,82.09 149.35,81.96 149.35,81.69 149.49,81.56 149.68,81.56 149.81,81.69 149.81,82.14 149.95,82.27 150.14,82.27 150.36,82.04 153.25,82.04 154.01,82.81 154.01,83.72 154.34,84.05 154.34,84.71 154.89,85.26 154.89,85.98 v6(155.06,86.15)
  vias: v1(154.33,85.48)
DDR0_DQ3: length 31.5
  L3-SIGNAL1 w0.127: v5(131.48,80.75) v3(131.12,80.63)
  L3-SIGNAL1 w0.129: v5(153.93,86.44) 153.93,86.44 v3(154.33,86.13)
  L4-GND2 w0.146: v6(131.13,80.7) v5(131.48,80.75) ; v6(153.53,86.13) v5(153.93,86.44)
  L5-SIGNAL2 w0.152: v6(153.53,86.13) 153.2,85.8 150.87,85.8 150.66,86.01 150.66,86.28 150.06,86.88 150.06,87.38 149.91,87.53 149.69,87.53 149.54,87.38 149.54,86.59 149.18,86.24 148.64,86.24 148.49,86.39 148.49,86.71 148.72,86.94 148.72,87.35 148.54,87.53 148.12,87.53 147.94,87.35 147.94,87 147.79,86.84 147.35,86.84 147.08,86.57 144.34,86.57 143.85,86.08 143.55,86.08 143.22,86.41 143.01,86.41 139.87,83.27 139.87,82.8 139.72,82.65 139.45,82.65 138.69,81.89 132.57,81.89 131.38,80.7 v6(131.13,80.7)
  vias: v1(154.33,86.13)
DDR0_DQ4: length 31.5
  L3-SIGNAL1 w0.127: v5(130.68,81.55) v3(130.32,81.43)
  L3-SIGNAL1 w0.129: v5(152.33,85.81) 152.33,85.8 v3(152.73,86.13)
  L4-GND2 w0.146: v6(130.95,81.79) v5(130.68,81.55) ; v6(151.93,86.13) v5(152.33,85.81)
  L5-SIGNAL2 w0.152: v6(151.93,86.13) 151.91,86.11 151.16,86.11 150.98,86.28 150.98,86.61 151.13,86.77 151.77,86.77 151.92,86.92 151.92,87.69 151.62,87.99 151.27,87.99 151.11,87.83 151.11,87.33 150.83,87.05 150.58,87.05 150.45,87.18 150.45,87.81 150.29,87.96 149.56,87.96 149.24,87.64 149.02,87.64 148.73,87.94 147.99,87.94 147.61,87.55 147.61,87.35 147.46,87.2 147.23,87.2 147.03,87 144.16,87 143.82,86.67 143.58,86.67 143.25,87 142.99,87 138.31,82.32 131.63,82.32 131.44,82.13 131.44,81.56 131.28,81.41 131.06,81.41 130.95,81.52 v6(130.95,81.79)
  vias: v1(152.73,86.13)
DDR0_DQ5: length 31.5
  L3-SIGNAL1 w0.127: v5(132.28,80.75) v3(131.92,80.63)
  L3-SIGNAL1 w0.129: v5(152.33,85.16) 152.33,85.17 v3(152.73,85.48)
  L4-GND2 w0.146: v6(151.93,85.48) v5(152.33,85.16) ; v6(131.93,80.7) v5(132.28,80.75)
  L5-SIGNAL2 w0.152: v6(131.93,80.7) 132.68,81.46 132.85,81.46 133.16,81.15 133.41,81.15 133.71,81.46 139.31,81.46 139.47,81.62 139.47,82.04 139.61,82.17 139.8,82.17 139.93,82.04 139.93,81.52 140.06,81.38 140.29,81.38 140.45,81.53 140.45,82.76 140.3,82.9 140.3,83.09 140.44,83.22 140.62,83.22 140.89,82.96 141.03,82.96 141.18,83.11 141.18,83.31 140.95,83.55 140.95,83.74 141.08,83.87 141.27,83.87 141.48,83.66 141.67,83.66 141.81,83.79 141.81,83.98 141.59,84.19 141.59,84.38 141.73,84.52 141.92,84.52 142.18,84.25 142.37,84.25 142.5,84.39 142.5,84.58 142.24,84.84 142.24,85.03 142.37,85.16 142.56,85.16 142.78,84.95 142.97,84.95 143.1,85.08 143.1,85.27 142.92,85.45 142.92,85.64 143.06,85.77 143.25,85.77 143.55,85.47 143.87,85.47 144.43,86.03 145.6,86.03 145.8,86.23 146.16,86.23 146.52,85.88 149.44,85.88 149.81,86.26 150.13,86.26 150.32,86.06 150.32,85.45 150.5,85.27 151.72,85.27 v6(151.93,85.48)
  vias: v1(152.73,85.48)
DDR0_DQ6: length 31.5
  L3-SIGNAL1 w0.127: v5(129.85,80.7) v3(129.52,80.63)
  L3-SIGNAL1 w0.129: v5(152.41,83.83) 152.43,83.85 v3(152.73,84.18)
  L4-GND2 w0.146: v6(152.1,84.13) v5(152.41,83.83) ; v6(130.21,80.59) v5(129.85,80.7)
  L5-SIGNAL2 w0.152: v6(152.1,84.13) 152.36,83.87 152.36,83.65 152.17,83.46 150.6,83.46 150.3,83.77 148.88,83.77 148.75,83.9 148.75,84.5 148.6,84.65 148.41,84.65 148.26,84.51 148.26,83.9 148.13,83.77 147.94,83.77 147.81,83.9 147.81,84.55 147.67,84.68 147.48,84.68 147.35,84.55 147.35,83.9 147.22,83.77 147.03,83.77 146.89,83.9 146.89,84.45 146.76,84.58 146.57,84.58 146.43,84.45 146.43,83.95 146.3,83.82 145.17,83.82 142.58,81.23 142.58,80.37 142.38,80.16 134.3,80.16 134.09,79.96 133.69,79.96 132.9,80.75 132.55,80.75 132.11,80.31 131.06,80.31 130.78,80.59 v6(130.21,80.59)
  vias: v1(152.73,84.18)
DDR0_DQ7: length 31.5
  L3-SIGNAL1 w0.127: v5(129.04,80.44) v3(128.72,80.63)
  L3-SIGNAL1 w0.129: v5(152.41,83.18) 152.41,83.19 v3(152.73,83.53)
  L4-GND2 w0.146: v6(128.73,80.7) v5(129.04,80.44) ; v6(152.71,82.91) v5(152.41,83.18)
  L5-SIGNAL2 w0.152: v6(128.73,80.7) 129.19,80.24 130.51,80.24 130.74,80.01 133.03,80.01 133.38,79.65 134.37,79.65 134.45,79.73 142.88,79.73 143.16,80.01 143.16,80.8 143.44,81.08 144.01,81.08 144.33,81.4 144.33,82.09 144.81,82.58 145.35,82.58 145.48,82.71 145.48,83.25 145.62,83.39 145.81,83.39 145.94,83.25 145.94,82.71 146.07,82.58 146.26,82.58 146.4,82.71 146.4,83.25 146.53,83.39 146.72,83.39 146.85,83.25 146.85,82.71 146.99,82.58 148.27,82.58 148.93,83.24 149.21,83.24 149.72,82.73 151.09,82.73 151.42,83.06 152.56,83.06 v6(152.71,82.91)
  vias: v1(152.73,83.53)
DDR0_DQ8: length 22
  L3-SIGNAL1 w0.14: v3(131.12,82.23) 131.19,82.23 131.54,81.88 131.62,81.88 131.66,81.84 131.99,81.84 132.25,82.1 132.25,82.28 132.53,82.56 133.27,82.56 133.64,82.19 134.49,82.19 134.63,82.06 142.6,82.06 142.73,82.19 142.73,82.42 142.86,82.55 143.05,82.55 143.18,82.42 143.18,82.19 143.31,82.06 143.58,82.06 143.71,82.19 143.71,83.57 143.84,83.7 144.02,83.7 144.15,83.57 144.15,82.19 144.28,82.06 144.55,82.06 144.7,82.21 144.7,83.53 144.86,83.69 146.92,83.69 v3(147.1,83.52)
DDR0_DQ9: length 21.9
  L3-SIGNAL1 w0.14: v3(128.72,82.23) 128.72,81.9 128.86,81.76 129.63,81.76 129.75,81.88 130.02,81.88 130.06,81.84 130.39,81.84 130.74,82.19 130.74,82.4 131,82.65 132.24,82.65 132.44,82.85 133.58,82.85 133.96,82.46 134.23,82.46 134.24,82.47 142.2,82.47 142.69,82.97 143.15,82.97 143.29,83.11 143.29,84.07 143.79,84.57 144.06,84.57 144.19,84.44 144.19,84.25 144.32,84.12 144.5,84.12 144.63,84.25 144.63,84.44 144.76,84.57 145.43,84.57 145.54,84.46 145.54,84.26 145.68,84.12 146.31,84.12 146.37,84.18 v3(147.13,84.18)
DDR0_DQ10: length 21.9
  L3-SIGNAL1 w0.14: v3(131.92,83.03) 132,83.11 133.13,83.11 133.99,83.97 134.76,83.97 134.9,84.12 134.9,84.68 135.45,85.23 138.2,85.23 138.46,84.96 138.46,83.89 138.6,83.75 138.87,83.75 139,83.88 139,84.76 139.13,84.89 139.31,84.89 139.44,84.76 139.44,83.88 139.57,83.75 141.82,83.75 142.02,83.95 142.02,85.29 142.43,85.71 145.43,85.71 145.54,85.82 145.54,85.96 145.77,86.19 146.09,86.19 146.46,85.82 146.46,85.67 146.66,85.48 v3(147.16,85.48)
DDR0_DQ11: length 21.9
  L3-SIGNAL1 w0.14: v3(130.32,82.23) 130.32,82.49 130.82,82.99 130.82,83.17 131.14,83.49 131.3,83.49 131.53,83.72 131.53,83.87 131.68,84.02 131.68,84.12 131.83,84.28 132.06,84.28 132.13,84.35 132.4,84.35 132.47,84.28 132.88,84.28 133.19,84.59 133.19,84.81 133.45,85.06 133.69,85.06 133.8,85.17 134.17,85.17 135.07,86.07 139.34,86.07 139.71,85.7 139.89,85.7 140.17,85.98 140.37,85.98 140.53,85.82 140.53,85.58 140.26,85.31 140.26,85.12 140.4,84.98 141.04,84.98 141.18,85.12 141.18,85.64 142.09,86.55 144.86,86.55 145.28,86.96 146.32,86.96 v3(147.1,86.16)
DDR0_DQ12: length 21.9
  L3-SIGNAL1 w0.14: v3(129.52,83.03) 129.9,83.42 129.9,83.88 130.18,84.16 130.31,84.16 130.65,84.5 130.65,84.62 131.09,85.07 131.25,85.07 131.55,85.37 131.55,85.57 131.81,85.83 131.97,85.83 132.1,85.95 132.54,85.95 132.58,85.91 134.25,85.91 134.83,86.49 141.44,86.49 141.91,86.96 141.94,87 144.72,87 145.11,87.38 145.76,87.38 145.77,87.37 145.89,87.37 146.55,87.37 147.18,86.89 147.66,86.89 v3(148.75,86.13)
DDR0_DQ13: length 21.9
  L3-SIGNAL1 w0.14: v3(132.72,81.43) 132.95,81.43 133.31,81.08 134.02,81.08 134.3,80.8 148.93,80.8 149.77,81.64 149.77,82.58 149.13,83.21 149.13,85.08 v3(148.73,85.48)
DDR0_DQ14: length 22
  L3-SIGNAL1 w0.14: v3(148.73,84.18) 148.34,84.57 148.34,85.58 148.1,85.83 146.92,85.83 146.21,86.54 145.45,86.54 145.04,86.13 142.26,86.13 141.6,85.47 141.6,84.93 141.23,84.56 140.01,84.56 139.86,84.71 139.86,84.93 139.15,85.65 135.28,85.65 133.04,83.41 131.76,83.41 131.38,83.03 v3(131.15,83.03)
DDR0_DQ15: length 21.9
  L3-SIGNAL1 w0.14: v3(148.73,83.53) 148.73,83.13 148.85,83.01 148.85,82.82 148.68,82.65 148.68,82.46 148.97,82.17 149.18,82.17 149.35,82 149.35,81.81 148.75,81.22 148.53,81.22 148.4,81.36 148.4,82.16 148.26,82.3 147.91,82.3 147.46,81.84 147.46,81.34 147.33,81.22 134.39,81.22 134.2,81.41 133.46,81.41 133.08,81.79 132.37,81.79 132.01,81.43 v3(131.92,81.43)
DDR0_DQ16: length 31.3
  L3-SIGNAL1 w0.127: v5(130.68,87.15) v3(130.32,87.03)
  L3-SIGNAL1 w0.129: v6(154.33,95.88) 154.01,95.53 v5(154.01,95.53)
  L4-GND2 w0.146: v6(154.33,95.88) v5(154.01,95.53) ; v6(130.33,87.1) v5(130.68,87.15)
  L5-SIGNAL2 w0.152: v6(154.33,95.88) 154.33,96.45 152.95,97.83 144.4,97.83 136.25,89.69 132.93,89.69 130.34,87.1 v6(130.33,87.1)
  vias: v1(154.33,95.88)
DDR0_DQ17: length 31.3
  L3-SIGNAL1 w0.127: v5(132.28,86.35) v3(131.92,86.23)
  L3-SIGNAL1 w0.129: v6(154.33,95.23) 154.01,94.87 v5(154.01,94.88)
  L4-GND2 w0.146: v6(131.93,86.3) v5(132.28,86.35) ; v6(154.33,95.23) v5(154.01,94.88)
  L5-SIGNAL2 w0.152: v6(154.33,95.23) 154.67,94.69 154.67,93.78 154.49,93.6 153.2,93.6 152.6,93.6 151.94,92.95 151.94,92.17 151.67,91.9 148.17,91.9 147.92,92.14 147.92,92.47 147.69,92.7 147.37,92.7 147.21,92.53 145.63,92.53 145.53,92.43 145.52,92.43 144.81,91.72 144.81,91.44 138.88,85.51 134.29,85.51 133.84,85.95 133.69,85.95 133.28,86.36 131.98,86.36 v6(131.93,86.3)
  vias: v1(154.33,95.23)
DDR0_DQ18: length 31.3
  L3-SIGNAL1 w0.127: v5(132.28,87.96) v3(131.92,87.83)
  L3-SIGNAL1 w0.129: v5(154.73,93.61) 154.73,93.6 v6(154.33,93.93)
  L4-GND2 w0.146: v6(154.33,93.93) v5(154.73,93.61) ; v6(131.93,87.9) v5(132.28,87.96)
  L5-SIGNAL2 w0.152: v6(131.93,87.9) 131.93,88.18 133,89.26 136.56,89.26 144.7,97.4 150.39,97.4 150.52,97.26 150.52,97.14 150.65,97 150.84,97 150.98,97.14 150.98,97.26 151.11,97.4 151.39,97.4 151.54,97.25 151.54,96.9 151.76,96.68 152.78,96.68 152.95,96.51 152.95,96.28 153.48,95.76 153.78,95.76 153.93,95.61 153.93,94.95 154.33,94.55 v6(154.33,93.93)
  vias: v1(154.33,93.93)
DDR0_DQ19: length 31.3
  L3-SIGNAL1 w0.127: v5(133.13,85.24) v3(132.72,85.43)
  L3-SIGNAL1 w0.129: v6(154.33,93.28) 154.73,92.95 v5(154.73,92.96)
  L4-GND2 w0.146: v5(133.13,85.24) v6(133.59,85.24) ; v6(154.33,93.28) v5(154.73,92.96)
  L5-SIGNAL2 w0.152: v6(133.59,85.24) 134.25,84.58 139.2,84.58 143.7,89.08 144.44,89.08 144.9,89.54 145.4,89.54 145.55,89.69 145.55,90.42 145.7,90.58 154.99,90.58 155.17,90.76 155.17,91 155.02,91.16 154.47,91.16 154.31,91.32 154.31,91.54 154.49,91.72 154.99,91.72 155.13,91.85 155.13,93.07 154.91,93.28 v6(154.33,93.28)
  vias: v1(154.33,93.28)
DDR0_DQ20: length 31.3
  L3-SIGNAL1 w0.127: v5(131.48,86.35) v3(131.12,86.23)
  L3-SIGNAL1 w0.129: v6(152.73,93.28) 152.41,92.94 v5(152.41,92.93)
  L4-GND2 w0.146: v6(152.73,93.28) v5(152.41,92.93) ; v6(131.13,86.3) v5(131.48,86.35)
  L5-SIGNAL2 w0.152: v6(152.73,93.28) 152.73,91.76 152.05,91.08 151.04,91.08 150.63,91.49 150.07,91.49 149.69,91.11 149.25,91.11 149.11,91.24 149.11,91.38 148.98,91.52 148.79,91.52 148.66,91.38 148.66,91.24 148.52,91.11 148.33,91.11 148.2,91.24 148.2,91.38 148.06,91.52 147.88,91.52 147.74,91.38 147.74,91.24 147.61,91.11 147.35,91.11 147.2,91.26 147.2,91.8 146.92,92.08 145.78,92.08 145.25,91.54 145.25,90.96 144.76,90.48 144.76,90.01 144.31,89.56 143.57,89.56 139.07,85.07 134.3,85.07 133.74,85.62 133.51,85.62 133.08,86.06 132.44,86.06 132.29,85.9 131.53,85.9 v6(131.13,86.3)
  vias: v1(152.73,93.28)
DDR0_DQ21: length 31.3
  L3-SIGNAL1 w0.127: v5(133.08,87.15) v3(132.72,87.03)
  L3-SIGNAL1 w0.129: v5(152.41,93.58) 152.41,93.6 v6(152.73,93.93)
  L4-GND2 w0.146: v6(152.73,93.93) v5(152.41,93.58) ; v6(132.73,87.1) v5(133.08,87.15)
  L5-SIGNAL2 w0.152: v6(152.73,93.93) 152.33,93.93 151.36,92.96 151.05,92.96 150.91,93.09 150.91,94.05 150.78,94.18 150.59,94.18 150.4,94 150.4,93.02 150.22,92.84 149.18,92.84 149.03,92.99 149.03,93.96 148.85,94.14 148.55,94.14 148.34,93.93 148.34,93.09 148.21,92.96 147.8,92.96 147.67,93.09 147.25,93.09 147.1,93.24 147.1,93.62 146.9,93.83 146.49,93.83 146.34,93.68 146.34,93.12 146.19,92.96 145.37,92.96 144.1,91.7 144.1,91.34 138.7,85.94 135.05,85.94 134.68,86.31 133.79,86.31 133.43,86.67 133.17,86.67 v6(132.73,87.1)
  vias: v1(152.73,93.93)
DDR0_DQ22: length 31.2
  L3-SIGNAL1 w0.127: v5(129.88,86.35) v3(129.52,86.23)
  L3-SIGNAL1 w0.129: v5(152.33,95.55) 152.33,95.56 v6(152.73,95.23)
  L4-GND2 w0.146: v6(129.53,86.3) v5(129.88,86.35) ; v6(152.73,95.23) v5(152.33,95.55)
  L5-SIGNAL2 w0.152: v6(152.73,95.23) 152.57,95.07 151.57,95.07 151.27,95.38 146.44,95.38 146.08,95.74 145.41,95.74 144.67,95 144.67,93.86 142.97,92.16 142.97,91.9 142,90.93 140.53,90.93 137.83,88.22 137.83,87.44 137.68,87.29 137.35,87.29 136.78,87.86 135.91,87.86 135.55,87.5 135.16,87.5 134.86,87.81 133.71,87.81 133.41,87.5 132.6,87.5 131.83,86.74 129.96,86.74 v6(129.53,86.3)
  vias: v1(152.73,95.23)
DDR0_DQ23: length 31.3
  L3-SIGNAL1 w0.127: v5(131.48,87.15) v3(131.12,87.03)
  L3-SIGNAL1 w0.129: v5(152.33,96.2) 152.33,96.21 v6(152.73,95.88)
  L4-GND2 w0.146: v6(152.73,95.88) v5(152.33,96.2) ; v6(131.13,87.1) v5(131.48,87.15)
  L5-SIGNAL2 w0.152: v6(131.13,87.1) 131.32,87.3 131.99,87.3 132.37,87.68 132.37,88.16 133.03,88.82 136.86,88.82 141.15,93.11 141.34,93.11 141.52,92.93 141.71,92.93 141.84,93.07 141.84,93.26 141.66,93.44 141.66,93.63 141.86,93.82 142.05,93.82 142.41,93.46 142.6,93.46 142.73,93.6 142.73,93.79 142.37,94.15 142.37,94.34 142.51,94.47 142.7,94.47 143.06,94.11 143.25,94.11 143.38,94.24 143.38,94.43 143.02,94.79 143.02,94.98 144.89,96.85 146.97,96.85 147.3,96.52 151.42,96.52 151.75,96.19 152.42,96.19 v6(152.73,95.88)
  vias: v1(152.73,95.88)
DDR0_DQ24: length 23.9
  L3-SIGNAL1 w0.14: v3(147.13,95.88) 146.84,96.18 143.94,96.18 142.84,95.08 142.66,95.08 142.46,95.28 142.28,95.28 142.15,95.15 142.15,94.97 142.35,94.76 142.35,94.58 142.22,94.45 142.04,94.45 141.86,94.63 141.68,94.63 141.55,94.5 141.55,94.31 141.72,94.14 141.72,93.95 141.59,93.82 141.41,93.82 141.23,94 141.05,94 140.92,93.87 140.92,93.68 141.09,93.51 141.09,93.32 140.96,93.19 140.78,93.19 140.6,93.37 140.42,93.37 140.29,93.24 140.29,93.06 140.47,92.88 140.47,92.69 140.34,92.56 140.15,92.56 139.95,92.77 139.76,92.77 139.63,92.64 139.63,92.45 139.84,92.25 139.84,92.07 139.71,91.94 139.52,91.94 139.32,92.14 139.14,92.14 139.01,92.01 139.01,91.82 139.21,91.62 139.21,91.44 138.78,91.01 138.78,90.15 138.64,90.01 134.98,90.01 134.92,89.95 132.6,89.95 132.27,89.61 131.3,89.61 v3(131.12,89.43)
DDR0_DQ25: length 23.9
  L3-SIGNAL1 w0.14: v3(147.13,95.2) 146.59,95.74 145.28,95.74 145.14,95.6 145.14,95.25 144.98,95.08 144.75,95.08 144.59,95.24 144.59,95.63 144.46,95.76 144.13,95.76 143.92,95.55 143.92,95.28 144.36,94.84 144.36,94.64 142.94,93.23 142.74,93.23 142.6,93.37 142.6,93.56 143.67,94.63 143.67,94.82 143.53,94.96 143.33,94.96 139.2,90.84 139.2,89.73 139.06,89.59 134.32,89.59 134.2,89.71 133.76,89.71 133.48,89.43 v3(132.72,89.43)
DDR0_DQ26: length 23.9
  L3-SIGNAL1 w0.14: v3(147.13,93.93) 146.82,93.93 146.48,93.59 146.15,93.59 145.95,93.8 145.71,93.8 145.31,93.4 144.71,93.4 143.38,92.07 142.37,92.07 142.23,91.93 142.23,91.71 142.45,91.49 143,91.49 143.14,91.35 143.14,89.56 142.98,89.4 142.78,89.4 142.48,89.7 142.28,89.7 142.14,89.56 142.14,89.36 142.52,88.99 142.52,88.79 142.4,88.67 141.25,88.67 141.22,88.64 140.77,88.19 140.5,88.19 140.22,88.46 139.98,88.46 139.71,88.19 139.48,88.19 139.21,88.46 138.96,88.46 138.69,88.19 138.44,88.19 138.17,88.46 137.85,88.46 137.57,88.19 137.32,88.19 137.05,88.46 136.78,88.46 136.51,88.19 136.25,88.19 135.98,88.46 135.76,88.46 135.49,88.19 135.15,88.19 134.88,88.46 134.62,88.46 134.35,88.19 134.02,88.19 133.11,89.1 132.39,89.1 v3(131.92,88.63)
DDR0_DQ27: length 23.9
  L3-SIGNAL1 w0.14: v3(130.32,87.83) 130.65,87.51 133.99,87.51 134.15,87.35 141.11,87.35 141.6,87.83 142.93,87.83 144.05,88.96 144.05,89.43 144.4,89.78 144.53,89.78 144.95,90.21 144.95,91.4 144.84,91.52 144.6,91.52 144.46,91.38 144.46,90.71 144.35,90.61 144.09,90.61 143.98,90.72 143.98,91.41 145.05,92.49 145.88,92.49 145.89,92.51 146.39,92.51 v3(147.13,93.24)
DDR0_DQ28: length 23.9
  L3-SIGNAL1 w0.14: v3(148.73,93.27) 148.37,92.92 147.54,92.92 146.69,92.08 145.7,92.08 145.37,91.75 145.37,90.02 144.66,89.3 144.66,88.97 143.1,87.41 141.77,87.41 141.74,87.38 141.26,86.91 134.26,86.91 134.06,86.71 130.09,86.71 129.9,86.89 129.9,87.43 129.52,87.81 v3(129.52,87.83)
  vias: v1(148.73,93.28)
DDR0_DQ29: length 23.9
  L3-SIGNAL1 w0.14: v3(130.3,89.45) 131.1,90.25 131.38,90.25 132.17,91.03 132.47,91.03 132.72,91.29 132.72,91.59 132.96,91.82 134.07,91.82 134.93,92.69 138.46,92.69 142.8,97.03 146.87,97.03 147.68,96.22 148.06,96.22 148.32,95.96 148.32,94.36 v3(148.7,93.98)
DDR0_DQ30: length 23.9
  L3-SIGNAL1 w0.14: v3(148.73,95.23) 149.13,94.83 149.13,93.8 148.93,93.6 146.92,93.6 146.26,92.94 144.89,92.94 143.56,91.61 143.56,89.09 142.72,88.25 141.42,88.25 141.39,88.22 140.94,87.77 134.04,87.77 133.53,88.28 131.49,88.28 131.14,88.63 v3(131.12,88.63)
DDR0_DQ31: length 24
  L3-SIGNAL1 w0.14: v3(129.52,90.23) 130.32,91.03 131.67,91.03 131.91,91.27 131.91,91.68 132.05,91.82 132.47,91.82 132.72,92.08 132.72,92.41 132.95,92.63 134.15,92.63 134.78,93.27 138.31,93.27 142.55,97.51 148.17,97.51 148.6,97.08 148.6,96.65 148.73,96.51 v3(148.73,95.88)
DDR0_DQS0_N: length 31.5
  L3-SIGNAL1 w0.127: v5(133.88,80.75) v3(133.52,80.63)
  L3-SIGNAL1 w0.129: v5(153.93,85.16) 153.93,85.15 v6(153.53,85.48)
  L4-GND2 w0.127: v6(133.88,81.08) v5(133.88,80.75) ; v6(153.53,85.48) v5(153.93,85.16)
  L5-SIGNAL2 w0.14: v6(133.88,81.08) 134.14,80.82 134.34,80.82 134.47,80.95 141.29,80.95 141.48,81.14 141.48,81.32 140.94,81.87 140.94,82.28 141.23,82.58 141.65,82.58 142.19,82.03 142.38,82.03 142.51,82.16 142.51,82.35 141.94,82.91 141.94,83.33 142.24,83.62 142.65,83.62 143.22,83.06 143.4,83.06 143.59,83.25 143.59,83.43 143.03,83.99 143.03,84.4 143.37,84.74 143.8,84.74 144.35,84.19 144.53,84.19 144.67,84.33 144.67,84.51 144.31,84.88 144.31,85.29 144.6,85.59 145.01,85.59 145.38,85.22 145.57,85.22 145.66,85.32 146.17,85.32 146.35,85.5 149.22,85.5 149.55,85.17 149.55,84.85 149.77,84.63 150.72,84.63 151,84.91 152.46,84.91 152.82,85.28 153.33,85.28 v6(153.53,85.48)
  vias: v1(133.52,80.63) v1(153.53,85.48)
DDR0_DQS0_P: length 31.5
  L3-SIGNAL1 w0.127: v5(133.88,79.95) v3(133.52,79.83)
  L3-SIGNAL1 w0.129: v5(153.93,84.51) 153.93,84.5 v6(153.53,84.83)
  L4-GND2 w0.127: v6(133.88,80.28) v5(133.88,79.95) ; v6(153.53,84.83) v5(153.93,84.51)
  L5-SIGNAL2 w0.14: v6(153.53,84.83) 153.36,85 152.94,85 152.57,84.63 151.11,84.63 150.83,84.35 149.65,84.35 149.27,84.73 149.27,85.05 149.11,85.22 146.46,85.22 146.29,85.04 145.78,85.04 145.68,84.94 145.27,84.94 144.9,85.31 144.72,85.31 144.58,85.18 144.58,84.99 144.95,84.63 144.95,84.21 144.65,83.91 144.23,83.91 143.68,84.46 143.48,84.46 143.31,84.29 143.31,84.1 143.87,83.54 143.87,83.13 143.52,82.78 143.1,82.78 142.54,83.34 142.35,83.34 142.22,83.21 142.22,83.03 142.79,82.46 142.79,82.05 142.49,81.75 142.08,81.75 141.53,82.3 141.35,82.3 141.22,82.17 141.22,81.98 141.76,81.44 141.76,81.02 141.41,80.67 134.59,80.67 134.46,80.54 134.14,80.54 v6(133.88,80.28)
  vias: v1(133.52,79.83) v1(153.53,84.83)
DDR0_DQS1_N: length 21.9
  TOP w0.229: v3(134.1,83.59) 133.52,83.03 U59.W1
  L3-SIGNAL1 w0.129: v3(134.1,83.59) 134.35,83.34 135.19,83.34 135.32,83.47 135.32,84.51 135.62,84.82 137.68,84.82 137.98,84.51 137.98,84.08 137.68,83.77 136.49,83.77 136.36,83.64 136.36,83.47 136.49,83.34 141.99,83.34 142.48,83.82 142.48,84.94 142.83,85.29 146.24,85.29 146.5,85.03 147.19,85.03 147.45,85.29 147.74,85.29 v3(147.93,85.48)
DDR0_DQS1_P: length 21.9
  TOP w0.229: v3(134.1,82.79) 133.52,82.23 U59.V1
  L3-SIGNAL1 w0.129: v3(134.1,82.79) 134.34,83.03 135.32,83.03 135.62,83.34 135.62,84.38 135.75,84.51 137.55,84.51 137.68,84.38 137.68,84.2 137.55,84.08 136.36,84.08 136.06,83.77 136.06,83.34 136.36,83.03 142.12,83.03 142.78,83.69 142.78,84.81 142.96,84.99 146.11,84.99 146.37,84.73 147.32,84.73 147.58,84.99 147.77,84.99 v3(147.93,84.83)
DDR0_DQS2_N: length 31.2
  L3-SIGNAL1 w0.127: v5(133.88,86.35) v3(133.52,86.23)
  L3-SIGNAL1 w0.129: v5(153.21,93.53) 153.2,93.53 v6(153.53,93.93)
  L4-GND2 w0.127: v6(153.53,93.93) v5(153.21,93.53) ; v6(133.91,86.69) v5(133.88,86.35)
  L5-SIGNAL2 w0.14: v6(153.53,93.93) 153.35,94.11 153.04,94.11 152.9,94.25 152.53,94.25 152.42,94.36 151.29,94.36 151.01,94.64 145.7,94.64 145.37,94.31 145.37,93.57 143.68,91.87 143.68,91.61 141.93,89.86 141.5,89.86 141.14,90.22 140.93,90.22 140.71,90 140.71,89.8 141.05,89.46 141.05,89.04 140.71,88.71 140.3,88.71 139.9,89.11 139.72,89.11 139.59,88.98 139.59,88.8 139.98,88.4 139.98,87.98 139.67,87.66 139.25,87.66 138.85,88.06 138.67,88.06 138.54,87.93 138.54,87.75 138.99,87.3 138.99,86.83 138.61,86.44 136.99,86.44 136.61,86.82 136.61,87.03 136.49,87.15 136.2,87.15 136.07,87.03 136.07,86.82 135.69,86.44 135.19,86.44 134.69,86.95 134.17,86.95 v6(133.91,86.69)
  vias: v1(153.53,93.93)
DDR0_DQS2_P: length 31.2
  L3-SIGNAL1 w0.127: v5(133.88,87.15) v3(133.52,87.03)
  L3-SIGNAL1 w0.129: v5(153.93,94.26) 153.93,94.25 v6(153.53,94.58)
  L4-GND2 w0.127: v6(133.91,87.49) v5(133.88,87.15) ; v6(153.53,94.58) v5(153.93,94.26)
  L5-SIGNAL2 w0.14: v6(133.91,87.49) 134.17,87.22 134.81,87.22 135.31,86.72 135.58,86.72 135.79,86.94 135.79,87.15 136.08,87.43 136.6,87.43 136.89,87.15 136.89,86.94 137.1,86.72 138.49,86.72 138.71,86.94 138.71,87.18 138.26,87.63 138.26,88.05 138.55,88.34 138.97,88.34 139.37,87.94 139.55,87.94 139.71,88.1 139.71,88.28 139.31,88.68 139.31,89.1 139.6,89.39 140.02,89.39 140.41,88.99 140.6,88.99 140.77,89.16 140.77,89.34 140.43,89.68 140.43,90.11 140.82,90.5 141.26,90.5 141.62,90.14 141.82,90.14 143.4,91.72 143.4,91.99 145.09,93.68 145.09,94.43 145.59,94.92 151.13,94.92 151.41,94.64 152.54,94.64 152.65,94.53 153.02,94.53 153.16,94.39 153.34,94.39 153.47,94.52 153.48,94.52 v6(153.53,94.58)
  vias: v1(153.53,94.58)
DDR0_DQS3_N: length 23.9
  TOP w0.229: v3(134.04,88.68) 133.52,88.63 U59.AF1
  L3-SIGNAL1 w0.129: v3(147.93,93.93) 147.74,94.12 147.47,94.12 147.15,94.44 146.14,94.44 145.94,94.64 145.58,94.64 145.45,94.51 145.45,94.16 145.1,93.81 144.54,93.81 143.24,92.51 142.1,92.51 139.93,90.34 139.93,90.1 140.09,89.94 140.33,89.94 141.65,91.26 142.1,91.26 142.45,90.91 142.45,90.47 140.85,88.88 134.24,88.88 v3(134.04,88.68)
DDR0_DQS3_P: length 23.9
  TOP w0.229: U59.AG1 133.52,89.43 v3(134.04,89.38)
  L3-SIGNAL1 w0.129: v3(134.04,89.38) 134.25,89.18 140.72,89.18 142.14,90.6 142.14,90.78 141.97,90.96 141.78,90.96 140.46,89.64 139.96,89.64 139.62,89.98 139.62,90.46 141.97,92.81 143.11,92.81 144.41,94.12 144.97,94.12 145.14,94.28 145.14,94.64 145.45,94.95 146.06,94.95 146.27,94.74 147.28,94.74 147.59,94.43 147.78,94.43 v3(147.93,94.58)
DDR0_ODT_CA_A: length 7.1
  TOP w0.127: U54.G2 v2(154.73,87.11)
  L12-SIGNAL5 w0.102: v2(159.92,86.99) 159.6,86.67 155.17,86.67 v2(154.73,87.11)
  BOTTOM w0.127: R1012.2 v2(159.92,86.99)
DDR0_ODT_CA_B: length 8.3
  TOP w0.127: U54.T2 v2(154.73,92.31)
  L12-SIGNAL5 w0.102: v2(159.9,92.99) 158.07,91.16 155.38,91.16 154.73,91.81 v2(154.73,92.31)
  BOTTOM w0.127: R970.1 v2(159.9,92.99) R978.2
DDR0_RET: length 38.3
  TOP w0.127: U59.AC7 128.72,86.23 v2(129.12,86.63)
  L10-SIGNAL4 w0.109: v2(129.12,86.63) 132.63,86.63 136.97,82.3 148.4,82.3 148.7,81.99 153.45,81.99 153.85,82.39 v2(164.79,82.39)
DDR0_RST#: length 38.2
  TOP w0.127: U54.T11 146.74,92.24 146.74,91.66 v2(146.73,91.66) ; v2(129.12,82.63) 128.72,83.03 U59.W7
  L12-SIGNAL5 w0.102: v2(129.12,82.63) 129.14,82.66 129.14,84.96 128.69,85.41 128.69,86.74 128.96,87.01 131.34,87.01 132.8,88.47 142.82,88.47 143.9,89.55 143.9,90.36 144.14,90.6 146.06,90.6 146.31,90.85 146.31,91.23 v2(146.73,91.66) 152.34,91.66 153.37,90.63 157.19,90.63 v2(157.59,90.23)
DDR0_ZQ0: length 0.5
  TOP w0.127: U54.A5 151.93,82.88 v2(151.53,82.55)
DDR0_ZQ1: length 1.7
  TOP w0.127: v2(149.93,83.2) 149.93,83.2 U54.A8
  BOTTOM w0.127: R1020.2 150.55,82.5 150.16,82.5 149.93,82.72 v2(149.93,83.2)
DDR1_CA0: length 34.8
  L3-SIGNAL1 w0.076: v3(154.33,70.65) 154.63,70.35 154.63,68.67 v5(154.33,68.37) 154.33,67.95 154.64,67.63 154.64,66.41 v3(154.33,66.1)
  L3-SIGNAL1 w0.127: v5(131.48,75.15) v3(131.12,75.03)
  L4-GND2 w0.146: v5(154.33,68.37) v7(154.71,68.8)
  L4-GND2 w0.185: v7(131.07,75.16) v5(131.48,75.15)
  L7-SIGNAL3 w0.185: 132.6,76.07 131.99,76.07 v7(131.07,75.16) ; 153.77,69.23 154.27,69.23 154.59,68.9 v7(154.71,68.8)
  L7-SIGNAL3 w0.191: 153.77,69.23 153.14,69.85 152.59,69.85 151.87,70.56 151.87,71.37 152,71.5 152,71.98 149.84,74.14 147.1,74.14 146.13,75.11 145.61,75.11 145.16,74.65 144.71,74.65 143.29,76.07 132.6,76.07
  vias: v1(131.12,75.03) v1(154.33,70.64) v1(154.33,66.09)
DDR1_CA1: length 34.9
  L3-SIGNAL1 w0.076: v3(154.33,70) 154.33,69.48 154.14,69.28 153.55,69.28 153.27,69 153.27,68.64 v5(153.54,68.37) 153.27,68.1 153.27,67.66 153.5,67.43 154.11,67.43 154.33,67.21 v3(154.33,66.75)
  L3-SIGNAL1 w0.132: v5(132.28,74.39) v3(131.92,74.23)
  L4-GND2 w0.146: v5(153.54,68.37) v7(153.92,68.8)
  L4-GND2 w0.185: v7(132.69,74.24) v5(132.28,74.39)
  L7-SIGNAL3 w0.185: 153.71,68.02 153.95,68.29 v7(153.92,68.8)
  L7-SIGNAL3 w0.191: 153.71,68.02 152.04,68.02 151.75,68.31 151.75,69.95 151.42,70.28 151.42,71.14 151.11,71.45 151.11,72.33 149.91,73.53 149.41,73.53 148.83,72.95 146.92,72.95 146.13,73.74 144.81,73.74 142.96,75.59 133.46,75.59 133.08,75.21 133.08,74.62 v7(132.69,74.24)
  vias: v1(131.92,74.23) v1(154.33,69.99) v1(154.33,66.74)
DDR1_CA2: length 34.8
  L3-SIGNAL1 w0.076: v3(148.73,66.1) 148.37,66.46 148.37,67.71 148.62,67.96 v5(148.62,68.37) 148.62,68.78 148.37,69.03 148.37,70.28 v3(148.73,70.65)
  L3-SIGNAL1 w0.127: v5(133.07,73.3) v3(132.72,73.43)
  L4-GND2 w0.146: v5(148.62,68.37) v7(149,68.8)
  L4-GND2 w0.185: v7(133.48,73.14) v5(133.07,73.3)
  L7-SIGNAL3 w0.185: 135.16,73.01 135.02,73.14 134.7,73.14 134.25,72.7 133.93,72.7 v7(133.48,73.14)
  L7-SIGNAL3 w0.191: v7(149,68.8) 149,69.2 149.2,69.39 149.65,69.39 149.87,69.61 149.87,70.22 149.58,70.51 147.35,70.51 146.8,71.07 144.36,71.07 142.81,72.62 142.6,72.62 142.11,72.12 140.51,72.12 140.32,72.31 140.32,73.23 140.51,73.42 140.88,73.42 141.53,72.78 141.9,72.78 142.17,73.05 142.17,73.25 141.33,74.09 139.82,74.09 139.63,73.9 139.63,72.2 139.44,72.01 135.57,72.01 135.16,72.42 135.16,73.01
  vias: v1(132.72,73.43) v1(148.73,70.64) v1(148.73,66.09)
DDR1_CA3: length 34.8
  L3-SIGNAL1 w0.076: v3(147.93,66.1) 147.93,66.4 147.76,66.57 147.76,66.97 148.04,67.25 148.04,67.91 147.89,68.07 v5(147.89,68.37) 147.89,68.67 148.09,68.87 148.09,69.54 147.81,69.82 147.81,70.22 147.93,70.34 v3(147.93,70.65)
  L3-SIGNAL1 w0.127: v5(132.28,75.15) v3(131.92,75.03)
  L4-GND2 w0.146: v5(147.89,68.37) v7(148.27,68.8)
  L4-GND2 w0.185: v7(132.6,74.88) v5(132.28,75.15)
  L7-SIGNAL3 w0.191: v7(148.27,68.8) 148.82,68.25 149.26,68.25 149.92,67.59 149.92,67.28 149.49,66.86 145.78,66.86 145.34,66.42 143.82,66.42 139.99,70.26 133.26,70.26 131.55,71.96 131.55,72.31 130.67,73.19 130.67,74.37 130.96,74.65 132.37,74.65 v7(132.6,74.88)
  vias: v1(131.92,75.03) v1(147.93,70.64) v1(147.93,66.09)
DDR1_CA4: length 34.8
  L3-SIGNAL1 w0.076: v3(147.13,66.1) 147.43,66.39 147.43,68.07 v5(147.13,68.37) 147.43,68.67 147.43,70.35 v3(147.13,70.65)
  L3-SIGNAL1 w0.132: v5(132.27,73.53) v3(131.92,73.43)
  L4-GND2 w0.146: v5(147.13,68.37) v7(147.51,68.8)
  L4-GND2 w0.185: v7(132.01,73.36) v5(132.27,73.53)
  L7-SIGNAL3 w0.185: 132.42,73.36 v7(132.01,73.36) ; 148.45,70 148.64,69.82 148.64,69.53 148.45,69.34 147.73,69.34 147.51,69.11 v7(147.51,68.8)
  L7-SIGNAL3 w0.191: 148.45,70 147.39,70 147.2,69.81 147.2,69.52 146.92,69.24 145.71,69.24 145.5,69.03 145.5,68.56 145.32,68.38 144.93,68.38 144.81,68.5 144.81,69 144.62,69.19 144.29,69.19 144.11,69.36 144.11,69.73 144.31,69.93 145.37,69.93 145.51,70.07 145.51,70.4 145.32,70.6 144.07,70.6 143.42,71.24 143.17,71.24 142.98,71.06 142.98,70.6 142.79,70.41 142.52,70.41 142.37,70.55 142.37,71.33 142.23,71.48 141.98,71.48 141.79,71.29 141.79,70.55 141.65,70.41 141.42,70.41 141.23,70.6 141.23,71.23 141.06,71.4 134.12,71.4 133.18,72.34 133.18,72.59 132.42,73.36
  vias: v1(131.92,73.43) v1(147.13,70.64) v1(147.13,66.09)
DDR1_CA5: length 34.8
  L3-SIGNAL1 w0.076: v3(147.13,66.75) 146.72,67.16 146.39,67.16 145.92,67.63 145.92,67.88 v5(146.41,68.37) 146.06,68.73 146.06,68.95 146.34,69.23 146.87,69.23 147.13,69.49 v3(147.13,70)
  L3-SIGNAL1 w0.127: v5(130.79,74.19) v3(131.12,74.23)
  L4-GND2 w0.146: v5(146.41,68.37) v7(146.03,68.8)
  L4-GND2 w0.185: v7(131.19,74.06) v5(130.79,74.19)
  L7-SIGNAL3 w0.191: v7(146.03,68.8) 146.03,68.35 146.24,68.15 148.14,68.15 148.29,68 148.29,67.58 148.1,67.39 146.24,67.39 145.88,67.74 145.55,67.74 145.29,67.48 145.29,67.13 145.05,66.89 144.14,66.89 142.6,68.43 142.6,68.63 142.77,68.8 143.07,68.8 143.52,68.35 143.72,68.35 143.87,68.5 143.87,68.87 142.92,69.82 142.65,69.82 142.01,69.18 141.8,69.18 140.19,70.79 133.57,70.79 131.55,72.8 131.55,73.69 v7(131.19,74.06)
  vias: v1(131.12,74.23) v1(147.13,69.99) v1(147.13,66.74)
DDR1_CAL0: length 45.5
  L3-SIGNAL1 w0.089: v3(127.92,72.63) v5(128.17,72.38)
  L4-GND2 w0.102: v5(128.17,72.38) v7(128.48,72.07)
  L10-SIGNAL4 w0.109: v2(164.79,78.84) 164.17,78.21 163.03,78.21 162.06,77.24 154.9,77.24 154.69,77.45 127.36,77.45 127.11,77.19 127.11,72.9 127.39,72.62 128.28,72.62 128.48,72.42 v7(128.48,72.07)
  vias: v1(127.92,72.63)
DDR1_CK_C: length 34.7
  L3-SIGNAL1 w0.076: v3(148.73,66.75) 149.11,66.75 150.16,67.8 150.16,68.16 v5(149.94,68.37) 150.17,68.6 150.17,68.9 149.08,70 v3(148.73,70)
  L3-SIGNAL1 w0.14: v5(133.83,74.44) v3(133.52,74.23)
  L4-GND2 w0.146: v5(149.94,68.37) v7(150.31,68.8)
  L4-GND2 w0.185: v7(134.23,74.52) v5(133.83,74.44)
  L7-SIGNAL3 w0.178: v7(150.31,68.8) 150.5,68.99 150.5,71.09 150.06,71.53 144.68,71.53 141.54,74.68 139.28,74.68 139.05,74.45 139.05,72.98 138.68,72.61 138.02,72.61 137.65,72.98 137.65,74.52 137.47,74.7 137.14,74.7 136.97,74.52 136.97,73.02 136.59,72.64 136.04,72.64 135.67,73.02 135.67,74.45 135.49,74.63 135,74.63 134.82,74.45 134.82,73.93 134.64,73.75 134.39,73.75 134.23,73.91 v7(134.23,74.52)
  vias: v1(133.52,74.23) v1(148.73,69.99) v1(148.73,66.74)
DDR1_CK_T: length 34.7
  L3-SIGNAL1 w0.076: v3(149.53,66.75) 150.02,66.75 150.81,67.53 150.81,68.16 v5(150.59,68.37) 150.83,68.61 150.83,69.13 149.97,70 v3(149.53,70)
  L3-SIGNAL1 w0.14: v3(132.72,75.03) v1(132.72,75.03) v5(133.1,75)
  L4-GND2 w0.146: v5(150.59,68.37) v7(150.98,68.8)
  L4-GND2 w0.185: v7(133.5,74.84) v5(133.1,75)
  L7-SIGNAL3 w0.178: v7(133.5,74.84) 133.61,74.96 135.63,74.96 136,74.58 136,73.15 136.18,72.97 136.46,72.97 136.63,73.15 136.63,74.66 137.01,75.03 137.61,75.03 137.98,74.66 137.98,73.11 138.16,72.94 138.54,72.94 138.72,73.11 138.72,74.58 139.14,75.01 141.67,75.01 144.82,71.86 150.2,71.86 150.83,71.22 150.83,68.94 v7(150.98,68.8)
  vias: v1(149.53,69.99) v1(149.53,66.74)
DDR1_CKE0: length 35.1
  L3-SIGNAL1 w0.127: v5(129.07,71.68) v3(128.72,71.83)
  L3-SIGNAL1 w0.14: v3(152.73,70) 152.73,69.48 152.53,69.28 152.33,69.28 152.19,69.14 152.19,68.97 152.31,68.85 152.71,68.85 152.86,68.71 152.86,68.5 v5(152.73,68.37) 152.86,68.24 152.86,68.03 152.71,67.89 152.31,67.89 152.19,67.77 152.19,67.6 152.33,67.46 152.53,67.46 152.73,67.26 v3(152.73,66.75)
  L4-GND2 w0.146: v5(152.73,68.37) v7(153.11,68.8) ; v7(129.47,71.68) v5(129.07,71.68)
  L12-SIGNAL5 w0.152: v7(129.47,71.68) 129.85,71.3 129.85,70.36 131.02,69.19 141.61,69.19 141.74,69.06 141.74,68.57 141.89,68.42 142.14,68.42 142.27,68.56 142.27,69.04 142.43,69.19 142.67,69.19 142.81,69.06 142.81,68.63 142.96,68.48 143.24,68.48 143.37,68.61 143.37,69.06 143.51,69.19 144.46,69.19 146.01,67.64 151.95,67.64 v7(153.11,68.8)
  vias: v1(128.72,71.83) v1(152.73,69.99) v1(152.73,66.74)
DDR1_CKE1: length 35.1
  L3-SIGNAL1 w0.127: v5(129.81,74.47) v3(129.52,74.23)
  L3-SIGNAL1 w0.14: v3(151.93,66.75) 151.39,66.75 151.24,66.9 151.24,67.67 v5(151.94,68.37) 151.24,69.07 151.24,69.85 151.39,70 v3(151.93,70)
  L4-GND2 w0.146: v5(151.94,68.37) v7(152.32,68.8) ; v7(130.18,74.17) v5(129.81,74.47)
  L12-SIGNAL5 w0.152: v7(152.32,68.8) 151.67,68.15 146.12,68.15 145.52,68.74 145.52,70.51 145.27,70.76 144.19,70.76 143.96,70.53 143.96,69.98 143.82,69.85 143.47,69.85 143.32,70 143.32,70.49 143.14,70.66 142.83,70.66 142.65,70.49 142.65,70.01 142.52,69.88 133.87,69.88 130.64,73.1 130.64,73.71 v7(130.18,74.17)
  vias: v1(129.52,74.23) v1(151.93,69.99) v1(151.93,66.74)
DDR1_CSN0_0: length 32.3
  TOP w0.33: v1(152.33,65.77) v7(152.33,65.77) U71.H4
  L3-SIGNAL1 w0.127: v5(129.81,73.67) v3(129.52,73.43)
  L3-SIGNAL1 w0.129: v5(152.74,66.09) v7(152.33,65.77)
  L4-GND2 w0.146: v7(152.33,65.77) v5(152.74,66.09) ; v7(130.16,73.43) v5(129.81,73.67)
  L7-SIGNAL3 w0.14: v7(130.16,73.43) 130.39,73.2 130.39,73.1 131.09,72.4 131.09,71.69 133.03,69.75 139.66,69.75 143.44,65.96 147.68,65.96 148.04,66.32 150.58,66.32 150.71,66.45 150.71,66.76 150.85,66.9 151.12,66.9 151.25,66.77 151.25,66.49 151.42,66.32 151.62,66.32 151.9,66.6 151.9,67.38 152.04,67.52 152.59,67.52 152.74,67.37 152.74,66.2 152.69,66.15
  L7-SIGNAL3 w0.146: v7(152.33,65.77) 152.69,66.15
  vias: v1(129.52,73.43)
DDR1_CSN0_1: length 32.2
  TOP w0.33: U71.R4 153.13,70.97 v1(153.13,70.97)
  L3-SIGNAL1 w0.127: v5(129.09,73.53) v3(128.72,73.43)
  L3-SIGNAL1 w0.129: v3(153.13,70.97) v5(152.79,71.25)
  L4-GND2 w0.146: v7(153.17,70.97) v3(153.13,70.97) v5(152.79,71.25) ; v7(129.35,73.97) v5(129.09,73.53)
  L7-SIGNAL3 w0.14: 150.53,75.11 148.8,75.11 146.82,77.09 131.66,77.09 129.51,74.94 129.51,74.15 129.33,73.98 v7(129.35,73.97)
  L7-SIGNAL3 w0.146: 150.53,75.11 153.87,71.77 153.87,71.11 153.72,70.97 v7(153.17,70.97)
  vias: v1(128.72,73.43)
DDR1_CSN1_0: length 32.2
  TOP w0.33: U71.H3 v3(153.13,65.77) v1(153.13,65.77)
  L3-SIGNAL1 w0.127: v5(128.84,73.89) v3(128.72,74.23)
  L3-SIGNAL1 w0.129: v5(153.53,66.09) v3(153.13,65.77)
  L4-GND2 w0.146: v7(153.83,66.45) v5(153.53,66.09) ; v7(128.96,72.95) 128.74,73.18 128.74,73.79 v5(128.84,73.89)
  L7-SIGNAL3 w0.14: v7(153.83,66.45) 152.74,65.35 152.74,64.97 152.39,64.62 150.94,64.62 150.48,65.08 148.27,65.08 147.83,65.51 143.18,65.51 139.4,69.29 132.62,69.29 v7(128.96,72.95)
  vias: v1(128.72,74.23)
DDR1_CSN1_1: length 32.3
  TOP w0.33: U71.R3 153.93,70.97 v3(153.93,70.97) v1(153.93,70.97)
  L3-SIGNAL1 w0.127: v5(129.7,72.92) v3(129.52,72.63)
  L3-SIGNAL1 w0.129: v3(153.93,70.97) v5(153.65,70.74)
  L4-GND2 w0.146: v7(154.01,70.46) v5(153.65,70.74) ; v7(130.06,72.67) v5(129.7,72.92)
  L7-SIGNAL3 w0.14: 152.66,71.2 152.66,71.83 149.84,74.65 147.48,74.65 145.53,76.61 131.81,76.61 130.41,75.21 130.41,75.06 129.76,74.4 129.76,72.97 v7(130.06,72.67)
  L7-SIGNAL3 w0.146: 152.66,71.2 152.77,71.1 152.77,70.79 153.09,70.46 v7(154.01,70.46)
  vias: v1(129.52,72.63)
DDR1_DM0_DBI0#: length 33.2
  L3-SIGNAL1 w0.127: v5(132.28,68.75) v3(131.92,68.63)
  L3-SIGNAL1 w0.129: v3(153.53,62.84) 153.93,62.52 v5(153.93,62.52)
  L4-GND2 w0.146: v6(153.55,62.79) v5(153.93,62.52) ; v6(131.93,68.7) v5(132.28,68.75)
  L5-SIGNAL2 w0.152: v6(131.93,68.7) 134.12,68.7 134.35,68.94 137.49,68.94 137.83,68.61 138.04,68.61 138.38,68.94 138.59,68.94 138.75,68.79 138.75,68.57 138.39,68.21 138.39,68.02 138.52,67.89 138.71,67.89 138.98,68.15 139.19,68.15 139.35,68 139.35,67.79 139.09,67.53 139.09,67.34 139.22,67.2 139.42,67.2 139.68,67.46 139.89,67.46 140.03,67.31 140.03,67.1 139.78,66.85 139.78,66.63 139.93,66.48 140.15,66.48 140.58,66.92 140.8,66.92 140.95,66.76 140.95,66.47 140.56,66.08 140.56,65.86 140.71,65.71 141.43,65.71 143.75,63.4 144.36,63.4 144.53,63.22 144.53,62.23 144.69,62.08 144.9,62.08 145.05,62.23 145.05,62.56 145.21,62.71 145.42,62.71 145.57,62.56 145.57,62.23 145.73,62.08 147.91,62.08 148.12,62.28 150.07,62.28 150.5,61.85 150.88,61.85 151.09,62.05 152.18,62.05 152.33,62.2 152.33,62.36 152.48,62.52 153.28,62.52 v6(153.55,62.79)
  vias: v1(131.92,68.63) v1(153.53,62.84)
DDR1_DM1_DBI1#: length 24.9
  L3-SIGNAL1 w0.14: v3(147.91,62.87) 148.34,63.3 148.34,64.35 148.2,64.49 146.96,64.49 146.77,64.69 146.77,64.94 146.21,65.51 145.69,65.51 140.43,70.77 140.19,70.77 139.67,70.24 139.47,70.24 139.32,70.39 139.32,70.59 139.88,71.14 139.88,71.29 139.69,71.48 139.54,71.48 138.99,70.92 138.79,70.92 137.47,72.24 137.47,72.9 137.33,73.04 134.44,73.04 134.32,72.92 133.66,72.92 133.38,72.64 132.85,72.64 132.48,72.27 132.28,72.27 v3(131.92,72.63)
DDR1_DM2_DBI2#: length 30.6
  L3-SIGNAL1 w0.127: v5(132.37,76.56) v3(132.72,76.63)
  L3-SIGNAL1 w0.129: v6(153.53,73.9) 153.13,74.22 v5(153.13,74.22)
  L4-GND2 w0.146: v6(153.53,73.9) v5(153.13,74.22) ; v6(132.72,76.23) v5(132.37,76.56)
  L5-SIGNAL2 w0.152: v6(132.72,76.23) 133.33,76.83 134.32,76.83 134.47,76.69 140.25,76.69 140.25,76.69 145.16,76.69 145.4,76.45 145.7,76.45 145.83,76.32 145.83,75.51 145.98,75.36 146.18,75.36 146.31,75.5 146.31,76.3 146.46,76.45 146.82,76.45 146.96,76.32 146.96,76.05 147.09,75.92 147.28,75.92 147.41,76.05 147.41,76.32 147.55,76.45 148.4,76.45 148.55,76.3 148.55,75.31 149.06,74.8 149.44,74.8 149.69,75.06 149.69,75.37 149.46,75.59 149.46,76.28 149.64,76.45 150.27,76.45 150.43,76.3 150.43,75.24 150.6,75.06 151.8,75.06 151.95,74.91 151.95,74.45 152.18,74.22 153.21,74.22 v6(153.53,73.9)
  vias: v1(132.72,76.63) v1(153.53,73.89)
DDR1_DM3_DBI3#: length 23.8
  L3-SIGNAL1 w0.14: v3(132.72,79.03) 132.87,78.88 133.7,78.88 133.84,79.02 134.32,79.02 134.33,79.01 141.78,79.01 141.92,78.87 141.92,77.65 142.69,76.88 142.96,76.88 143.64,77.56 143.84,77.56 143.98,77.42 143.98,77.24 143.25,76.52 143.25,76.32 143.42,76.15 143.64,76.15 144.35,76.85 144.54,76.85 144.74,76.66 144.74,76.46 144.45,76.17 144.45,75.97 144.69,75.73 144.69,75.49 144.47,75.27 144.47,75.07 144.85,74.69 145.05,74.69 145.38,75.01 145.38,75.49 145.56,75.67 145.75,75.67 146.72,74.7 146.72,74.4 146.93,74.19 147.69,74.19 v3(147.94,73.94)
DDR1_DQ0: length 33.1
  L3-SIGNAL1 w0.127: v5(129.88,68.75) v3(129.52,68.63)
  L3-SIGNAL1 w0.129: v6(154.33,62.19) 154.73,61.87 v5(154.73,61.87)
  L4-GND2 w0.146: v6(129.53,68.7) v5(129.88,68.75) ; v6(154.33,62.19) v5(154.73,61.87)
  L5-SIGNAL2 w0.152: v6(154.33,62.19) 154.71,62.19 154.92,61.98 154.92,60.89 154.77,60.74 153.88,60.74 153.52,60.37 148.47,60.37 148.1,60.74 138.2,60.74 131.99,66.95 130.36,66.95 129.53,67.79 129.53,68.24 129.53,68.24 v6(129.53,68.7)
  vias: v1(129.52,68.63) v1(154.33,62.19)
DDR1_DQ1: length 33.1
  L3-SIGNAL1 w0.127: v5(129.7,69.9) v3(129.52,70.23)
  L3-SIGNAL1 w0.129: v5(154.73,62.52) 154.73,62.52 v6(154.33,62.84)
  L4-GND2 w0.146: v6(129.53,70.3) v5(129.7,69.9) ; v6(154.33,62.84) v5(154.73,62.52)
  L5-SIGNAL2 w0.152: v6(154.33,62.84) 153.93,62.36 153.63,61.14 153.29,60.8 148.78,60.8 148.5,61.09 147.53,61.09 147.43,61.19 143.37,61.19 142.48,62.08 142.17,62.08 142.04,62.21 142.04,62.52 141.91,62.66 141.59,62.66 141.46,62.79 141.46,63.1 139.46,65.1 134.86,65.1 132.14,67.82 130.56,67.82 129.95,68.43 129.95,68.91 129.53,69.34 v6(129.53,70.3)
  vias: v1(129.52,70.23) v1(154.33,62.84)
DDR1_DQ2: length 33.1
  L3-SIGNAL1 w0.127: v5(130.68,68.75) v3(130.32,68.63)
  L3-SIGNAL1 w0.129: v6(154.33,64.14) 154.64,64.49 v5(154.66,64.49)
  L4-GND2 w0.146: v6(130.33,68.7) v5(130.68,68.75) ; v6(154.33,64.14) v5(154.66,64.49)
  L5-SIGNAL2 w0.152: v6(154.33,64.14) 154.72,64.53 154.72,64.97 153.83,65.86 153.63,65.86 153.22,66.27 153.22,66.47 153.04,66.65 152.2,66.65 151.94,66.91 151.94,67.22 150.81,68.35 145.86,68.35 145.16,69.05 145.16,69.18 144.28,70.05 142.86,70.05 141,71.91 131.83,71.91 130.71,70.78 130.38,70.78 130,70.4 130,69.3 130.33,68.97 v6(130.33,68.7)
  vias: v1(130.32,68.63) v1(154.33,64.14)
DDR1_DQ3: length 33.1
  L3-SIGNAL1 w0.127: v5(131.48,70.35) v3(131.12,70.23)
  L3-SIGNAL1 w0.129: v6(154.33,64.79) 154.64,65.13 v5(154.66,65.14)
  L4-GND2 w0.146: v6(131.13,70.3) v5(131.48,70.35) ; v6(154.33,64.79) v5(154.66,65.14)
  L5-SIGNAL2 w0.152: v6(131.13,70.3) 131.13,70.72 131.89,71.48 140.8,71.48 142.73,69.55 144.18,69.55 144.72,69 144.72,68.54 144.94,68.33 145.25,68.33 145.66,67.92 149.96,67.92 150.12,67.76 150.12,67.57 149.98,67.44 149.13,67.44 148.95,67.26 148.95,66.8 149.13,66.62 150.33,66.62 150.6,66.9 150.6,67.51 150.74,67.65 150.93,67.65 151.54,67.03 151.54,66.35 151.7,66.19 152.51,66.19 152.81,65.89 152.81,65.68 152.99,65.51 153.29,65.51 153.78,65.02 154.1,65.02 v6(154.33,64.79)
  vias: v1(131.12,70.23) v1(154.33,64.79)
DDR1_DQ4: length 33.1
  L3-SIGNAL1 w0.127: v5(131.48,69.55) v3(131.12,69.43)
  L3-SIGNAL1 w0.129: v5(153.13,64.47) 153.13,64.47 v6(152.73,64.79)
  L4-GND2 w0.146: v6(131.13,69.5) v5(131.48,69.55) ; v6(152.73,64.79) v5(153.13,64.47)
  L5-SIGNAL2 w0.152: v6(152.73,64.79) 152.67,64.73 151.24,64.73 151.09,64.88 151.09,66.23 150.94,66.38 150.72,66.38 150.53,66.19 148.65,66.19 148.47,66.37 148.47,67.32 148.32,67.48 148.04,67.48 147.89,67.32 147.89,65.72 147.7,65.53 147.51,65.53 147.33,65.71 147.33,67.29 147.18,67.44 146.3,67.44 146.16,67.3 146.16,67.01 146.01,66.86 145.55,66.86 145.32,67.09 145.32,67.28 145.12,67.49 144.81,67.49 144.65,67.64 144.65,67.95 144.43,68.17 144.2,68.17 143.89,68.48 143.89,68.77 143.59,69.06 142.6,69.06 140.62,71.04 132.44,71.04 132.04,70.64 131.64,70.64 131.5,70.51 131.5,69.88 v6(131.13,69.5)
  vias: v1(131.12,69.43) v1(152.73,64.79)
DDR1_DQ5: length 33.1
  L3-SIGNAL1 w0.127: v5(133.08,69.55) v3(132.72,69.43)
  L3-SIGNAL1 w0.129: v5(153.13,63.82) 153.13,63.82 v6(152.73,64.14)
  L4-GND2 w0.146: v6(152.73,64.14) v5(153.13,63.82) ; v6(132.73,69.5) v5(133.08,69.55)
  L5-SIGNAL2 w0.152: v6(152.73,64.14) 152.59,64.29 150.83,64.29 150.68,64.44 150.68,65.25 150.52,65.41 150.27,65.41 150.12,65.26 150.12,64.97 150.01,64.86 149.73,64.86 149.61,64.97 149.61,65.15 149.45,65.31 149.23,65.31 149.08,65.16 149.08,64.02 148.93,63.87 148.71,63.87 148.56,64.02 148.56,65.16 148.41,65.31 148.19,65.31 148.04,65.16 148.04,64.49 147.89,64.34 147.05,64.34 146.9,64.49 146.9,65.86 146.75,66.02 146.53,66.02 146.38,65.86 146.38,65.16 146.23,65.01 145.95,65.01 145.45,65.51 145.45,66.24 143.45,68.23 143.45,68.42 143.24,68.63 142.42,68.63 140.44,70.61 134.5,70.61 134.42,70.69 132.88,70.69 132.73,70.54 v6(132.73,69.5)
  vias: v1(132.72,69.43) v1(152.73,64.14)
DDR1_DQ6: length 33.1
  L3-SIGNAL1 w0.127: v5(132.28,70.35) v3(131.92,70.23)
  L3-SIGNAL1 w0.129: v3(152.73,62.84) 152.41,62.48 v5(152.41,62.5)
  L4-GND2 w0.146: v6(152.69,62.87) v5(152.41,62.5) ; v6(131.93,70.3) v5(132.28,70.35)
  L5-SIGNAL2 w0.152: v6(131.93,70.3) 132.32,69.91 132.32,69.34 132.51,69.15 133.8,69.15 134.03,69.37 139.99,69.37 140.13,69.24 140.13,69.05 139.68,68.61 139.68,68.35 140.58,67.46 140.79,67.46 140.94,67.61 140.94,67.82 140.41,68.35 140.41,68.54 140.55,68.67 140.74,68.67 141.65,67.76 141.65,67.55 141.38,67.29 141.38,66.37 143.87,63.88 144.76,63.88 145.02,63.63 145.02,63.32 145.17,63.17 145.82,63.17 145.97,63.02 145.97,62.69 146.15,62.51 146.36,62.51 146.52,62.66 146.52,63.02 146.67,63.17 146.88,63.17 147.04,63.02 147.04,62.64 147.19,62.48 147.4,62.48 147.56,62.64 147.56,62.95 147.71,63.11 147.95,63.11 148.4,62.66 151.01,62.66 151.47,63.12 151.77,63.12 152.03,62.87 v6(152.69,62.87)
  vias: v1(131.92,70.23) v1(152.73,62.84)
DDR1_DQ7: length 33.1
  L3-SIGNAL1 w0.127: v5(130.68,69.55) v3(130.32,69.43)
  L3-SIGNAL1 w0.129: v5(152.41,61.85) 152.41,61.85 v6(152.73,62.19)
  L4-GND2 w0.146: v6(130.33,69.5) v5(130.68,69.55) ; v6(152.73,62.19) v5(152.41,61.85)
  L5-SIGNAL2 w0.152: v6(152.73,62.19) 152.73,61.77 152.58,61.62 151.3,61.62 151.14,61.47 151.14,61.25 151.04,61.14 150.76,61.14 150.45,61.44 150.25,61.44 149.94,61.14 149.64,61.14 149.52,61.26 149.52,61.68 149.37,61.83 148.99,61.83 148.6,61.44 147.96,61.44 147.76,61.65 144.23,61.65 144.08,61.8 144.08,62.74 143.88,62.94 143.67,62.94 143.36,62.63 143.17,62.63 143.04,62.77 143.04,62.95 143.2,63.12 143.2,63.33 143.05,63.49 142.83,63.49 142.67,63.32 142.48,63.32 142.35,63.46 142.35,63.65 142.51,63.81 142.51,64 142.38,64.13 142.19,64.13 142.02,63.97 141.83,63.97 141.7,64.1 141.7,64.29 141.86,64.46 141.86,64.65 141.73,64.78 141.54,64.78 141.38,64.62 141.19,64.62 141.05,64.75 141.05,65.13 140.9,65.28 140.5,65.28 137.27,68.51 134.76,68.51 134.09,67.84 132.96,67.84 132.5,68.3 131.55,68.3 131.4,68.45 131.4,68.92 131.25,69.07 130.75,69.07 v6(130.33,69.5)
  vias: v1(130.32,69.43) v1(152.73,62.19)
DDR1_DQ8: length 24.8
  L3-SIGNAL1 w0.14: v3(130.32,71.83) 130.72,71.43 130.72,70.08 130.9,69.9 133.61,69.9 133.84,69.67 134.05,69.67 134.3,69.41 134.3,68.12 134.43,68 137.08,68 143.45,61.62 145.83,61.62 146.05,61.84 146.25,61.84 146.56,61.52 147.8,61.52 147.94,61.66 147.94,61.86 147.8,62 147.28,62 v3(147.1,62.18)
DDR1_DQ9: length 24.9
  L3-SIGNAL1 w0.14: v3(147.13,62.84) 146.77,62.84 146.54,62.61 145.56,62.61 145.46,62.51 143.75,62.51 141.26,65 141.26,65.65 141.07,65.84 140.88,65.84 140.74,65.7 140.56,65.7 140.43,65.83 140.43,66.01 140.57,66.15 140.57,66.34 140.44,66.47 140.26,66.47 140.12,66.33 139.93,66.33 139.8,66.46 139.8,66.64 139.94,66.78 139.94,66.96 139.81,67.09 139.63,67.09 139.49,66.95 139.3,66.95 139.17,67.08 139.17,67.27 139.31,67.41 139.31,67.59 139.18,67.72 139,67.72 138.86,67.58 138.67,67.58 138.54,67.71 138.54,67.9 138.68,68.04 138.68,68.22 138.55,68.35 138.37,68.35 138.23,68.21 138.05,68.21 137.92,68.34 137.92,68.53 138.06,68.67 138.06,68.85 136.7,70.2 136.52,70.2 136.39,70.07 136.39,69.89 136.96,69.32 136.96,69.13 136.83,69 136.65,69 135.76,69.89 135.76,70.24 136.09,70.58 136.09,70.76 135.96,70.89 133.49,70.89 133.33,71.04 v3(132.73,71.04)
DDR1_DQ10: length 24.9
  L2-GND1 w0.146: v1(132.72,71.83) v3(132.75,71.83)
  L3-SIGNAL1 w0.14: v3(147.13,64.11) 146.96,64.11 146.39,64.69 146.39,64.9 146.2,65.08 146,65.08 145.79,64.87 145.59,64.87 145.45,65.01 145.45,65.15 141.12,69.47 140.89,69.47 140.75,69.33 140.75,69.13 141.95,67.94 141.95,67.75 141.81,67.61 141.61,67.61 140.11,69.1 140.11,69.3 140.55,69.74 140.55,69.94 140.41,70.08 140.22,70.08 139.72,69.58 139.52,69.58 137.01,72.1 137.01,72.45 136.86,72.59 134.21,72.59 134.13,72.68 133.86,72.68 133.64,72.46 133.64,71.97 133.5,71.83 v3(132.75,71.83)
DDR1_DQ11: length 24.9
  L3-SIGNAL1 w0.14: v3(147.1,64.82) 147.1,65.05 146.21,65.94 145.86,65.94 138.95,72.84 138.72,72.84 138.58,72.7 138.58,72.5 139.17,71.92 139.17,71.72 139.03,71.59 138.85,71.59 137.96,72.47 137.96,72.67 138.39,73.1 138.39,73.3 138.22,73.47 135.96,73.47 135.3,73.47 134.51,73.47 134.47,73.51 134.3,73.51 133.95,73.16 133.56,73.16 133.55,73.16 133.46,73.16 133.28,72.97 132.94,72.97 132.83,73.08 131.67,73.08 131.53,72.94 131.53,72.35 131.39,72.21 131.01,72.21 130.9,72.32 130.9,72.47 131.06,72.63 v3(131.12,72.63)
DDR1_DQ12: length 24.9
  L3-SIGNAL1 w0.14: v3(148.75,64.8) 147.58,65.61 146.99,65.61 146.32,66.28 146.32,66.58 146.09,66.81 145.59,66.81 138.52,73.88 131.73,73.89 130.67,73.08 130.31,73.07 129.95,72.71 129.95,71.73 v3(129.52,71.03)
DDR1_DQ13: length 24.8
  L3-SIGNAL1 w0.14: v3(131.12,71.83) 131.45,71.5 132.06,71.5 132.06,71.5 133.51,71.5 133.69,71.32 133.76,71.32 133.86,71.22 134.13,71.22 134.23,71.32 136.18,71.32 141.26,66.24 142.04,66.24 142.23,66.04 142.23,65.85 141.72,65.33 141.72,65.13 143.92,62.93 145.28,62.93 145.4,63.04 146.52,63.04 146.69,63.22 147.35,63.22 147.53,63.04 147.53,62.78 147.78,62.54 148.05,62.54 148.24,62.73 148.24,62.81 148.57,63.14 148.84,63.14 149.06,63.36 149.06,63.82 v3(148.73,64.14)
DDR1_DQ14: length 24.8
  L3-SIGNAL1 w0.14: v3(131.92,71.03) 132.27,70.68 132.42,70.68 132.42,70.67 133.23,70.67 133.35,70.55 133.65,70.55 133.78,70.43 135.12,70.43 135.28,70.27 135.28,70.07 135.15,69.94 134.88,69.94 134.75,69.81 134.75,68.56 134.89,68.42 135.16,68.42 135.29,68.55 135.29,69.06 135.42,69.19 135.6,69.19 135.73,69.06 135.73,68.55 135.86,68.42 136.84,68.42 137.15,68.73 137.36,68.73 137.5,68.59 137.5,68.17 140.39,65.28 140.7,65.28 140.84,65.14 140.84,64.83 143.57,62.09 145.69,62.09 145.89,62.29 146.75,62.29 146.96,62.51 147.24,62.51 147.44,62.3 148.23,62.3 v3(148.75,62.81)
DDR1_DQ15: length 24.9
  L3-SIGNAL1 w0.14: v3(130.32,71.03) 130.09,71.03 129.88,70.82 129.88,70.59 129.88,70.59 129.88,70.31 130.03,70 130.03,69.77 129.95,69.6 129.95,69.33 130.2,69.09 130.92,69.09 135.67,64.34 140.14,64.34 143.29,61.19 148.2,61.19 148.76,61.74 v3(148.76,62.17)
DDR1_DQ16: length 30.6
  L3-SIGNAL1 w0.129: v5(154.01,74.2) 154.01,74.19 v6(154.33,74.54)
  L3-SIGNAL1 w0.132: v5(132.27,77.57) v3(131.92,77.43)
  L4-GND2 w0.146: v6(131.95,77.46) v5(132.27,77.57) ; v6(154.33,74.54) v5(154.01,74.2)
  L5-SIGNAL2 w0.152: v6(131.95,77.46) 131.95,77.74 132.2,77.98 145.85,77.98 146.08,77.75 154.59,77.75 154.91,77.43 154.91,76.18 154.76,76.03 154.55,76.03 154.39,75.87 154.39,75.46 154.54,75.31 155.46,75.31 155.61,75.16 155.61,74.78 155.46,74.63 154.41,74.63 v6(154.33,74.54)
  vias: v1(131.92,77.43) v1(154.33,74.54)
DDR1_DQ17: length 30.6
  L3-SIGNAL1 w0.127: v5(130.78,75.81) v3(131.12,75.83)
  L3-SIGNAL1 w0.129: v6(154.33,73.89) 154.01,73.56 v5(154.01,73.55)
  L4-GND2 w0.146: v6(131.14,75.86) v5(130.78,75.81) ; v6(154.33,73.89) v5(154.01,73.55)
  L5-SIGNAL2 w0.152: v6(131.14,75.86) 132.14,74.86 132.14,74.22 132.51,73.85 134.49,73.85 134.73,73.61 136.51,73.61 136.53,73.58 136.79,73.33 141.55,73.33 141.7,73.48 141.7,73.74 141.85,73.89 143.14,73.89 143.29,73.74 143.29,73.1 144.51,71.88 145.98,71.88 146.37,72.27 147.8,72.27 148.76,72.27 149.4,71.63 150.02,71.63 150.66,72.27 154.46,72.27 154.8,72.6 154.8,73.43 v6(154.33,73.89)
  vias: v1(131.12,75.83) v1(154.33,73.89)
DDR1_DQ18: length 30.6
  L3-SIGNAL1 w0.127: v5(133.07,77.3) v3(132.72,77.43)
  L3-SIGNAL1 w0.129: v5(154.73,72.27) 154.73,72.27 v6(154.33,72.59)
  L4-GND2 w0.146: v6(154.33,72.59) v5(154.73,72.27) ; v6(132.7,77.29) v5(133.07,77.3)
  L5-SIGNAL2 w0.152: v6(132.7,77.29) 132.96,77.55 134.5,77.55 145.65,77.55 145.86,77.34 145.88,77.34 145.9,77.32 152.83,77.32 152.97,77.18 152.97,76.64 153.1,76.51 153.29,76.51 153.48,76.69 153.48,77.16 153.61,77.29 153.84,77.29 153.99,77.14 153.99,76.16 153.74,75.91 153.32,75.91 153.16,75.76 153.16,75.51 152.92,75.26 152.92,74.96 153.25,74.63 153.6,74.63 153.93,74.3 153.93,73.51 154.33,73.11 v6(154.33,72.59)
  vias: v1(132.72,77.43) v1(154.33,72.59)
