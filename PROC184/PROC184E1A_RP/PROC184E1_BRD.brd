# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EXP_RSTZ: length 4.9
  TOP w0.127: TP48.1 v2(41.55,119.51) 42.15,119.51 42.44,119.22 U39.4
  BOTTOM w0.127: J54.118 v2(41.55,119.51)
EXT_I2C_SCL: length 5.2
  BOTTOM w0.127: J37.1 230.43,14.54 230.07,14.91 R1277.1 U268.2
EXT_I2C_SDA: length 5.5
  BOTTOM w0.127: J37.3 226.43,14.47 226.87,14.91 R1278.1 U268.5
EXT_MIPI_EMU0: length 34.7
  TOP w0.127: U47.11 v2(29.17,102.88)
  L5-SIGNAL2 w0.102: v2(6.95,92.13) 8.24,93.42 8.24,102.67 9.3,103.73 13.24,103.73 14.82,102.16 25.59,102.16 26.31,102.88 v2(29.17,102.88)
EXT_MIPI_EMU1: length 34.8
  TOP w0.127: U47.14 v2(29.17,104.83)
  L5-SIGNAL2 w0.102: v2(29.17,104.83) 27.72,103.38 25.89,103.38 24.95,102.44 15.05,102.44 13.42,104.06 8.95,104.06 7.96,103.07 7.96,95 6.95,93.99 v2(6.95,93.28)
EXT_MIPI_TCK: length 27.2
  TOP w0.127: R375.1 R381.2 v2(23.61,81.92) ; U47.2 v2(23.57,105.48)
  L14-SIGNAL6 w0.089: v2(23.57,105.48) 23.57,104.99 24.05,104.51 24.05,82.36 v2(23.61,81.92)
EXT_MIPI_TDI: length 24
  L14-SIGNAL6 w0.089: v2(20.52,104.18) 20.52,102.15 21.02,101.65 21.02,98.93 21.89,98.06 21.89,84.76 20.66,83.53 v2(20.66,83.07)
  BOTTOM w0.127: v2(20.52,104.18) U206.5
EXT_MIPI_TDO: length 28.8
  L14-SIGNAL6 w0.089: v2(6.95,81.35) 19.01,93.42 v2(19.01,101.61)
  BOTTOM w0.127: v2(19.01,101.61) 19.97,101.61 20.58,102.23 U206.2
EXT_MIPI_TMS: length 42.2
  TOP w0.127: R394.2 6.96,80.2 v2(6.95,80.21)
  L14-SIGNAL6 w0.089: v2(6.95,80.21) 6.52,80.63 6.52,81.53 7.02,82.02 7.08,82.02 18.47,93.42 18.47,104.62 19.76,105.9 24.76,105.9 25.08,105.58 25.08,104.64 v2(25.53,104.18)
  BOTTOM w0.127: U206.11 26.18,104.83 v2(25.53,104.18)
EXT_MIPI_TRST#: length 37.8
  TOP w0.127: U47.5 21.04,103.53 20.86,103.7 19.76,103.7 v2(18.98,102.92)
  L3-SIGNAL1 w0.089: v2(20.66,84.21) 20.09,83.64 v2(6.95,83.64)
  L14-SIGNAL6 w0.089: v2(18.98,102.92) 20.78,101.12 20.78,98.88 21.57,98.09 21.57,85.12 v2(20.66,84.21)
FB_LM5141: length 3.8
  TOP w0.254: U81.19 204.42,58.94 204.05,59.32 204.05,60.13 R466.1 R465.2
FB_MCU_V2V5: length 2.9
  TOP w0.254: U138.8 113.94,23.07 R641.1 112.84,23.67 112.67,23.83 R643.2
FB_V1V0: length 2.9
  TOP w0.254: R611.2 112.69,31.27 112.86,31.11 R607.1 113.94,30.51 U125.8
FB_V1V1: length 2.9
  BOTTOM w0.254: R1265.2 60.77,18.08 60.6,18.24 R1264.1 60,19.35 U266.8
FB_V1V2: length 2.9
  BOTTOM w0.254: U186.8 89.66,129.19 R865.1 91.19,129.79 R866.2
FB_V2V5: length 2.9
  BOTTOM w0.254: U260.8 85.3,25.66 85.9,25.07 R1244.1 85.9,24.16 86.06,24 R1248.2
FB_V3V3_DP0: length 2.9
  BOTTOM w0.127: U174.8 129.35,167.55 R793.1 R791.2
FB_V3V3_DP1: length 2.9
  BOTTOM w0.254: U169.8 106.87,172.91 106.27,173.5 R769.1 106.27,174.4 106.1,174.57 R766.2
FT2232_EECLK: length 21.7
  TOP w0.127: U147.2 v2(177.1,10.38) ; v2(185.81,16.43) 184.59,16.43 U144.62
  L3-SIGNAL1 w0.089: v2(177.1,10.38) 176.51,9.79 176.51,8.52 TP329.1
  BOTTOM w0.127: v2(177.1,10.38) 177.1,15.53 179.51,17.94 184.3,17.94 v2(185.81,16.43)
FT2232_EECS: length 28.7
  TOP w0.127: U144.63 185.76,15.93 185.89,15.8 v2(185.89,15.44) ; U147.1 R670.1
  L3-SIGNAL1 w0.089: v2(175.87,10.41) 174.61,9.15 174.61,6.29 TP330.1
  BOTTOM w0.127: v2(185.89,15.44) 186.29,15.84 186.29,16.85 184.82,18.32 178.37,18.32 175.87,15.82 v2(175.87,10.41)
FT2232_EEDIN: length 19.7
  TOP w0.127: U144.61 184.59,16.93 183.42,16.93 183.29,16.8 v2(183.29,16.44) ; U147.3 v2(178.37,10.38)
  L3-SIGNAL1 w0.089: TP327.1 179.61,6.54 179.61,8.26 179.05,8.81 179.05,9.7 v2(178.37,10.38)
  BOTTOM w0.127: v2(178.37,10.38) 178.37,14.67 180.15,16.44 v2(183.29,16.44)
FT2232_EEDOUT: length 5.6
  TOP w0.127: v2(178.36,9.54) R668.1 178.79,9.54 178.98,9.72 178.98,10.2 179.15,10.38 R667.1 U147.4
  L3-SIGNAL1 w0.089: v2(178.36,9.54) 178.25,9.43 TP328.1
FT2232_NR: length 2.2
  BOTTOM w0.127: C1251.1 196.83,9.33 197.1,9.06 U276.4
FT2232_PWREN#: length 20.7
  TOP w0.127: v2(183.24,17.43) 184.59,17.43 U144.60
  L5-SIGNAL2 w0.102: v2(196.6,6.96) 196.19,7.37 193.2,7.37 192.87,7.7 190.13,7.7 184.71,13.11 184.71,15.95 v2(183.24,17.43)
FT2232_REF: length 1.8
  TOP w0.254: U144.6 R703.2
FT2232_RESET#: length 3.1
  TOP w0.127: U144.14 193.04,13.48 193.04,12.45 193.19,12.31 C514.1 193.72,11.64 193.76,11.6 R701.1
FT2232_SUSPEND#: length 2.6
  TOP w0.127: TP223.1 192.54,25.8 192.54,24.88 U144.36
FT2232_UART0_RTS#: length 7.6
  TOP w0.127: v2(198.6,16.04) 198.48,15.93 U144.18
  BOTTOM w0.127: v2(198.6,16.04) 198.6,17.69 196.86,19.43 U270.12
FT2232_UART0_RXD: length 11.5
  TOP w0.127: U144.17 196.83,15.43 197.05,15.21 v2(197.05,14.28)
  BOTTOM w0.127: v2(197.05,14.28) 198.08,14.28 199.09,15.3 199.09,18.45 197.46,20.08 U270.11
FT2232_UART0_TXD: length 7.3
  TOP w0.127: U144.16 194.04,13.48 194.04,14.08 194.5,14.54 v2(194.5,14.67)
  BOTTOM w0.127: U270.13 194.58,18.78 194.12,18.32 194.12,15.05 v2(194.5,14.67)
FT2232_UART1_CTS#: length 5.5
  TOP w0.127: U144.41 v2(190.04,23.68)
  BOTTOM w0.127: v2(190.04,23.68) 187.03,23.68 186.82,23.89 U259.10
FT2232_UART1_RTS#: length 7.7
  TOP w0.127: v2(190.54,26.08) 190.54,24.88 U144.40
  BOTTOM w0.127: U259.12 185.52,25.91 186.24,26.63 188.02,26.63 188.56,26.08 v2(190.54,26.08)
FT2232_UART1_RXD: length 7.7
  TOP w0.127: U144.39 191.04,24.88 v2(191.04,23.66)
  BOTTOM w0.127: U259.11 186.17,23.68 186.62,23.22 190.61,23.22 v2(191.04,23.66)
FT2232_UART1_TXD: length 10.1
  TOP w0.127: v2(191.09,26.86) 191.09,26.37 191.54,25.92 191.54,24.88 U144.38
  BOTTOM w0.127: v2(191.09,26.86) 190.84,27.11 185.91,27.11 184.87,26.07 U259.13
FT2232_VPHY: length 4.4
  TOP w0.254: v2(187.9,11.68) 187.9,12.22 188.04,12.36 U144.4
  BOTTOM w0.381: L40.2 C1243.2 v2(187.9,11.68)
FT2232_VPLL: length 4.3
  TOP w0.254: v2(190.54,11.64) 190.54,13.48 U144.9
  BOTTOM w0.381: v2(190.54,11.64) C1245.1 191.24,12.53 191.37,12.66 L43.2
FT2232_XIN: length 8.4
  TOP w0.127: Y8.1 183.08,10.13 183.37,9.84 C519.2 186.49,9.84 186.67,10.02 186.67,11.95 187.04,12.32 U144.2
FT2232_XOUT: length 9.9
  TOP w0.127: U144.3 187.54,12.21 187.16,11.82 187.16,9.23 186.64,8.71 C525.2 183.38,8.71 183.08,8.41 Y8.2
FT4232_EECLK: length 11
  TOP w0.127: v2(203.26,15.48) 203.26,15.04 203.54,14.76 205.77,14.76 207.73,16.72 209.47,16.72 209.76,16.43 210.69,16.43 U145.62
  BOTTOM w0.127: v2(203.26,15.48) 203.26,15.01 203.65,14.63 U275.2
FT4232_EECS: length 12.2
  TOP w0.127: v2(201.99,15.48) 203.07,14.41 206,14.41 207.98,16.39 209.27,16.39 209.74,15.93 U145.63
  BOTTOM w0.127: U275.1 202.38,14.56 201.99,14.94 v2(201.99,15.48)
FT4232_EEDIN: length 9.4
  TOP w0.127: U145.61 210.69,16.93 209.62,16.93 208.93,17.61 207.04,17.61 205.77,16.34 v2(205.77,15.48)
  BOTTOM w0.127: v2(205.77,15.48) R1268.2 U275.3
FT4232_EEDOUT: length 4.1
  BOTTOM w0.127: U275.4 206.19,14.9 206.33,15.04 206.33,15.76 206.19,15.9 R1266.1 R1268.1
FT4232_NR: length 2.2
  BOTTOM w0.127: U277.4 219.73,8.58 219.44,8.87 C1253.1
FT4232_PWREN#: length 16.6
  TOP w0.127: v2(212.59,15.58) 212.59,17.12 212.28,17.43 210.69,17.43 U145.60
  L5-SIGNAL2 w0.102: v2(218.11,4.8) 215.79,7.12 215.79,8.11 212.59,11.32 v2(212.59,15.58)
FT4232_REF: length 1.8
  TOP w0.254: U145.6 R704.2
FT4232_RESET#: length 3.1
  TOP w0.127: R702.1 219.86,11.6 219.82,11.64 C517.1 219.28,12.31 219.14,12.45 U145.14
FT4232_SUSPEND#: length 2.6
  TOP w0.127: TP224.1 218.64,25.8 218.64,24.88 U145.36
FT4232_UART0_CTS#: length 7.6
  TOP w0.127: v2(219.64,16.82) 219.79,16.82 220.24,16.38 221.01,16.38 221.06,16.43 222.09,16.43 U145.19
  BOTTOM w0.127: U273.10 220.34,19.76 219.64,19.06 v2(219.64,16.82)
FT4232_UART0_RTS#: length 8
  TOP w0.127: U145.18 223.03,15.93 223.55,15.4 v2(224.62,15.4)
  BOTTOM w0.127: v2(224.62,15.4) 224.62,17.91 224.08,18.46 U273.12
FT4232_UART0_RXD: length 11.1
  TOP w0.127: U145.17 223.02,15.43 223.15,15.3 v2(223.15,14.28)
  BOTTOM w0.127: v2(223.15,14.28) 224.9,14.28 225.13,14.51 225.13,17.86 224.21,18.78 223.3,18.78 222.97,19.11 U273.11
FT4232_UART0_TXD: length 6.1
  TOP w0.127: U145.16 220.14,14.27 v2(220.58,14.71)
  BOTTOM w0.127: U273.13 220.86,17.81 220.25,17.2 220.25,16.01 220.58,15.68 v2(220.58,14.71)
FT4232_UART1_RXD: length 8.2
  TOP w0.127: v2(220.46,21.19) 220.46,20.86 220.89,20.43 U145.27
  BOTTOM w0.127: v2(220.46,21.19) 219.92,21.72 219.92,24.57 220.54,25.19 U264.11
FT4232_UART1_TXD: length 6.7
  TOP w0.127: U145.26 220.75,19.93 v2(220.44,20.24)
  BOTTOM w0.127: U264.13 222.14,23.91 221.17,23.91 220.94,23.68 220.94,20.73 v2(220.44,20.24)
FT4232_UART2_RXD: length 8.9
  TOP w0.127: U145.39 217.14,24.88 217.14,23.62 v2(218.12,22.64)
  BOTTOM w0.127: U264.10 220.68,25.84 219.57,24.72 219.57,23.15 219.06,22.64 v2(218.12,22.64)
FT4232_UART2_TXD: length 7.7
  TOP w0.127: U145.38 217.64,24.88 217.64,23.78 218.78,22.64 v2(220.37,22.64)
  BOTTOM w0.127: U264.12 220.91,24.54 220.4,24.04 220.4,22.68 v2(220.37,22.64)
FT4232_UART3_RTS#: length 11.4
  TOP w0.127: U143.12 201.79,19.17 203.23,20.61 209.43,20.61 209.75,20.93 U145.53
FT4232_UART3_RXD: length 12.3
  TOP w0.127: U145.52 209.77,21.43 209.33,20.99 202.98,20.99 201.14,19.15 U143.11
FT4232_UART3_TXD: length 16.4
  TOP w0.127: v2(212.29,21.51) 211.86,21.94 211.86,24.35 212.39,24.88 212.64,24.88 U145.48 ; U143.13 v2(202.44,18.73)
  BOTTOM w0.127: v2(202.44,18.73) 204.04,20.32 211.1,20.32 v2(212.29,21.51)
FT4232_VPHY: length 4.4
  TOP w0.254: v2(214,11.68) 214,12.22 214.14,12.36 U145.4
  BOTTOM w0.381: L41.2 C1244.2 v2(214,11.68)
FT4232_VPLL: length 4.3
  TOP w0.254: v2(216.64,11.64) U145.9
  BOTTOM w0.254: C1246.1 v2(216.64,11.64)
  BOTTOM w0.381: L42.2 217.51,12.66 217.38,12.53 C1246.1
FT4232_XIN: length 8.3
  TOP w0.127: U145.2 213.14,12.55 211.44,10.85 C509.2 207.91,10.85 207.63,11.13 Y7.1
FT4232_XOUT: length 9.4
  TOP w0.127: Y7.2 207.63,9.48 207.88,9.73 C523.2 210.95,9.73 213.64,12.42 U145.3
GATE: length 9.1
  TOP w0.127: U16.6 208.05,165.04 208.47,164.62 213.6,164.62 214.31,163.91 U21.4
GESI_EXP_PHY_RSTZ: length 18
  TOP w0.127: U39.2 R204.1 v2(43.39,123.43) ; U43.17 46.38,111.41 v2(46.38,110.57)
  L7-SIGNAL3 w0.109: v2(46.38,110.57) 45.55,111.39 44.91,111.39 43.87,112.43 43.87,115.73 43.39,116.21 v2(43.39,123.43)
GESI_GPIO_RGMII1_RST#: length 273.7
  L7-SIGNAL3 w0.109: v2(32.66,43.13) 32.66,44.14 37.94,49.41 37.94,72.16 36.22,73.88 36.22,82.76 41.11,87.66 41.11,89.18 48.37,96.44 48.37,98.42 46.82,99.97 46.82,111.3 46.13,111.99 46.13,115.17 46.41,115.45 46.41,118.1 45.02,119.5 45.02,130.87 44,131.89 44,132.85 43.02,133.82 43.02,136.99 44.04,138 44.04,140.68 60.1,156.74 60.1,162.1 61.9,163.89 61.9,176.42 60.77,177.55 60.77,181.94 63.87,185.05 78.39,185.05 86.35,177.09 125.26,177.09 131.01,171.34 134.93,171.34 137.04,173.44 148.15,173.44 150.89,176.19 159.16,176.19 v2(160.46,174.89)
  BOTTOM w0.127: v2(160.46,174.89) 160.46,175.14 160.14,174.82 160.14,173.12 160.23,173.03 161.3,173.03 161.77,172.56 R778.1 ; J56.29 v2(32.66,43.13)
GESI_MCAN4_RX: length 2.8
  BOTTOM w0.127: J54.55 32.03,99.01 R954.2
GESI_MCAN4_TX: length 2.9
  BOTTOM w0.127: J54.53 32.18,98.51 R958.2
GESI_MDIO0_MDC: length 60.6
  L3-SIGNAL1 w0.089: v3(74.77,88.7) 74.26,89.21 74.26,89.68 73.36,90.58 72.58,90.58 70.04,93.12 66.58,93.12 v2(62.01,97.69)
  L5-SIGNAL2 w0.102: v2(62.01,97.69) 59.98,99.72 59.98,102.97 57.26,105.68 57.26,106.94 56.41,107.79 54.75,107.79 53.35,109.2 53.35,109.55 50.61,112.29 48.37,112.29 47.84,112.83 44.36,112.83 44.08,113.11 41.36,113.11 41.08,113.38 34.9,113.38 34.11,114.18 v2(31.1,114.18)
  BOTTOM w0.127: J54.97 31.43,114.51 v2(31.1,114.18)
GESI_MDIO0_MDIO: length 76.9
  TOP w0.127: v2(87.32,91.09) 87.08,90.85 R933.1
  L14-SIGNAL6 w0.089: v2(30.92,116.42) 32.44,117.93 43.38,117.93 43.65,117.67 49.36,117.67 49.68,117.35 53.82,117.35 58.17,112.99 58.17,108.87 60.34,106.71 65.54,106.71 66.38,105.87 67.04,105.87 69.25,103.66 69.25,102.5 74.79,96.96 78.49,96.96 84.35,91.09 v2(87.32,91.09)
  BOTTOM w0.127: v2(30.92,116.42) 32.33,115.01 J54.99
GESI_RGMII1_INT#: length 67.6
  L7-SIGNAL3 w0.109: v2(32.66,39.63) 32.23,40.07 32.23,44.04 37.7,49.51 37.7,71.89 35.88,73.71 35.88,82.76 40.85,87.73 40.85,89.32 47.06,95.53 47.06,96.63 v2(47.91,97.48)
  BOTTOM w0.127: J56.15 v2(32.66,39.63)
GESI_RGMII1_RD0: length 66.2
  L14-SIGNAL6 w0.089: v11(79.02,86.56) 79.45,86.98 79.45,88.36 79.19,88.62 77.25,88.62 74.88,90.99 74.2,90.99 72.46,92.73 72.3,92.89 72.3,94.69 69.13,97.87 62.8,97.87 62.34,98.32 58.69,98.32 56.8,96.43 55.96,96.43 52.73,99.65 52.3,99.65 52.16,99.79 52.16,100.32 52.05,100.43 51.85,100.43 51.69,100.26 51.69,99.79 51.55,99.65 51.36,99.65 51.22,99.79 51.22,100.32 51.11,100.43 50.91,100.43 50.75,100.26 50.75,99.79 50.61,99.65 49.51,99.65 48.66,100.51 38.73,100.51 34.7,104.54 34.69,104.54 34.46,104.77 34.46,104.78 32.83,106.41 32.82,106.41 31.5,107.73 v11(31.38,107.73)
  BOTTOM w0.127: v11(31.38,107.73) 31.68,107.42 33.03,107.42 33.11,107.51 J54.69
GESI_RGMII1_RD1: length 66.2
  L14-SIGNAL6 w0.089: v11(31.3,108.47) 32.5,107.27 33.43,107.27 39.85,100.85 46.66,100.85 46.8,100.98 46.8,101.22 46.94,101.36 47.13,101.36 47.27,101.22 47.27,100.98 47.41,100.85 48.77,100.85 49.15,101.23 52.97,101.23 56.02,98.17 56.95,98.17 58.15,99.37 61.8,99.37 63.03,98.13 69.24,98.13 72.57,94.8 72.57,93 74.31,91.26 74.99,91.26 77.35,88.9 80.17,88.9 80.44,88.63 80.44,86.98 v11(80.01,86.56)
  BOTTOM w0.127: J54.77 32.14,109.51 31.3,108.67 v11(31.3,108.47)
GESI_RGMII1_RD2: length 66
  L14-SIGNAL6 w0.089: v11(32.01,108.52) 32.36,108.17 33.49,108.17 35.83,105.83 36.67,105.83 39.59,102.9 46.05,102.9 46.53,103.38 47.11,103.38 47.25,103.51 47.25,103.98 47.38,104.12 47.58,104.12 47.72,103.98 47.72,103.51 47.85,103.38 51.66,103.38 51.8,103.51 51.8,103.81 51.94,103.94 52.13,103.94 52.27,103.81 52.27,103.51 52.41,103.38 54.15,103.38 55.64,101.89 60.32,101.89 63.54,98.67 69.46,98.67 75.13,93 75.13,92.29 75.36,92.07 76.58,90.84 77.28,90.84 77.92,90.21 79.2,90.21 79.74,89.66 80.74,89.66 81.68,88.72 82.18,88.72 82.42,88.48 82.42,87.36 82.27,87.21 82.27,86.83 v11(81.99,86.56)
  BOTTOM w0.127: J54.75 32.51,109.01 v11(32.01,108.52)
GESI_RGMII1_RD3: length 66
  L14-SIGNAL6 w0.089: v11(83.98,86.56) 84.92,87.5 84.92,88.14 83.52,89.54 83.52,89.94 83.17,90.3 79.86,90.3 79.42,90.74 78.3,90.74 77.53,91.51 76.72,91.51 76.01,92.22 76.01,92.87 69.66,99.22 63.74,99.22 57.56,105.4 55.98,105.4 55.48,104.9 42.75,104.9 42.52,104.67 39.7,104.67 34.36,110.01 v11(32.7,110.01)
  BOTTOM w0.127: v11(32.7,110.01) J54.79
GESI_RGMII1_RX_CTL: length 66.2
  L14-SIGNAL6 w0.089: v11(32.65,107.83) 33.3,107.83 39.25,101.89 46.56,101.89 46.7,102.02 46.7,102.6 46.84,102.74 47.03,102.74 47.17,102.6 47.17,102.02 47.31,101.89 47.5,101.89 47.64,102.02 47.64,102.6 47.78,102.74 47.97,102.74 48.11,102.6 48.11,102.02 48.25,101.89 49.05,101.89 49.41,102.25 51.36,102.25 51.5,102.39 51.5,102.81 51.64,102.94 51.83,102.94 51.97,102.81 51.97,102.39 52.11,102.25 53.75,102.25 54.54,101.46 54.54,101.27 54.22,100.95 54.22,100.75 54.35,100.62 54.55,100.62 54.87,100.94 55.06,100.94 55.94,100.06 61.76,100.06 63.42,98.4 69.35,98.4 74.86,92.89 74.86,92.18 75.09,91.96 76.47,90.58 77.17,90.58 78.57,89.18 80.61,89.18 81.43,88.36 81.43,87.09 81.19,86.85 81.19,86.74 v11(81,86.56)
  BOTTOM w0.127: J54.71 32.88,108.01 32.7,107.83 v11(32.65,107.83)
GESI_RGMII1_RXC: length 66
  L14-SIGNAL6 w0.089: v11(32.66,108.51) 33.71,108.51 36.04,106.18 36.86,106.18 39.14,103.9 46.05,103.9 46.67,104.52 48.52,104.52 48.66,104.38 48.66,103.93 48.8,103.79 48.99,103.79 49.13,103.93 49.13,104.38 49.27,104.52 49.46,104.52 49.6,104.38 49.6,103.93 49.74,103.79 49.93,103.79 50.07,103.93 50.07,104.38 50.21,104.52 53.95,104.52 54.17,104.52 55.02,103.66 58.92,103.66 63.65,98.93 69.57,98.93 75.62,92.88 75.62,92.18 76.63,91.17 77.43,91.17 78.13,90.47 79.31,90.47 79.79,89.99 81.12,89.99 81.93,89.18 82.84,89.18 83.41,88.61 83.41,87.46 82.98,87.03 v11(82.98,86.56)
  BOTTOM w0.127: J54.73 v11(32.66,108.51)
GESI_RGMII1_TD0: length 55.6
  L14-SIGNAL6 w0.089: v11(80.01,90.71) 80.01,91.06 76.61,94.47 75.29,94.47 67.9,101.86 67.9,102.73 67.9,102.95 66.37,104.48 60.35,104.48 59.56,105.27 57.2,107.63 55.29,107.63 54.06,106.4 50.63,106.4 50.13,106.9 49.83,106.9 49.74,107 49.74,107.37 49.64,107.46 49.51,107.46 49.42,107.37 49.42,107 49.32,106.9 49.19,106.9 49.1,107 49.1,107.37 49.01,107.46 48.88,107.46 48.78,107.37 48.78,107 48.69,106.9 48.56,106.9 48.47,107 48.47,107.37 48.37,107.46 48.24,107.46 48.15,107.37 48.15,107 48.05,106.9 47.92,106.9 47.83,107 47.83,107.37 47.74,107.46 47.61,107.46 47.51,107.37 47.51,107 47.42,106.9 47.29,106.9 47.2,107 47.2,107.37 47.1,107.46 46.97,107.46 46.88,107.37 46.88,107 46.78,106.9 45.59,106.9 44.69,107.81 42.6,107.81 v11(42.4,107.6)
  BOTTOM w0.127: R989.2 v11(80.01,90.71) ; J54.72 41.99,108.01 v11(42.4,107.6)
GESI_RGMII1_TD1: length 55.5
  L14-SIGNAL6 w0.089: v11(41.56,107.22) 42.93,105.85 46.87,105.85 46.96,105.94 46.96,106.38 47.05,106.47 47.19,106.47 47.28,106.38 47.28,105.94 47.37,105.85 47.5,105.85 47.6,105.94 47.6,106.38 47.69,106.47 47.82,106.47 47.91,106.38 47.91,105.94 48.01,105.85 48.14,105.85 48.23,105.94 48.23,106.38 48.32,106.47 48.46,106.47 48.55,106.38 48.55,105.94 48.64,105.85 48.77,105.85 48.87,105.94 48.87,106.38 48.96,106.47 49.09,106.47 49.18,106.38 49.18,105.94 49.28,105.85 49.41,105.85 49.5,105.94 49.5,106.38 49.59,106.47 49.73,106.47 49.82,106.38 49.82,105.94 49.91,105.85 54.62,105.85 56.13,107.36 57.09,107.36 60.24,104.22 66.26,104.22 67.64,102.84 67.64,101.75 73.29,96.09 75.19,94.19 76.01,94.19 v11(79.03,91.17)
  BOTTOM w0.127: v11(41.56,107.22) 41.27,107.51 J54.70 ; v11(79.03,91.17) 78.57,90.71 78.57,89.29 R990.2
GESI_RGMII1_TD2: length 55.6
  L14-SIGNAL6 w0.089: v11(41.55,109.51) 42.01,109.05 43.75,109.05 44.78,110.08 48.01,110.08 48.1,110.17 48.1,110.46 48.19,110.56 48.32,110.56 48.42,110.46 48.42,110.17 48.51,110.08 49.84,110.08 50.33,110.57 54.85,110.57 56.21,109.21 56.96,109.21 60.89,105.28 66.7,105.28 66.95,105.04 68.51,103.48 68.7,103.28 68.7,103.19 68.7,102.27 74.56,96.41 77.29,96.41 v11(82.98,90.71)
  BOTTOM w0.127: J54.78 v11(41.55,109.51) ; v11(82.98,90.71) 82.51,90.24 82.51,89.32 R986.2
GESI_RGMII1_TD3: length 56.1
  L14-SIGNAL6 w0.089: v11(42.45,109.46) 43.99,111 55.62,111 56.56,110.06 56.56,110.06 56.81,109.81 56.81,109.8 61.06,105.55 66.85,105.55 68.97,103.44 68.97,103.26 68.97,102.38 74.67,96.68 78.01,96.68 v11(83.98,90.71)
  BOTTOM w0.127: J54.76 42,109.01 v11(42.45,109.46) ; v11(83.98,90.71) 83.52,90.26 83.52,89.29 R985.2
GESI_RGMII1_TX_CTL: length 56
  L14-SIGNAL6 w0.089: v11(81.99,90.71) 81.99,91.22 79.11,94.1 78.61,94.1 76.56,96.15 74.45,96.15 68.44,102.16 68.44,102.51 68.44,103.17 68.31,103.3 66.76,104.85 66.59,105.02 60.75,105.02 57.61,108.16 56.22,108.16 55.93,108.45 50.68,108.45 50.26,108.87 48.93,108.87 48.84,108.77 48.84,108.45 48.75,108.36 48.61,108.36 48.52,108.45 48.52,108.77 48.43,108.87 48.3,108.87 48.2,108.77 48.2,108.45 48.11,108.36 47.98,108.36 47.89,108.45 47.89,108.77 47.79,108.87 47.66,108.87 47.57,108.77 47.57,108.45 47.48,108.36 47.34,108.36 47.25,108.45 47.25,108.77 47.16,108.87 47.03,108.87 46.93,108.77 46.93,108.45 46.84,108.36 46.71,108.36 46.62,108.45 46.62,108.77 46.52,108.87 45.17,108.87 44.82,108.51 v11(41.55,108.51)
  BOTTOM w0.127: R987.2 81.52,89.32 81.52,90.24 v11(81.99,90.71) ; J54.74 v11(41.55,108.51)
GESI_RGMII1_TXC: length 55.8
  L14-SIGNAL6 w0.089: v11(41.54,110.22) 40.81,110.22 40.25,109.67 40.25,108.7 40.84,108.12 45.38,108.12 45.59,107.9 50.13,107.9 50.63,107.4 53.83,107.4 54.33,107.89 57.31,107.89 60.46,104.75 66.48,104.75 68.17,103.06 68.17,103.04 68.17,101.97 68.74,101.4 74.26,95.88 76.09,95.88 78.14,93.83 78.85,93.83 81,91.67 v11(81,90.71)
  BOTTOM w0.127: R988.2 v11(81,90.71) ; J54.80 41.33,110.01 v11(41.54,110.22)
GESI_RMII8_CLKOUT: length 1.2
  TOP w0.127: TP117.1 R367.2
GESI_RMII8_CRS_DV: length 80.7
  L5-SIGNAL2 w0.102: v2(43.61,56.63) 38.48,61.76 38.48,74.92 39.15,75.59 41.22,75.59 41.76,75.05 51.84,75.05 54.64,77.85 57.09,77.85 58.33,79.09 65.93,79.09 67.7,77.32 76.87,77.32 83.42,83.87 83.42,89.22 v2(83.98,89.78)
  BOTTOM w0.127: J56.64 v2(43.61,56.63)
GESI_RMII8_PHY_INTN: length 54.7
  L14-SIGNAL6 w0.089: v2(47.91,96.74) 48.6,96.05 48.6,69.05 41.13,61.57 41.13,49.95 41.95,49.13 v2(42.57,49.13)
  BOTTOM w0.127: J56.56 42.07,49.63 v2(42.57,49.13)
GESI_RMII8_REF_CLK: length 50.5
  L3-SIGNAL1 w0.089: v2(41.55,98.51) 41.55,98.48 45.46,94.58 48.61,94.58 52.76,90.42 57.39,90.42 59.9,87.91 70.53,87.91 70.53,87.91 70.75,87.91 73.61,85.05 73.61,84.3 75.57,82.35 79,82.35 79.33,82.02 v5(79.87,82.02)
  L4-GND2 w0.102: v5(79.87,82.02) 80.2,82.02 v6(80.2,82.03)
  L5-SIGNAL2 w0.102: v6(80.2,82.03) 81.99,83.83 v2(81.99,84.27)
  BOTTOM w0.127: J54.54 v2(41.55,98.51)
GESI_RMII8_RX_ER: length 82.9
  L5-SIGNAL2 w0.102: v2(41.55,50.13) 41.96,50.54 41.96,56.4 37.57,60.79 37.57,75.3 38.77,76.51 41.71,76.51 42.26,75.96 51.41,75.96 54.26,78.82 56.52,78.82 57.71,80 66.31,80 66.68,79.63 72.96,79.63 76.61,83.29 80.59,83.29 81.44,84.13 81.44,89.22 v2(81.99,89.78)
  BOTTOM w0.127: J56.58 v2(41.55,50.13)
GESI_RMII8_RXD0: length 85.9
  L5-SIGNAL2 w0.102: v2(79.02,89.78) 78.01,88.77 78.01,85.93 77.28,85.19 77.07,85.19 73.79,81.91 57.94,81.91 55.86,79.83 53.86,79.83 51.59,77.57 42.79,77.57 42.24,78.11 40.58,78.11 39.99,77.52 38.5,77.52 36.09,75.12 36.09,59 39.02,56.07 39.02,49.09 41.98,46.13 v2(42.57,46.13)
  BOTTOM w0.127: J56.44 42.07,46.63 v2(42.57,46.13)
GESI_RMII8_RXD1: length 89
  L5-SIGNAL2 w0.102: v2(42.57,47.13) 42.97,47.54 42.97,56.08 37.87,61.18 37.87,75.17 38.9,76.2 41.47,76.2 42.01,75.66 51.56,75.66 54.42,78.51 56.65,78.51 57.84,79.7 66.18,79.7 67.15,78.73 72.57,78.73 75.82,81.98 79.16,81.98 79.46,81.69 80.34,81.69 82.43,83.78 82.43,89.22 v2(82.98,89.78)
  BOTTOM w0.127: v2(42.57,47.13) 42.07,47.63 J56.48
GESI_RMII8_TX_EN: length 71.3
  L5-SIGNAL2 w0.102: v2(81,84.27) 80.37,83.64 76.51,83.64 73.42,80.55 66.24,80.55 65.89,80.9 57.84,80.9 56.12,79.17 54.16,79.17 51.26,76.27 42.43,76.27 41.89,76.81 38.65,76.81 36.7,74.86 36.7,60.98 v2(41.55,56.13)
  BOTTOM w0.127: J56.62 v2(41.55,56.13)
GESI_RMII8_TXD0: length 79.4
  L5-SIGNAL2 w0.102: v2(42.57,50.13) 42.16,49.72 41.38,49.72 39.89,51.22 39.89,55.71 36.4,59.2 36.4,74.99 38.52,77.12 42.35,77.12 42.89,76.57 51.03,76.57 53.96,79.5 56.02,79.5 58.12,81.61 74,81.61 76.37,83.98 79.73,83.98 v2(80.01,84.27)
  BOTTOM w0.127: J56.60 42.07,50.63 v2(42.57,50.13)
GESI_RMII8_TXD1: length 83.9
  L5-SIGNAL2 w0.102: v2(41.55,47.13) 41.96,46.72 42.74,46.72 43.28,47.27 43.28,56.35 38.18,61.46 38.18,75.05 39.03,75.9 41.34,75.9 41.89,75.35 51.71,75.35 54.57,78.21 56.93,78.21 58.12,79.39 66.05,79.39 67.02,78.43 72.84,78.43 76.09,81.68 79.01,81.68 79.31,81.38 80.5,81.38 82.98,83.87 v2(82.98,84.27)
  BOTTOM w0.127: J56.46 v2(41.55,47.13)
GESI_SPI5_CLK: length 60.7
  L12-SIGNAL5 w0.102: v2(18.21,71.09) 18.57,70.72 25.73,70.72 29.55,74.55 29.55,78.35 31.26,80.05 31.26,95.06 29.62,96.7 29.62,100.58 30.17,101.12 30.17,102.13 30.99,102.95 30.99,106.44 31.74,107.19 31.74,116.47 v2(32.57,117.3)
  BOTTOM w0.127: v2(32.57,117.3) 32.57,116.8 32.86,116.51 J54.105
GESI_SPI5_CS0: length 47.1
  L12-SIGNAL5 w0.102: v2(18.21,66.01) 19.37,66.01 20.68,67.32 23.31,67.32 24.72,68.72 29.37,68.72 30.99,70.34 30.99,77.79 32.77,79.57 32.77,100.13 v2(32.62,100.29)
  BOTTOM w0.127: J54.59 32.9,100.01 v2(32.62,100.29)
GESI_SPI5_CS1: length 47.7
  L12-SIGNAL5 w0.102: v2(18.21,67.28) 19.94,67.28 21.61,68.95 29.23,68.95 30.76,70.49 30.76,77.88 32.55,79.67 32.55,99.37 v2(31.63,100.29)
  BOTTOM w0.127: v2(31.63,100.29) 31.89,100.29 32.66,99.51 J54.57
GESI_SPI5_D0: length 65.4
  L12-SIGNAL5 w0.102: v2(18.21,69.82) 18.06,69.82 16.96,68.72 16.96,68.34 17.16,68.14 20.18,68.14 21.21,69.17 29.13,69.17 30.45,70.49 30.45,77.98 32.26,79.79 32.26,98.8 31.15,99.9 31.15,100.46 33.07,102.37 33.07,115.1 v2(32.66,115.51)
  BOTTOM w0.127: J54.101 v2(32.66,115.51)
GESI_SPI5_D1: length 60.4
  L12-SIGNAL5 w0.102: v2(18.21,68.55) 20,70.34 25.66,70.34 29.78,74.45 29.78,78.25 31.48,79.96 31.48,95.15 29.86,96.78 29.86,100.16 31.22,101.52 31.22,106.35 32.19,107.32 v2(32.19,116.34)
  BOTTOM w0.127: J54.103 32.52,116.01 v2(32.19,116.34)
GESI_UART8_RXD: length 2.7
  BOTTOM w0.127: v2(31.6,37.45) 32.21,37.45 32.4,37.63 J56.7
GESI_UART8_TXD: length 2.9
  BOTTOM w0.127: J56.9 32.85,38.13 32.16,38.82 v2(31.58,38.82)
GESI_UART9_RXD: length 2.7
  BOTTOM w0.127: J56.88 41.72,62.63 41.89,62.46 R1113.2
GESI_UART9_TXD: length 2.8
  BOTTOM w0.127: R1108.2 41.97,63.13 J56.90
GPIO0_14: length 2.5
  TOP w0.127: TP90.1 42.72,95.58 U50.54
GPIO0_15: length 2.4
  TOP w0.127: TP85.1 42.32,96.58 U50.52
GPIO0_29: length 2.8
  TOP w0.127: TP126.1 54.71,80.42 53.09,80.42 52.89,80.23 U58.7
GPIO0_30: length 2.9
  TOP w0.127: U58.10 54.12,81.73 TP121.1
GPIO_EDP_ENABLE: length 55.3
  TOP w0.127: v2(135.04,159.27) 135.04,159.38 135.1,159.44 U18.4
  L7-SIGNAL3 w0.109: v2(112.49,119.35) 112.49,120.69 120.86,129.06 120.86,130.6 138.54,148.27 138.54,150.87 139.51,151.84 139.51,155.68 135.92,159.27 v2(135.04,159.27)
  BOTTOM w0.127: v2(112.49,119.35) 112.49,119.43 113.06,120.01 R913.1
GPIO_LIN_EN: length 270.6
  TOP w0.127: U109.5 v2(26.35,34.35) ; U109.2 v2(24.4,34.35)
  L3-SIGNAL1 w0.089: v2(161.98,167.15) 161.52,167.62 161.52,171.08 159.43,173.17 156.85,173.17 155.24,171.56 141.36,171.56 138.14,168.34 133.84,168.34 133.1,169.08 129.26,169.08 126.56,166.37 123.67,166.37 123.18,166.86 120.79,166.86 119.92,166 114.96,166 114.61,166.35 114.61,167.31 113.72,168.2 111.33,168.2 109.81,169.72 104.42,169.72 103.55,168.84 103.55,168.02 87.66,152.13 82.12,152.13 56.71,126.73 46.11,126.73 41.1,121.71 41.1,117.96 v2(41.55,117.51) ; v2(24.4,34.35) v2(26.35,34.35)
  L14-SIGNAL6 w0.089: v2(41.55,117.51) 39.77,115.72 36.84,115.72 28.15,107.04 28.15,102.24 26.73,100.82 26.73,89.95 32.59,84.08 32.59,73.95 33.1,73.44 33.1,69.22 31.95,68.06 30.51,68.06 30.32,68.25 24.48,68.25 21.56,65.32 21.56,55.44 21.62,55.38 21.62,51.5 22.18,50.93 22.18,48.39 21.73,47.94 21.73,38.86 22.6,37.98 22.6,36.14 v2(24.4,34.35)
  BOTTOM w0.127: J54.110 v2(41.55,117.51) ; v2(24.4,34.35) 24.09,34.66 R1189.2 23.25,34.12 23.07,33.94 R1195.1 ; U173.7 161.48,166.65 v2(161.98,167.15)
GPIO_MCU_RGMII1_RST#: length 96.6
  TOP w0.127: U111.2 R587.2 v2(86.1,35.56)
  L3-SIGNAL1 w0.089: v3(119.12,68.63) 119.31,68.44 119.31,57.53 111.39,49.61 v2(109.41,49.61)
  L5-SIGNAL2 w0.102: v2(108.69,36.57) 108.69,36.58 96.5,36.58 95.11,35.18 86.48,35.18 v2(86.1,35.56)
  L7-SIGNAL3 w0.109: v2(86.1,35.56) 86.1,36.23 85.27,37.07 83.49,37.07 79.53,41.03 68.07,41.03 64.47,44.63 64.47,46.25 64.19,46.53 64.19,50.45 v2(64.56,50.81) ; v2(109.41,49.61) 109.91,49.1 109.91,40.31 109.36,39.75 109.36,36.96 108.97,36.58 108.69,36.58 v2(108.69,36.57)
  vias: v1(119.12,68.63)
GPIO_ONAND_RESET#: length 76.1
  TOP w0.127: U241.40 129.27,45.66 129.27,45.66 130.01,45.66 v2(130.51,45.16)
  L7-SIGNAL3 w0.109: v2(70.93,53.32) 71.9,52.35 78.8,52.35 84.62,46.53 98.81,46.53 104.99,52.71 129.9,52.71 131.86,50.75 131.86,47.6 131.1,46.84 131.1,45.75 v2(130.51,45.16)
  BOTTOM w0.127: R1140.1 v2(70.93,53.32)
GPIO_PRG1_RGMII_RST: length 2.4
  BOTTOM w0.127: J54.66 R941.1
GPIO_RGMII1_RST#: length 247
  TOP w0.127: v2(74.92,41.83) R567.2 U107.2
  L7-SIGNAL3 w0.109: v2(74.92,41.83) 74.42,41.33 68.28,41.33 65.41,44.2 65.41,46.1 64.73,46.79 64.73,48.41 65.06,48.74 65.06,50.89 64.72,51.23 64.04,51.23 61.85,53.42 61.85,86.24 52.2,95.89 52.2,110.54 50.45,112.29 50.45,113.12 49.51,114.06 49.51,114.84 49.59,114.91 49.59,116.25 50.42,117.09 50.42,119.43 51.9,120.9 51.9,128.5 56.65,133.25 56.65,142.72 84.14,170.21 102.72,170.21 103.69,169.25 139.22,169.25 140.14,168.33 151.55,168.33 153.32,170.1 153.32,173.46 154.01,174.14 160.44,174.14 v2(160.97,173.62)
  BOTTOM w0.127: v2(160.97,173.62) 161.35,173.62 161.7,173.26 162.24,173.26 162.78,172.72 R777.1
GPIO_USD_PWR_EN: length 164
  TOP w0.127: v2(27.03,124.31) U34.3
  L3-SIGNAL1 w0.089: v2(161.98,169.15) 161.98,170.92 158.71,174.19 157.27,174.19 155.06,171.99 141.15,171.99 139.36,170.2 129.76,170.2 129.03,170.94 126.95,170.94 125.76,169.74 114.41,169.74 113.99,170.16 109.14,170.16 108.37,170.92 105.01,170.92 103.11,169.02 103.11,168.63 100.08,165.6 99.69,165.6 87.89,153.8 83.17,153.8 56.53,127.16 43.95,127.16 41.1,124.31 v2(27.03,124.31)
  BOTTOM w0.127: U173.3 161.48,168.65 v2(161.98,169.15)
H_MAIN_WK0N: length 140.2
  L3-SIGNAL1 w0.089: v3(110.32,80.63) v5(110.09,80.35)
  L4-GND2 w0.102: v5(110.09,80.35) v7(109.81,80.67)
  L12-SIGNAL5 w0.102: v8(91.09,81.66) 100.52,81.66 101.33,82.47 107.31,82.47 108.59,81.19 108.59,80.48 108.83,80.24 109.17,80.24 109.29,80.36 109.5,80.36 v7(109.81,80.67)
  L13-GND5 w0.102: v8(91.09,81.66) v9(90.74,81.66)
  L14-SIGNAL6 w0.089: v2(123.66,22.8) 123.44,22.59 113.92,22.59 109.58,26.92 107.81,26.92 106.38,25.5 106.38,24.84 105.16,23.62 103.36,23.62 102.4,22.66 87.03,22.66 82.76,26.92 82.76,37.34 79.94,40.16 79.08,40.16 74.8,44.44 74.8,66.28 77.61,69.09 77.61,69.98 81.08,73.45 81.08,74.65 81.59,75.16 81.59,78.02 81.86,78.28 82.09,78.51 83.24,78.51 83.68,78.08 83.68,77.57 84.87,76.38 87.74,76.38 90.74,79.38 v9(90.74,81.66)
  vias: v1(110.32,80.63)
H_MCU_INTN: length 55.4
  TOP w0.127: v2(166.99,64.39) 167.03,64.35 167.03,63.67 TP158.1
  L3-SIGNAL1 w0.089: 166.99,64.39 169.7,67.11 169.7,69.32 171.21,70.82 172.08,70.82 v3(172.09,70.82) ; 166.99,64.39 168.11,64.39 168.4,64.09 168.4,56.06 161.31,48.97 145.63,48.97 142.55,52.05 v2(142.1,52.05) ; 166.99,64.39 v2(166.99,64.39)
  BOTTOM w0.127: R446.2 141.84,51.79 v2(142.1,52.05)
H_MCU_PORZ: length 54.8
  TOP w0.127: v2(163.86,28.52) 163.24,28.52 162.68,29.08 TP220.1 ; v2(177.83,70.83) U68.25
  L14-SIGNAL6 w0.089: v2(177.83,70.83) 177.58,70.83 176.08,69.32 176.08,62.37 175.78,62.07 175.78,45.71 170.3,40.23 167.27,40.23 162.59,35.56 162.59,29.79 v2(163.86,28.52)
  BOTTOM w0.127: U258.1 v2(163.86,28.52)
H_MCU_WK1N: length 66.2
  L3-SIGNAL1 w0.089: v2(107.27,50.62) 111.44,50.62 118.32,57.5 v3(118.32,68.63)
  L5-SIGNAL2 w0.102: v2(124.93,22.8) 120.76,26.98 116.34,26.98 112.63,30.68 v2(108.49,30.68)
  L14-SIGNAL6 w0.089: v2(107.27,50.62) 106.89,50.24 106.89,48.72 106,47.83 106,35.15 107.42,33.73 107.42,31.75 v2(108.49,30.68)
  vias: v1(118.32,68.63)
H_SOC_PORZ: length 362.5
  TOP w0.127: v2(174.3,77.27) 174.3,78.05 U68.53
  L3-SIGNAL1 w0.089: v2(204.2,65.07) 200.57,65.07 196.73,68.91 191.32,68.91 190.74,68.33 187,68.33 183.7,71.63 183.7,78.18 182.2,79.68 179.71,79.68 178.34,78.31 176.18,78.31 175.15,77.27 v2(174.3,77.27) 174.3,77.65 172,79.96 168.85,79.96 v2(166.99,81.82)
  L12-SIGNAL5 w0.102: v2(15.29,43.14) 23.52,34.91 40.63,34.91 40.97,35.26 45.67,35.26 48.9,32.03 48.9,27.34 53.04,23.2 53.04,20.18 53.53,19.69 53.53,17.88 52.94,17.3 52.94,12.5 54.47,10.97 62.16,10.97 63.83,12.65 94.56,12.65 94.72,12.48 111.04,12.48 117.83,5.69 170.77,5.69 175.03,9.94 180.59,9.94 180.98,9.55 200.59,9.55 202.14,11.1 202.14,15.01 203.25,16.12 214.72,16.12 214.76,16.08 221.14,16.08 222.33,17.27 222.33,23.27 229.62,30.56 229.62,38.4 224.14,43.89 212.85,43.89 204.2,52.54 204.2,55.36 204.2,55.36 204.2,55.7 204.2,55.7 204.2,59.68 204.2,59.68 204.2,60.02 204.2,60.02 204.2,60.62 204.2,60.62 204.2,60.96 204.2,60.96 v2(204.2,65.07)
  BOTTOM w0.127: v2(174.3,77.27) 174.22,77.36 R1033.1 ; U252.1 v2(15.29,43.14)
H_WKUP_I2C0_SCL: length 314.1
  TOP w0.127: U42.13 72.48,115.2 v2(72.1,115.2) ; v2(167.39,48.75) 167.71,48.75 168.1,49.14 U89.16 ; v2(177.91,53.14) 178.71,52.34 U87.16 ; v2(171.34,123.02) 171.08,122.76 171.08,122.54 U35.13 ; v2(179.31,71.82) U68.31
  L3-SIGNAL1 w0.089: v2(167.39,48.75) 167.79,48.36 176.3,48.36 177.91,49.97 v2(177.91,53.14) ; v2(170.67,132.98) 170.67,134.57 163.25,141.99 146.25,141.99 144.54,140.28 130.06,140.28 120.58,130.81 98.03,130.81 95.03,127.81 86.02,127.81 84.88,126.68 81.14,122.93 81.14,121.67 78.68,119.21 75.22,119.21 73.96,117.95 73.96,117.36 72.1,115.49 v2(72.1,115.2)
  L14-SIGNAL6 w0.089: v2(170.67,132.98) 170.67,131.6 173.01,129.27 173.01,124.69 v2(171.34,123.02) 171.07,122.75 171.07,121.05 171.48,120.65 173.82,120.65 174.96,119.51 174.96,116.9 176.02,115.83 177.58,115.83 178.41,115 178.41,113.96 181.22,111.15 184.44,107.93 184.44,96.35 179.99,91.9 179.99,87.09 179.23,86.32 179.23,82.57 179.5,82.3 179.5,78.64 178.26,77.39 178.26,77.12 177.66,76.52 177.66,71.9 177.99,71.56 179.04,71.56 v2(179.31,71.82) 179.31,71.7 182.41,68.61 182.41,59.97 177.91,55.47 v2(177.91,53.14) 177.91,48.96 177.91,47.73 192.59,33.04 192.59,30.27 203.89,18.97 203.89,17.93 206.83,14.99 213.43,14.99 213.61,15.16 214.69,15.16 214.87,15.34 224.11,15.34 224.47,14.99 228.51,14.99 230.67,17.14 230.67,18.65 v2(230.2,19.11)
  BOTTOM w0.127: v2(230.2,19.11) 229.14,19.11 228.25,18.21 U268.4
H_WKUP_I2C0_SDA: length 305.2
  TOP w0.127: v2(178.82,53.14) 179.21,52.76 U87.15 ; U42.12 73.48,115.51 73.31,115.68 v2(72.93,115.68) ; U35.12 171.45,121.62 171.6,121.76 v2(171.6,122.04) ; U89.15 167.63,49.64 166.8,48.81 v2(166.21,48.81) ; U68.30 v2(180.89,71.32)
  L3-SIGNAL1 w0.089: v2(72.93,115.68) 72.93,116.03 74.18,117.27 74.18,117.78 75.24,118.85 78.77,118.85 81.35,121.42 81.35,122.84 86.04,127.53 95.05,127.53 98.05,130.53 120.68,130.53 130.13,139.98 144.55,139.98 146.34,141.78 162.88,141.78 170.24,134.42 170.24,132.79 170.56,132.47 171.31,132.47 171.48,132.64 v2(171.48,133) ; v2(178.82,53.14) 178.14,52.46 178.14,49.87 176.41,48.14 166.89,48.14 v2(166.21,48.81)
  L14-SIGNAL6 w0.089: v2(171.48,133) 171.48,131.38 173.22,129.64 173.22,124.24 171.6,122.62 v2(171.6,122.04) 171.95,122.4 173.01,122.4 175.33,120.08 175.33,116.84 176.14,116.03 177.66,116.03 178.61,115.08 178.61,114.04 182.24,110.42 184.64,108.02 184.64,96.17 180.2,91.73 180.2,86.94 179.43,86.18 179.43,82.66 179.84,82.25 179.84,78.69 178.54,77.4 178.54,72.73 179.01,72.27 179.95,72.27 v2(180.89,71.32) 180.89,70.43 182.63,68.68 182.63,59.72 178.82,55.91 v2(178.82,53.14) 178.19,52.51 178.19,47.73 192.81,33.11 192.81,30.33 204.15,19 204.15,18.67 206.56,16.26 214.36,16.26 214.39,16.23 214.72,16.23 214.75,16.26 223.64,16.26 225.68,16.26 v2(226.41,15.52)
  BOTTOM w0.127: v2(226.41,15.52) 226.3,15.64 U268.7
HB1: length 6.9
  TOP w0.254: U46.20 219.31,107.04 220.37,108.1 C201.2 221.28,109.65 222.17,108.76 D34.1
HB2: length 6.7
  TOP w0.254: D35.1 222.67,100.81 222.03,100.18 C232.1 219.99,101.86 219.31,102.54 U46.11
HB_LM5141: length 4.4
  TOP w0.254: U81.11 209.95,58.44 C302.2 211.6,58.82 212.49,59.71 D38.1
HCPS_A_CPU_FSEL_PH1: length 2.9
  TOP w0.127: R195.1 R194.2 169.02,123.31 169.16,123.17 U35.16
HCPS_A_CPU_FSEL_PH2: length 3
  TOP w0.127: U36.16 180.59,123.11 180.22,123.48 R188.2 R189.1
HCPS_A_CPU_FSEL_PH3: length 2.9
  TOP w0.127: R192.1 R191.2 191.6,123.54 191.76,123.38 U37.16
HCPS_A_CPU_PG: length 1.7
  BOTTOM w0.127: R907.2 172.86,122.8 v2(172.78,122.89) 172.73,122.94 C705.1
HCPS_A_CPU_VSEL: length 3.9
  TOP w0.127: R197.1 R196.2 170.81,123.47 170.07,123.47 169.66,123.05 U35.15
HCPS_A_SYNC_OUT_PH1: length 15.7
  TOP w0.127: v2(170.42,123.02) 170.15,122.75 U35.14 ; U36.11 v2(183,121.12)
  L12-SIGNAL5 w0.102: v2(183,121.12) 181.9,122.23 181.9,122.91 181.36,123.45 170.85,123.45 v2(170.42,123.02)
HCPS_A_SYNC_OUT_PH2: length 18.7
  TOP w0.127: U37.11 v2(194.18,121.12) ; v2(182.51,124.04) 182.51,123.54 181.58,122.62 U36.14
  L12-SIGNAL5 w0.102: v2(194.18,121.12) 194.8,121.12 195.55,121.87 195.55,122.22 194.29,123.48 183.07,123.48 v2(182.51,124.04)
HCPS_A_SYNC_OUT_PH3: length 2.5
  TOP w0.127: R193.1 193.89,123.3 193.78,123.19 193.17,123.19 192.76,122.78 U37.14
HCPS_B_CORE_FSEL_PH1: length 3
  TOP w0.127: R228.1 R234.2 71.64,113.2 U42.16
HCPS_B_CORE_FSEL_PH2: length 2.9
  TOP w0.127: R265.1 R269.2 71.72,102.02 U48.16
HCPS_B_CORE_PG: length 2.7
  TOP w0.127: R213.2 72.54,118.86 C171.1 TP51.1
HCPS_B_CORE_VSEL: length 4.6
  TOP w0.127: U42.15 71.94,113.7 71.64,114 71.64,115.49 R223.2 R216.1
HCPS_B_SY_OUT_PH2: length 2.9
  TOP w0.127: R262.1 71.87,104.16 71.87,103.26 72.1,103.02 U48.14
HCPS_B_SYNC_OUT_PH1: length 12
  TOP w0.127: U42.14 v2(72.09,114.2) ; U48.11 v2(73.98,104.45)
  L14-SIGNAL6 w0.089: v2(73.98,104.45) 73.98,104.71 73.98,104.71 73.98,105.89 72.09,107.77 v2(72.09,114.2)
HO1: length 2.1
  TOP w0.127: R252.2 218.37,108.92 217.81,108.36 U46.22
HO2: length 1.8
  TOP w0.127: R277.1 217.93,100.57 217.81,100.69 U46.9
HO_LM5141: length 2.7
  TOP w0.127: U81.13 208.01,60.01 208.42,60.41 209.2,60.41 209.48,60.69 R464.1
HOL1: length 16.5
  TOP w0.127: U46.23 217.31,108.46 217.53,108.68 R252.1 v2(217.53,110.57) ; U45.4 v2(229.78,109.01)
  L3-SIGNAL1 w0.089: v2(229.78,109.01) 222.13,109.01 221.51,109.63 218.47,109.63 v2(217.53,110.57)
HOL2: length 17.4
  TOP w0.127: v3(217.09,100.08) 217.09,100.53 217.31,100.74 U46.8
  L3-SIGNAL1 w0.089: v3(232.45,100.56) 217.57,100.56 v3(217.09,100.08)
HOL_LM5141: length 7.7
  TOP w0.127: v2(212.63,61.45) 211.81,61.45 211.38,61.88 208.82,61.88 208.64,61.7 R464.2 207.51,60.04 U81.14
  BOTTOM w0.127: U237.4 212.83,61.64 v2(212.63,61.45)
HYP0_RXFLCLK: length 3.6
  TOP w0.127: U50.3 53.56,95.58 54.01,95.13 54.01,94.34 54.21,94.14 R309.1
HYP0_RXFLDAT: length 2.8
  TOP w0.127: R298.1 54.25,95.96 53.63,96.58 U50.5
HYP0_RXPMCLK: length 2.6
  TOP w0.127: U50.22 53.68,105.08 53.72,105.04 R261.1
HYP0_RXPMCLK_MUX: length 2.7
  TOP w0.127: R264.2 54.16,104.58 U50.21
HYP0_RXPMDAT: length 2.9
  TOP w0.127: R257.1 54.22,106.85 53.45,106.08 U50.24
HYP0_TXFLCLK: length 3.1
  TOP w0.127: R273.1 53.27,100.08 U50.12
HYP0_TXFLDAT: length 4.2
  TOP w0.127: U50.14 53.12,101.08 53.68,101.63 53.68,102.93 53.97,103.22 R267.1
HYP0_TXPMCLK: length 2.5
  TOP w0.127: R287.1 54.03,97.77 53.84,97.58 U50.7
HYP0_TXPMCLK_MUX: length 2.6
  TOP w0.127: R294.2 54.03,96.88 53.84,97.08 U50.6
HYP0_TXPMDAT: length 2.8
  TOP w0.127: R281.1 53.77,99.59 53.26,99.08 U50.10
HYP0_TXPMDAT_MUX: length 2.6
  TOP w0.127: R283.2 53.49,98.7 53.37,98.58 U50.9
HYP1_RXFLCLK: length 110.1
  TOP w0.127: v2(70.04,182.16) 70.04,182.06 70.08,182.01 J10.20 ; R346.2 v2(55.57,87.78)
  L7-SIGNAL3 w0.109: v2(55.57,87.78) 54.32,87.78 51.27,90.83 51.27,104.12 49.54,105.84 49.54,110.92 48.4,112.07 48.4,114.4 48.76,114.77 49.11,114.77 49.28,114.93 49.28,114.94 49.35,115.01 49.35,115.88 48.95,116.28 48.95,118.54 49.93,119.51 49.93,129.34 52,131.41 52,132.68 50.96,133.72 50.96,137.13 52.02,138.19 52.02,144.23 62.7,154.92 62.7,173.37 65.38,176.05 65.38,177.5 v2(70.04,182.16)
HYP1_RXFLCLK_MUX: length 74.4
  TOP w0.127: v2(50.81,86.98) 51.06,87.23 U58.21
  L3-SIGNAL1 w0.089: v5(90.13,81.23) 90.58,80.77 90.69,80.77 90.69,80.32 97.54,73.46 97.54,72.42 98.57,71.4 100.67,71.4 101.42,72.15 102.34,72.15 104.22,74.03 107.39,74.03 107.59,74.23 v3(107.92,74.23)
  L4-GND2 w0.102: v6(89.8,81.22) 89.8,81.23 v5(90.13,81.23)
  L5-SIGNAL2 w0.102: v6(89.8,81.22) 89.8,82.75 89.51,83.03 89.51,83.03 89.01,83.53 89.01,83.8 86.91,85.89 86.91,86.7 85.89,87.73 85.89,90.39 84.71,91.56 77.91,91.56 74.93,88.58 74.06,88.58 72.22,86.74 54.78,86.74 54.13,87.39 51.21,87.39 v2(50.81,86.98)
  vias: v1(107.92,74.23)
HYP1_RXFLCLK_R: length 2.7
  TOP w0.127: U58.22 R346.1
HYP1_RXFLDAT: length 126.3
  TOP w0.127: U58.3 51.06,78.23 v2(50.81,77.98) ; J10.22 69.08,182.04 v3(69.17,182.13)
  L3-SIGNAL1 w0.089: v3(69.17,182.13) 66.96,179.91 64.26,179.91 62.39,178.04 53.6,178.04 v2(52.71,177.15)
  L12-SIGNAL5 w0.102: v2(50.81,77.98) 50.4,78.39 50.4,90.92 52.23,92.75 52.23,112.85 52.64,113.26 52.9,113.26 53.04,113.4 53.04,114.46 52.76,114.74 52.76,116.36 53.04,116.64 53.04,118.7 50.35,121.4 50.35,131.1 50.05,131.4 50.05,132.73 51.02,133.7 51.02,137.2 52.04,138.22 52.04,152.91 51.02,153.93 51.02,157.45 49.99,158.48 49.99,174.43 v2(52.71,177.15)
HYP1_RXPMCLK: length 125.3
  TOP w0.127: v3(74.58,177.93) J10.8 ; v2(53.27,82.98) 53.02,82.73 U58.12
  L3-SIGNAL1 w0.089: v5(74.58,177.57) v3(74.58,177.93)
  L4-GND2 w0.102: v5(74.58,177.57) 74.58,177.25 v6(74.59,177.24)
  L5-SIGNAL2 w0.102: v6(74.59,177.24) 74.07,177.24 72.5,175.67 64.68,175.67 63.03,177.32 58.12,177.32 53.25,172.45 v2(52.73,172.45)
  L12-SIGNAL5 w0.102: v2(53.27,82.98) 52.42,83.83 52.42,91.77 53.68,93.03 53.68,108.15 53.39,108.44 53.39,112.26 53.86,112.73 53.86,114.28 53.46,114.67 53.46,116.15 54.36,117.05 54.36,119.91 52.79,121.48 52.79,123.68 54.22,125.12 54.22,131.43 56.65,133.86 56.65,157.14 52.28,161.51 52.28,172 v2(52.73,172.45)
HYP1_RXPMDAT: length 125.9
  TOP w0.127: U58.14 53.02,83.73 v2(53.27,83.98) ; J10.10 73.58,177.99 v3(73.19,177.6)
  L3-SIGNAL1 w0.089: v5(73.19,177.24) v3(73.19,177.6)
  L4-GND2 w0.102: v6(73.2,176.91) 73.19,176.92 v5(73.19,177.24)
  L5-SIGNAL2 w0.102: v2(52.7,173.36) 53.66,173.36 57.92,177.62 64.35,177.62 65.95,176.02 72.31,176.02 v6(73.2,176.91)
  L12-SIGNAL5 w0.102: v2(53.27,83.98) 53.68,83.57 53.68,82.81 53.44,82.57 52.92,82.57 52.19,83.3 52.19,92 52.63,92.43 52.63,108.79 53.07,109.22 53.07,112.82 53.45,113.2 53.45,114.37 53.24,114.58 53.24,116.24 54.14,117.14 54.14,119.82 52.04,121.92 52.04,132.66 53.13,133.75 53.13,134.54 52.8,134.87 52.8,135.98 54.11,137.28 54.11,153.34 52.97,154.48 52.97,157.5 52.01,158.45 52.01,172.67 v2(52.7,173.36)
HYP1_TXFLCLK: length 112.1
  TOP w0.127: v2(53.27,89.98) 53.02,89.73 U58.26 ; J10.18 70.58,179.26 v3(70.49,179.17)
  L3-SIGNAL1 w0.089: v3(70.49,179.17) 69.99,179.67 64.33,179.67 62.47,177.82 55.27,177.82 v2(52.69,175.24)
  L12-SIGNAL5 w0.102: v2(52.69,175.24) 54.73,173.2 54.73,160.47 57.58,157.61 57.58,133.34 55.12,130.88 55.12,123.12 55.58,122.65 55.58,112.55 54.9,111.87 54.9,91.78 53.27,90.15 v2(53.27,89.98)
HYP1_TXFLDAT: length 113.4
  TOP w0.127: U58.28 53.02,90.73 v2(53.27,90.98) ; J10.14 72.08,179.26 71.94,179.11 v3(71.08,179.11)
  L3-SIGNAL1 w0.089: v2(51.95,174.68) 53.08,174.68 56.01,177.6 62.64,177.6 64.39,179.35 68.74,179.35 69.32,178.77 70.74,178.77 v3(71.08,179.11)
  L12-SIGNAL5 w0.102: v2(53.27,90.98) 54.35,92.06 54.35,108.48 54.06,108.76 54.06,111.62 55.36,112.91 55.36,122.56 54.9,123.02 54.9,131.02 57.36,133.49 57.36,157.49 54.5,160.35 54.5,172.14 51.96,174.68 v2(51.95,174.68)
HYP1_TXPMCLK: length 131.2
  TOP w0.127: v3(76.08,177.68) J10.4 ; U58.5 51.06,79.23 v2(50.81,78.98)
  L3-SIGNAL1 w0.089: v5(76.08,177.32) v3(76.08,177.68)
  L4-GND2 w0.102: v5(76.08,177.32) 76.08,177 v6(76.09,176.99)
  L5-SIGNAL2 w0.102: v2(52.73,171.47) 54.51,171.47 58.23,175.18 72.55,175.18 74.15,176.78 75.88,176.78 v6(76.09,176.99)
  L12-SIGNAL5 w0.102: v2(52.73,171.47) 54.19,170.01 54.19,160.35 57.14,157.4 57.14,133.58 54.67,131.11 54.67,122.93 55.14,122.47 55.14,113.09 53.84,111.79 53.84,108.62 54.12,108.34 54.12,92.44 52.86,91.18 52.86,89.81 53.13,89.55 53.28,89.55 53.9,88.92 53.9,79.03 53.44,78.57 51.21,78.57 v2(50.81,78.98)
HYP1_TXPMDAT: length 123
  TOP w0.127: U58.20 53.02,86.73 v2(53.27,86.98) ; J10.2 76.58,179.06 v3(76.97,178.67)
  L3-SIGNAL1 w0.089: v5(76.97,178.32) v3(76.97,178.67)
  L4-GND2 w0.102: v5(76.97,178.32) 76.97,178 v6(76.98,177.99)
  L5-SIGNAL2 w0.102: v6(76.98,177.99) 76.74,177.75 73.01,177.75 72.32,177.06 71.31,177.06 71.08,177.29 67.29,177.29 66.63,177.95 57.87,177.95 54.52,174.6 52.87,174.6 52,173.74 52,171.45 52.75,170.7 v2(52.75,170.56)
  L12-SIGNAL5 w0.102: v2(53.27,86.98) 52.64,87.61 52.64,91.28 53.9,92.54 53.9,108.24 53.62,108.53 53.62,111.89 54.3,112.57 54.3,116.12 54.91,116.73 54.91,122.37 54.45,122.84 54.45,131.27 56.89,133.71 56.89,157.31 52.75,161.44 v2(52.75,170.56)
I2C0_IOEXP_INT#: length 190.2
  TOP w0.127: v2(50.22,114.26) 49.62,113.66 U43.22
  L3-SIGNAL1 w0.089: v2(160.16,171.22) 157.35,168.42 147.04,168.42 144.86,166.23 133.56,166.23 131.34,164.01 123.92,164.01 123.29,163.38 116.86,163.38 116.64,163.6 109.96,163.6 107.39,166.17 107.39,168.47 107.01,168.85 104.78,168.85 104.65,168.72 104.64,168.72 104.41,168.49 104.41,168.16 104.41,167.66 86.41,149.66 81.81,149.66 56.32,124.18 56.32,122.71 54.34,120.73 51.43,120.73 49.82,119.12 49.82,114.66 v2(50.22,114.26)
  L7-SIGNAL3 w0.109: v2(50.22,114.26) 51.2,113.29 51.2,112.38 52.68,110.9 52.68,96.29 59.62,89.34 60.95,89.34 v2(69.23,81.06)
  BOTTOM w0.127: v2(160.16,171.22) 160.18,171.2 160.18,171.13 160.05,171 159.72,171 159.41,170.69 U173.32
I2C0_SCL: length 507.6
  TOP w0.127: v2(50.63,111.43) 50.23,111.03 49.28,111.03 48.16,112.16 U43.19 ; U22.12 v3(108.09,160.48) ; R303.2 86.93,95.71 v3(86.92,95.72)
  L3-SIGNAL1 w0.089: v2(136.95,161.85) 136.71,161.85 135.47,160.6 135.47,159.09 135.22,158.84 135.19,158.84 135.19,158.84 109.1,158.84 108.65,159.29 108.65,159.93 v3(108.09,160.48) 99.19,160.48 95.78,157.07 95.56,156.85 95.56,156.45 v3(95.92,156.09) 94.84,156.09 86.18,147.43 v2(86.18,141.03) ; v3(110.32,84.63) 110.32,84.3 109.82,83.8 109.82,83.71 109.63,83.52 109.31,83.52 109.02,83.23 109.02,82.91 109.02,82.5 109.02,82.5 109.02,82.11 108.84,81.93 108.58,81.93 108.13,81.48 106.97,81.48 106.43,80.95 100.95,80.95 99.22,82.68 99.22,83.49 93.12,89.59 90.56,89.59 89.75,90.4 78.85,90.4 73.73,95.52 69.19,95.52 66.35,98.35 65.01,98.35 63.23,100.13 63.23,101.8 57.49,107.54 54.26,107.54 53.45,108.36 50.71,108.36 50.15,108.92 50.15,110.95 v2(50.63,111.43) 50.98,111.78 52.93,111.78 53.64,112.49 53.64,114.61 v2(53.87,114.84) 55.74,112.97 55.74,111.39 62.81,104.31 66.23,104.31 73.59,96.96 85.68,96.96 v3(86.92,95.72)
  L5-SIGNAL2 w0.102: v2(86.18,141.03) 85.7,140.55 80.67,140.55 80.12,141.09 73.49,141.09 66.69,134.29 66.69,126.81 64.01,124.12 63.88,123.99 63.88,120.08 60.4,116.6 60.4,116 59.76,115.36 54.38,115.36 v2(53.87,114.84)
  L7-SIGNAL3 w0.109: v2(50.63,111.43) 50.35,111.15 50.35,105.94 51.97,104.33 51.97,91.47 52.92,90.53 55.13,90.53 57.67,87.99 57.67,75.83 61.62,71.88 61.62,51.22 61.93,50.9 61.93,43.51 68.84,36.6 77.34,36.6 80.66,33.28 88.89,33.28 90.25,34.65 107.22,34.65 108.29,33.58 109.84,33.58 110.24,33.99 115.65,33.99 116.59,33.05 128.29,33.05 131.37,29.96 138.74,29.96 141.89,26.8 141.89,26.12 141.51,25.73 140.35,25.73 v2(139.94,26.14)
  L12-SIGNAL5 w0.102: v2(20.55,143.09) 22.31,141.33 23.95,141.33 24.59,140.69 42.57,140.69 44.03,139.23 44.03,138.17 45,137.2 45,133.49 45.92,132.57 45.92,129.86 50.13,125.66 50.13,119 51.62,117.5 51.82,117.5 52.2,117.11 52.2,113.46 51.8,113.06 51.62,113.06 50.63,112.07 v2(50.63,111.43)
  L14-SIGNAL6 w0.089: v2(136.95,161.85) 136.95,165.89 136.1,166.73 136.1,167.36 136.5,167.75 145.61,167.75 147.57,165.79 148.32,165.79 148.88,166.35 148.88,169.82 150.87,171.81 157.08,171.81 157.56,171.34 v2(157.91,171.34)
  BOTTOM w0.127: U181.12 v2(20.55,143.09) ; U173.29 v2(157.91,171.34) ; U256.6 v2(139.94,26.14)
  vias: v1(110.31,84.63)
I2C0_SDA: length 510.2
  TOP w0.127: U43.20 48.29,112.66 48.67,112.28 49.61,112.28 49.77,112.12 49.77,111.53 v2(49.72,111.48)
  L3-SIGNAL1 w0.089: v2(157.95,172.35) 158.24,172.06 159.93,172.06 160.59,171.4 160.59,170.22 157.84,167.48 154.85,167.48 154.53,167.79 147.36,167.79 140.09,160.53 138.63,160.53 137.82,161.34 136.51,161.34 135.72,160.55 135.72,159.02 135.33,158.63 109.23,158.63 108.65,158.04 108.65,156.39 v3(108.63,156.38) 97.47,156.38 96.83,157.02 96.2,157.02 v3(95.92,156.74) 96.36,156.31 96.36,155.93 96.17,155.74 94.98,155.74 86.78,147.53 86.78,140.01 v2(86.98,139.8) ; v3(86.96,96.33) 86.61,96.33 85.77,97.18 73.81,97.18 66.08,104.9 64.78,104.9 63.79,105.89 63.79,112.45 63.41,112.83 63.41,114.9 v2(62.96,115.35) 62.88,115.27 53.65,115.27 53.41,115.03 53.41,112.64 52.77,112.01 50.53,112.01 50,111.48 v2(49.72,111.48) 49.72,108.48 50.05,108.15 50.05,106.76 51.34,105.46 57.44,105.46 64.91,97.99 66.35,97.99 69.22,95.12 73.72,95.12 78.01,90.83 78.01,85.83 78.09,85.74 78.09,85.74 78.33,85.5 78.34,85.5 78.34,85.5 78.82,85.5 79.18,85.85 79.18,87.45 79.56,87.83 79.56,88.47 80.03,88.94 84.5,88.94 84.66,89.1 89.04,89.1 89.42,88.72 93.05,88.72 98.56,83.21 98.56,82.35 100.52,80.39 106.61,80.39 107.27,81.05 108.39,81.05 108.46,81.12 108.83,81.12 109.02,81.31 109.02,81.82 109.21,82.02 109.21,82.58 109.21,82.58 109.21,82.83 109.21,82.83 109.21,83.15 109.39,83.33 109.82,83.33 v3(110.32,83.83)
  L5-SIGNAL2 w0.102: v2(62.96,115.35) 62.96,118.73 64.23,120 64.23,123.91 67.1,126.79 67.1,134.28 73.68,140.87 80.03,140.87 80.61,140.28 86.5,140.28 v2(86.98,139.8)
  L7-SIGNAL3 w0.109: v2(141.21,26.14) 141.21,27.16 138.74,29.62 131.25,29.62 128.07,32.81 116.45,32.81 115.58,33.68 110.47,33.68 110.09,33.3 107.91,33.3 106.84,34.37 90.61,34.37 89.28,33.04 80.57,33.04 77.39,36.22 68.89,36.22 61.65,43.46 61.65,50.64 61.38,50.9 61.38,71.55 57.06,75.88 57.06,88.01 55.74,89.33 53.2,89.33 51.62,90.91 51.62,104.25 50,105.87 50,111.2 v2(49.72,111.48)
  L12-SIGNAL5 w0.102: v2(49.72,111.48) 49.72,111.51 51.38,113.17 51.38,117.42 49.9,118.9 49.9,125.47 44.02,131.35 44.02,132.55 43.03,133.53 43.03,137.12 42,138.15 42,139.64 41.18,140.47 24.5,140.47 23.86,141.11 21.62,141.11 v2(19.64,143.09)
  BOTTOM w0.127: v2(157.95,172.35) 158.37,171.92 158.37,170.45 U173.30 ; v2(19.64,143.09) 19.9,142.82 U181.13 ; U256.5 v2(141.21,26.14)
  vias: v1(110.31,83.83)
I2C1_SCL: length 106.3
  TOP w0.127: v2(45.77,89.98) 45.52,89.73 U58.31 ; R96.2 v2(8.72,158.93)
  L12-SIGNAL5 w0.102: v2(45.77,89.98) 46.6,90.81 46.6,98.35 47.79,99.54 47.79,113.79 48.66,114.66 49,114.66 49.35,115.01 49.35,116.12 48.86,116.61 48.86,117.06 48.71,117.21 48.18,117.21 47.53,116.56 47.53,116.33 46.93,115.72 44.45,115.72 42.93,114.21 41.48,114.21 40.55,115.14 40.55,116.33 35.41,121.47 25.67,121.47 22.64,124.49 19.25,124.49 10.79,132.96 10.79,149.78 8.8,151.76 8.8,158.85 v2(8.72,158.93)
I2C1_SCL_MUX: length 72.5
  TOP w0.127: U58.25 52.89,89.23 53.1,89.44 54.25,89.44 54.76,89.95 v2(54.77,89.95)
  L3-SIGNAL1 w0.089: v5(76.79,91.48) 77.12,91.15 77.12,85.57 77.43,85.27 78.34,85.27 80.01,83.6 86.89,83.6 88.17,84.88 88.87,84.88 90,83.75 90,83.52 90.65,82.87 91.32,82.87 98.98,75.2 99.79,75.2 101.01,73.98 102.03,73.98 103.59,75.54 106.84,75.54 107.44,76.14 107.85,76.14 108.22,76.51 108.22,76.76 108.39,76.93 108.9,76.93 109.2,76.63 v3(109.52,76.63)
  L4-GND2 w0.102: v6(76.81,91.78) 76.81,91.48 v5(76.79,91.48)
  L5-SIGNAL2 w0.102: v6(76.81,91.78) 74.7,91.78 72.29,89.37 55.35,89.37 v2(54.77,89.95)
  vias: v1(109.52,76.63)
I2C1_SDA: length 107.2
  TOP w0.127: v2(45.77,90.98) 45.52,90.73 U58.29 ; R90.2 v2(8.72,161.65)
  L12-SIGNAL5 w0.102: v2(8.72,161.65) 8.31,161.24 8.31,158.23 8.58,157.97 8.58,151.58 10.56,149.59 10.56,132.86 19.16,124.27 22.55,124.27 25.58,121.24 35.17,121.24 40.14,116.27 40.14,114.63 41.61,113.16 43.11,113.16 43.89,113.94 43.89,114.57 44.82,115.5 47.2,115.5 47.84,116.14 48.31,116.14 48.45,116 48.45,115.53 47.49,114.57 47.49,112.13 46.92,111.56 46.92,98.99 46.38,98.44 46.38,91.58 v2(45.77,90.98)
I2C1_SDA_MUX: length 69
  TOP w0.127: U58.27 52.89,90.23 53.2,90.53 54.33,90.53 54.76,90.96 v2(54.77,90.96)
  L3-SIGNAL1 w0.089: v5(90.71,81.97) 91.41,81.27 91.41,80.73 92.62,79.53 93.31,79.53 98.26,74.58 98.26,73.87 99.26,72.87 102.14,72.87 103.95,74.68 107.12,74.68 107.48,75.03 v3(107.92,75.03)
  L4-GND2 w0.102: v5(90.71,81.97) 90.71,82.3 v6(90.7,82.3)
  L5-SIGNAL2 w0.102: v6(90.7,82.3) 90.03,82.97 90.03,84.02 86.7,87.35 86.7,89.9 84.47,92.12 72.17,92.12 71.05,91.01 69.32,91.01 68.77,91.57 55.37,91.57 v2(54.77,90.96)
  vias: v1(107.92,75.03)
