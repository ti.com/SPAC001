# Allegro board PROC184E1_BRD.brd (continued)
## Nets (continued)
DGND: B1.2(-) C1.2 C2.1 C3.2 C4.2 C5.2 C6.1 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.1 C19.2 C20.1 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.1 C28.2 C30.2 C31.2 C32.2 C33.1 C34.2 C35.2 C36.2 C41.2 C42.1 C43.2 C48.2 C49.2 C50.2 C54.2 C55.1 C58.1 C59.2 C60.2 C64.1 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.1 C75.2 C76.1 C77.1 C78.1 C79.1 C80.2 C81.1 C82.1 C83.2 C84.2 C85.2 C86.2 C87.1 C88.2 C89.2 C90.1 C91.1 C92.2 C93.2 C95.2 C96.2 C97.2 C98.1 C99.1 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.1 C109.2 C110.2 C111.1 C112.2 C113.2 C114.1 C115.1 C116.2 C117.2 C118.2 C119.2 C120.2 C123.2 C124.2 C126.2 C130.2 C134.2 C136.2 C137.2 C138.2 C139.1 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C147.1 C148.2 C149.2 C150.1 C151.2 C152.2 C153.1 C157.2 C159.2 C160.2 C161.2 C162.1 C163.1 C164.2 C165.2 C166.1 C167.1 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.1 C187.1 C188.1 C190.2 C191.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.1 C199.2 C200.2 C203.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.1 C220.2 C221.1 C222.1 C223.2 C224.2 C225.2 C226.1 C227.2 C228.2 C229.2 C230.2 C231.2 C233.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C252.1 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C273.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.1 C296.2 C297.2 C298.2 C299.2 C300.1 C301.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.1 C314.2 C315.2 C316.1 C317.1 C318.2 C319.2 C320.2 C321.1 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.2 C331.2 C335.2 C336.2 C338.2 C339.2 C340.2 C341.2 C342.2 C343.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.1 C366.2 C370.2 C372.1 C373.1 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C388.2 C390.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C399.2 C400.2 C401.2 C403.2 C404.2 C405.2 C407.2 C408.1 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.1 C418.1 C419.2 C420.1 C421.2 C422.2 C423.2 C424.2 C425.2 C426.1 C427.2 C428.2 C429.2 C430.2 C431.2 C433.1 C435.2 C436.2 C437.2 C438.1 C439.2 C441.1 C442.2 C443.2 C444.2 C445.1 C446.1 C448.2 C449.1 C450.2 C451.1 C453.2 C454.2 C455.1 C456.2 C457.2 C458.2 C460.2 C461.2 C462.1 C463.1 C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.2 C486.1 C487.2 C489.2 C490.2 C492.2 C493.1 C494.1 C495.1 C496.1 C497.1 C498.1 C500.2 C501.2 C502.2 C504.2 C505.2 C507.2 C508.2 C509.1 C510.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.1 C520.2 C521.1 C522.2 C523.1 C524.2 C525.1 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.1 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.1 C548.1 C549.2 C550.2 C551.2 C552.2 C553.1 C554.1 C555.1 C556.1 C557.1 C558.1 C559.1 C560.2 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C567.2 C569.2 C570.1 C571.2 C572.2 C573.2 C574.2 C575.1 C576.2 C577.2 C578.1 C579.1 C580.2 C581.1 C582.1 C583.2 C584.1 C585.2 C586.2 C588.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.1 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.1 C650.2 C654.2 C655.2 C666.2 C667.2 C668.1 C676.1 C678.2 C681.2 C682.2 C685.2 C686.2 C691.2 C692.2 C693.2 C698.2 C700.2 C701.1 C702.1 C703.1 C704.2 C705.2 C706.2 C708.1 C709.2 C711.2 C712.2 C713.2 C715.2 C716.2 C717.1 C718.2 C719.2 C721.2 C723.2 C724.2 C725.2 C726.2 C729.2 C730.2 C731.2 C742.2 C743.2 C744.2 C746.2 C747.2 C749.2 C750.2 C751.2 C752.2 C753.2 C755.2 C756.2 C758.2 C762.2 C763.2 C764.2 C765.2 C766.2 C768.2 C769.2 C770.2 C773.2 C774.2 C776.2 C777.2 C778.2 C779.2 C780.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C798.2 C800.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C813.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C844.2 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C853.2 C854.2 C855.2 C856.2 C857.2 C859.2 C860.2 C862.2 C863.2 C864.2 C865.2 C866.2 C867.2 C870.2 C872.2 C873.2 C874.2 C875.2 C877.2 C878.2 C879.2 C880.2 C881.2 C882.2 C883.2 C884.2 C885.2 C886.2 C887.2 C888.2 C889.2 C890.2 C891.2 C892.2 C893.2 C894.2 C895.2 C897.2 C898.2 C899.2 C900.2 C901.2 C902.1 C904.2 C906.2 C907.1 C908.2 C909.2 C910.2 C912.2 C913.2 C914.2 C915.2 C916.2 C917.1 C918.2 C920.2 C921.2 C922.2 C923.2 C926.2 C927.2 C928.2 C929.2 C930.2 C931.2 C932.2 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.2 C941.1 C942.2 C943.2 C944.2 C947.2 C948.2 C949.2 C952.2 C953.2 C954.2 C955.2 C957.2 C958.2 C959.2 C960.2 C962.2 C963.2 C965.2 C966.2 C967.2 C968.2 C969.2 C970.2 C971.2 C972.2 C973.2 C974.2 C977.2 C978.2 C979.2 C980.2 C981.2 C982.2 C983.2 C984.2 C985.2 C986.2 C988.2 C989.2 C990.2 C992.2 C993.2 C994.2 C995.2 C996.2 C997.2 C999.2 C1000.2 C1001.2 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1007.2 C1008.2 C1009.2 C1010.2 C1011.2 C1012.2 C1014.2 C1015.2 C1017.2 C1018.2 C1019.2 C1020.2 C1021.2 C1022.2 C1023.2 C1024.2 C1025.2 C1026.2 C1027.2 C1028.2 C1029.2 C1031.2 C1032.2 C1033.2 C1034.2 C1035.2 C1036.2 C1037.2 C1038.2 C1039.2 C1040.2 C1041.2 C1042.2 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1053.2 C1054.2 C1055.2 C1056.2 C1058.2 C1059.2 C1060.2 C1062.2 C1063.2 C1064.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.2 C1071.2 C1072.2 C1074.2 C1075.1 C1077.2 C1078.2 C1079.1 C1080.2 C1081.2 C1082.2 C1083.2 C1084.2 C1085.2 C1086.1 C1089.2 C1090.2 C1091.2 C1092.2 C1093.2 C1095.2 C1096.2 C1097.2 C1098.2 C1105.1 C1117.2 C1118.2 C1120.2 C1122.2 C1123.2 C1124.2 C1131.1 C1134.2 C1135.2 C1137.2 C1138.1 C1161.2 C1162.2 C1163.2 C1164.2 C1165.2 C1166.2 C1167.2 C1168.2 C1169.2 C1170.2 C1171.2 C1172.2 C1173.2 C1174.1 C1175.1 C1176.2 C1177.1 C1178.2 C1179.2 C1180.2 C1181.2 C1182.1 C1183.2 C1184.2 C1185.1 C1186.2 C1187.2 C1188.2 C1189.2 C1190.2 C1191.2 C1192.2 C1196.2 C1197.2 C1198.2 C1199.2 C1200.2 C1203.1 C1204.1 C1205.2 C1206.1 C1207.1 C1208.1 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1216.1 C1217.2 C1218.1 C1219.1 C1220.2 C1221.2 C1222.2 C1223.2 C1224.2 C1225.2 C1226.2 C1227.2 C1228.1 C1230.2 C1231.2 C1232.1 C1235.2 C1236.1 C1237.2 C1238.2 C1239.2 C1240.2 C1241.2 C1243.1 C1244.1 C1245.2 C1246.2 C1247.1 C1248.1 C1249.2 C1250.2 C1251.2 C1252.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1258.2 C1259.2 C1260.2 C1261.2 C1264.1 C1265.2 C1266.2 C1267.2 C1268.2 C1269.2 C1271.2 C1290.2 C1291.2 C1292.2 C1293.2 C2582.2 C2583.2 C2584.2 C2585.2 C2586.2 C2587.2 C2588.2 C2589.2 C2590.2 C2591.2 C2592.2 D1.2(GND) D2.2(GND) D3.2(GND) D4.2(GND) D5.2(GND) D6.2(GND) D7.2(GND) D8.2(GND) D9.2(GND) D10.2(GND) D11.2(GND) D12.2(GND) D13.2(GND) D14.2(GND) D15.2(GND) D16.2(GND) D17.2(GND) D18.2(GND) D19.2(GND) D20.2(GND) D21.2(GND) D22.2(GND) D23.2(GND) D24.2(GND) D25.2(GND) D26.2(GND) D27.2(GND) D28.2(GND) D29.2(ANODE) D30.2(ANODE) D33.2 D36.2(ANODE) D37.1 D39.2(ANODE) D41.2(ANODE) FL1.2(GND1) FL2.2(GND1) FL3.2(GND1) FL4.2(GND1) FL5.2(GND1) FL6.2(GND1) FL8.2(GND1) FL9.2(GND1) FL10.2 FL10.4 FL11.2 FL11.4 FL12.2 FL12.4 FL13.2 FL13.4 FL14.2 FL14.4 FL15.2 FL15.4 FL16.2 FL16.4 FL17.2 FL17.4 FL18.2 FL18.4 FL19.2 FL19.4 FL20.2 FL20.4 FL21.2 FL21.4 FL22.2 FL22.4 FL23.2 FL23.4 FL24.2 FL24.4 FL25.2 FL25.4 FL26.2(GND1) FL27.2(GND1) FL32.2 FL32.4 FL33.2 FL33.4 FL34.2 FL34.4 FL35.2 FL35.4 FL40.2 FL40.4 FL41.2 FL41.4 FL43.2 FL43.4 FL44.2 FL44.4 FL45.2 FL45.4 FL46.2 FL46.4 FL47.2 FL47.4 FL48.2 FL48.4 FL122.2 FL122.4 FL137.2 FL137.4 FL141.2 FL141.4 FL150.2 FL150.4 FL154.2 FL154.4 FL170.2 FL170.4 FL177.2 FL177.4 FL193.2 FL193.4 J1.5(GND) J2.4 J3.1 J4.A1(GND#A1) J4.A12(GND#A12) J4.B1(GND#B1) J4.B12(GND#B12) J5.4 J5.8 J7.3 J7.4 J7.5 J7.6 J7.7 J7.SH1 J7.SH2 J7.SH3 J7.SH4 J8.2(GND#2) J8.5(GND#5) J8.8(GND#8) J8.11(GND#11) J8.16(GND#16) J8.19(RETURN) J8.SH1 J8.SH2 J8.SH3 J8.SH4 J9.2(GND#2) J9.5(GND#5) J9.8(GND#8) J9.11(GND#11) J9.16(GND#16) J9.19(RETURN) J9.SH1 J9.SH2 J9.SH3 J9.SH4 J10.6 J10.12 J10.16 J10.24 J10.SH1 J10.SH2 J10.SH3 J10.SH4 J14.A4(GND#A4) J14.A12(GND#A12) J14.A15(GND#A15) J14.A18(GND#A18) J14.A20(GND#A20) J14.A23(GND#A23) J14.A24(GND#A24) J14.A27(GND#A27) J14.A28(GND#A28) J14.A31(GND#A31) J14.B4(GND#B4) J14.B7(GND#B7) J14.B13(GND#B13) J14.B16(GND#B16) J14.B18(GND#B18) J14.B21(GND#B21) J14.B22(GND#B22) J14.B25(GND#B25) J14.B26(GND#B26) J14.B29(GND#B29) J14.B32(GND#B32) J17.A4(GND#A4) J17.A12(GND#A12) J17.A15(GND#A15) J17.A18(GND#A18) J17.A20(GND#A20) J17.A23(GND#A23) J17.A24(GND#A24) J17.A27(GND#A27) J17.A28(GND#A28) J17.A31(GND#A31) J17.B4(GND#B4) J17.B7(GND#B7) J17.B13(GND#B13) J17.B16(GND#B16) J17.B18(GND#B18) J17.B21(GND#B21) J17.B22(GND#B22) J17.B25(GND#B25) J17.B26(GND#B26) J17.B29(GND#B29) J17.B32(GND#B32) J23.16 J23.57 J23.61(SH1) J23.62(SH2) J23.63(SH3) J23.64(SH4) J24.3 J25.1 J26.6 J27.1 J27.7 J27.8 J27.13 J27.14 J27.19 J27.20 J28.4 J29.1A J29.1B J30.3 J37.2 J39.1(CH-GND) J40.1(CH-GND) J41.2 J42.2 J43.2 J44.2 J45.2 J46.2 J47.1 J48.5(GND) J49.5(GND) J50.7 J50.16 J50.25 J50.34 J50.40 J50.41 J50.42 J53.6(VSS) J53.10 J53.11 J53.12(CD2) J53.13 J53.14 J54.1 J54.3 J54.5 J54.19 J54.20 J54.37 J54.38 J54.51 J54.52 J54.67 J54.68 J54.81 J54.82 J54.95 J54.96 J54.107 J54.108 J54.119 J54.120 J54.121 J54.122 J54.123 J54.124 J54.125 J54.126 J54.127 J54.128 J55.12 J55.16 J55.24 J55.SH1 J55.SH2 J55.SH3 J55.SH4 J56.1 J56.3 J56.5 J56.39 J56.40 J56.67 J56.68 J56.77 J56.79 J56.81 J56.105 J56.119 J56.120 J56.121 J56.122 J56.123 J56.124 J56.125 J56.126 J56.127 J56.128 J57.12 J57.16 J57.24 J57.SH1 J57.SH2 J57.SH3 J57.SH4 L1.2 LD1.1(CATHODE) LD4.1 LD6.1(CATHODE) LD7.1 LD8.1 LD9.1 Q1.2(S) Q2.2(S) Q3.1(S1) Q4.1(S1) R14.1 R15.1 R17.2 R18.2 R20.1 R21.1 R22.2 R24.2 R25.1 R26.2 R27.1 R28.2 R31.1 R32.1 R33.1 R34.1 R35.1 R36.1 R37.1 R38.1 R39.1 R40.1 R41.1 R42.1 R44.1 R47.1 R48.1 R51.1 R59.1 R64.1 R66.2 R70.2 R73.1 R76.2 R79.1 R82.1 R84.1 R97.1 R114.1 R129.2 R130.2 R132.1 R133.2 R141.2 R161.1 R183.1 R189.2 R190.2 R192.2 R193.2 R195.2 R197.2 R198.2 R201.2 R203.2 R204.2 R210.2 R211.2 R216.2 R218.2 R221.2 R222.2 R228.2 R231.2 R237.1 R239.2 R240.2 R247.1 R248.2 R249.2 R251.2 R256.2 R262.2 R265.2 R331.1 R337.1 R342.1 R354.2 R358.2 R361.2 R396.2 R401.1 R405.2 R407.2 R409.1 R410.1 R420.1 R423.1 R431.1 R436.1 R437.1 R442.1 R447.2 R451.1 R455.1 R457.1 R459.1 R461.1 R466.2 R468.1 R469.1 R475.1 R479.1 R484.1 R486.1 R492.2 R497.1 R498.1 R503.1 R515.1 R521.1 R524.1 R530.1 R531.1 R533.2 R534.2 R537.1 R539.1 R540.2 R543.2 R545.1 R549.1 R552.1 R554.1 R560.2 R564.2 R566.2 R567.1 R568.1 R578.2 R587.1 R597.1 R599.1 R607.2 R608.2 R609.2 R615.2 R619.2 R621.2 R622.2 R628.1 R635.1 R637.1 R641.2 R652.1 R654.2 R655.2 R659.1 R660.1 R663.1 R676.1 R686.1 R687.2 R693.1 R695.1 R696.1 R697.1 R698.1 R703.1 R704.1 R710.1 R728.2 R729.2 R730.1 R737.1 R741.2 R743.2 R754.2 R755.2 R756.1 R757.2 R758.2 R759.1 R760.1 R762.1 R765.1 R769.2 R770.1 R773.2 R782.2 R786.2 R790.2 R793.2 R797.1 R798.2 R799.2 R803.2 R804.2 R807.2 R814.1 R816.2 R819.1 R822.1 R824.2 R833.1 R845.2 R849.2 R851.2 R853.1 R857.2 R861.2 R862.2 R865.2 R873.2 R874.2 R881.1 R884.2 R890.2 R894.2 R895.2 R896.2 R897.1 R901.2 R914.2 R915.2 R917.2 R918.2 R920.2 R932.2 R938.2 R941.2 R945.2 R946.2 R947.2 R948.2 R949.2 R951.2 R953.2 R965.2 R970.2 R976.1 R979.2 R981.2 R984.2 R998.2 R1018.2 R1022.2 R1023.2 R1027.2 R1030.1 R1032.2 R1037.2 R1042.2 R1047.1 R1055.2 R1064.2 R1073.1 R1079.1 R1087.1 R1088.1 R1100.2 R1120.2 R1122.1 R1127.2 R1132.1 R1168.1 R1177.1 R1182.1 R1183.1 R1184.1 R1189.1 R1194.2 R1196.1 R1197.2 R1198.2 R1199.2 R1200.2 R1223.2 R1224.2 R1227.1 R1228.1 R1230.1 R1231.2 R1232.2 R1233.1 R1243.2 R1244.2 R1252.2 R1253.2 R1254.2 R1255.2 R1256.2 R1257.1 R1258.1 R1259.1 R1262.1 R1263.2 R1264.2 R1273.1 R1297.1 SW3.1 SW3.4 SW5.1 SW5.4 SW6.1 SW6.4 SW8.1 SW8.4 SW9.1 SW9.4 SW10.1 SW10.4 SW12.1 SW12.4 SW14.1 SW14.4 SW15.1 SW15.4 TP14.1(TP) TP21.1(TP) TP28.1(TP) TP33.1(TP) TP37.1(TP) TP77.1(TP) TP95.1(TP) TP96.1(TP) TP135.1(TP) TP168.1(TP) TP179.1(TP) TP184.1(TP) TP192.1(TP) TP205.1(TP) TP207.1(TP) TP208.1(TP) TP211.1(TP) TP249.1(TP) TP260.1(TP) TP323.1(TP) TP324.1(TP) TP325.1(TP) TP326.1(TP) TP331.1(TP) U2.3(GND) U3.1(A) U4.2(SOURCE) U5.3(GND) U6.6(GND) U6.9(PAD) U8.16(AGND) U8.25(PGND#25) U8.26(PGND#26) U8.27(PGND#27) U8.33(EP) U8.A1 U8.A2 U8.A3 U8.A4 U9.2(GND) U10.10(A8) U10.11(GND1) U10.12(GND2) U10.13(GND3) U10.14(B8) U11.65(EP) U12.5(GND) U13.1(ANODE) U14.3(GND) U15.3(GND) U16.2(GND) U18.6(GND) U18.17(EP) U19.8(GND) U20.1(GND) U22.25(GND) U23.5(GND#5) U23.9(GND#9) U23.16(GND#16) U24.1(S1) U24.2(S2) U24.3(S3) U25.3(FB2) U25.14(PGND2) U25.17(PGND1) U25.35(AGND) U25.41(EP) U26.B2(VSS#B2) U26.B11(VSS#B11) U26.B12(VSS#B12) U26.C1(VSS#C1) U26.C2(VSS#C2) U26.C3(VSS#C3) U26.C11(VSS#C11) U26.C12(VSS#C12) U26.D3(VSS#D3) U26.D12(VSS#D12) U26.D13(VSS#D13) U26.D14(VSS#D14) U26.E1(VSS#E1) U26.E2(VSS#E2) U26.E3(VSS#E3) U26.E12(VSS#E12) U26.F3(VSS#F3) U26.F12(VSS#F12) U26.F13(VSS#F13) U26.F14(VSS#F14) U26.G1(VSS#G1) U26.G2(VSS#G2) U26.G3(VSS#G3) U26.G10(VSS#G10) U26.G12(VSS#G12) U26.H3(VSS#H3) U26.H5(VSS#H5) U26.H10(VSS#H10) U26.H12(VSS#H12) U26.H13(VSS#H13) U26.H14(VSS#H14) U26.J1(VSS#J1) U26.J2(VSS#J2) U26.J3(VSS#J3) U26.J5(VSS#J5) U26.J12(VSS#J12) U26.K3(VSS#K3) U26.K5(VSS#K5) U26.K12(VSS#K12) U26.K13(VSS#K13) U26.K14(VSS#K14) U26.L1(VSS#L1) U26.L2(VSS#L2) U26.L3(VSS#L3) U26.L12(VSS#L12) U26.M3(VSS#M3) U26.M4(VSS#M4) U26.M5(VSS#M5) U26.M12(VSS#M12) U26.M13(VSS#M13) U26.M14(VSS#M14) U26.N2(VSS#N2) U26.N3(VSS#N3) U26.N4(VSS#N4) U26.N5(VSS#N5) U26.N11(VSS#N11) U26.N12(VSS#N12) U26.P4(VSS#P4) U26.P5(VSS#P5) U26.P11(VSS#P11) U26.P12(VSS#P12) U27.1(S1) U27.2(S2) U27.3(S3) U29.7(GND) U31.C1(GND) U32.7(GND) U33.3(GND) U34.2(GND) U35.6(GND#6) U35.8(GND#8) U35.17(EP) U36.6(GND#6) U36.8(GND#8) U36.12(SDA) U36.13(SCL) U36.15(VSEL) U36.17(EP) U37.6(GND#6) U37.8(GND#8) U37.12(SDA) U37.13(SCL) U37.15(VSEL) U37.17(EP) U38.3(GND) U39.3(GND) U40.25(GND) U41.3(GND) U41.7(EP) U42.2(GOSNS) U42.6(GND#6) U42.8(GND#8) U42.17(EP) U43.9(GND) U43.25(PAD) U44.1(S1) U44.2(S2) U44.3(S3) U46.14(PGND2) U46.17(PGND1) U46.35(AGND) U46.37(OSC) U46.38(SYNIN) U46.41(EP) U47.8(GND) U48.2(GOSNS) U48.6(GND#6) U48.8(GND#8) U48.12(SDA) U48.13(SCL) U48.15(VSEL) U48.17(EP) U50.8(GND#8) U50.19(GND#19) U50.38(GND#38) U50.49(GND#49) U51.1(S1) U51.2(S2) U51.3(S3) U52.A6(VSS#A6) U52.C4(VSSQ#C4) U52.E7(VSS#E7) U52.G5(VSS#G5) U52.H10(VSS#H10) U52.J5(VSS#J5) U52.K8(VSS#K8) U52.N2(VSSQ#N2) U52.N5(VSSQ#N5) U52.P4(VSSQ#P4) U52.P6(VSSQ#P6) U53.4(GND) U54.A3(VSS#A3) U54.A10(VSS#A10) U54.AB3(VSS#AB3) U54.AB5(VSS#AB5) U54.AB8(VSS#AB8) U54.AB10(VSS#AB10) U54.C1(VSS#C1) U54.C5(VSS#C5) U54.C8(VSS#C8) U54.C12(VSS#C12) U54.D2(VSS#D2) U54.D4(VSS#D4) U54.D9(VSS#D9) U54.D11(VSS#D11) U54.E1(VSS#E1) U54.E5(VSS#E5) U54.E8(VSS#E8) U54.E12(VSS#E12) U54.G1(VSS#G1) U54.G3(VSS#G3) U54.G5(VSS#G5) U54.G8(VSS#G8) U54.G10(VSS#G10) U54.G12(VSS#G12) U54.J1(VSS#J1) U54.J3(VSS#J3) U54.J10(VSS#J10) U54.J12(VSS#J12) U54.K2(VSS#K2) U54.K4(VSS#K4) U54.K9(VSS#K9) U54.K11(VSS#K11) U54.N2(VSS#N2) U54.N4(VSS#N4) U54.N9(VSS#N9) U54.N11(VSS#N11) U54.P1(VSS#P1) U54.P3(VSS#P3) U54.P10(VSS#P10) U54.P12(VSS#P12) U54.T1(VSS#T1) U54.T3(VSS#T3) U54.T5(VSS#T5) U54.T8(VSS#T8) U54.T10(VSS#T10) U54.T12(VSS#T12) U54.V1(VSS#V1) U54.V5(VSS#V5) U54.V8(VSS#V8) U54.V12(VSS#V12) U54.W2(VSS#W2) U54.W4(VSS#W4) U54.W9(VSS#W9) U54.W11(VSS#W11) U54.Y1(VSS#Y1) U54.Y5(VSS#Y5) U54.Y8(VSS#Y8) U54.Y12(VSS#Y12) U55.2(GND) U56.1(A1) U56.2(A0) U56.7(GND) U57.B3(A0) U57.C1(GND) U57.C3(A1) U58.8(GND#8) U58.19(GND#19) U58.38(GND#38) U58.49(GND#49) U59.A1(VSS#A1) U59.A4(VSS#A4) U59.A7(VSS#A7) U59.A23(VSS#A23) U59.A25(VSS#A25) U59.A27(VSS#A27) U59.A29(VSS#A29) U59.A31(VSS#A31) U59.AA2(VSS#AA2) U59.AA5(VSS#AA5) U59.AA9(VSS#AA9) U59.AA11(VSS#AA11) U59.AA13(VSS#AA13) U59.AA15(VSS#AA15) U59.AA17(VSS#AA17) U59.AA19(VSS#AA19) U59.AA21(VSS#AA21) U59.AA23(VSS#AA23) U59.AA25(VSS#AA25) U59.AA27(VSS#AA27) U59.AA29(VSS#AA29) U59.AA31(VSS#AA31) U59.AA33(VSS#AA33) U59.AB1(VSS#AB1) U59.AB4(VSS#AB4) U59.AB8(VSS#AB8) U59.AB10(VSS#AB10) U59.AB12(VSS#AB12) U59.AB14(VSS#AB14) U59.AB18(VSS#AB18) U59.AB20(VSS#AB20) U59.AB22(VSS#AB22) U59.AB24(VSS#AB24) U59.AB26(VSS#AB26) U59.AB28(VSS#AB28) U59.AB30(VSS#AB30) U59.AB32(VSS#AB32) U59.AC2(VSS#AC2) U59.AC5(VSS#AC5) U59.AC9(VSS#AC9) U59.AC13(VSS#AC13) U59.AC15(VSS#AC15) U59.AC17(VSS#AC17) U59.AC19(VSS#AC19) U59.AC21(VSS#AC21) U59.AC23(VSS#AC23) U59.AC25(VSS#AC25) U59.AC27(VSS#AC27) U59.AD3(VSS#AD3) U59.AD6(VSS#AD6) U59.AD8(VSS#AD8) U59.AD10(VSS#AD10) U59.AD12(VSS#AD12) U59.AD14(VSS#AD14) U59.AD18(VSS#AD18) U59.AD22(VSS#AD22) U59.AD24(VSS#AD24) U59.AD26(VSS#AD26) U59.AD28(VSS#AD28) U59.AD29(VSS#AD29) U59.AD31(VSS#AD31) U59.AD33(VSS#AD33) U59.AE1(VSS#AE1) U59.AE4(VSS#AE4) U59.AE7(VSS#AE7) U59.AE13(VSS#AE13) U59.AE17(VSS#AE17) U59.AE19(VSS#AE19) U59.AE21(VSS#AE21) U59.AE23(VSS#AE23) U59.AE25(VSS#AE25) U59.AE27(VSS#AE27) U59.AE30(VSS#AE30) U59.AE32(VSS#AE32) U59.AF2(VSS#AF2) U59.AF5(VSS#AF5) U59.AF8(VSS#AF8) U59.AF11(VSS#AF11) U59.AF14(VSS#AF14) U59.AF18(VSS#AF18) U59.AF20(VSS#AF20) U59.AF21(VSS#AF21) U59.AF24(VSS#AF24) U59.AF28(VSS#AF28) U59.AG3(VSS#AG3) U59.AG6(VSS#AG6) U59.AG9(VSS#AG9) U59.AG14(VSS#AG14) U59.AG18(VSS#AG18) U59.AG20(VSS#AG20) U59.AG25(VSS#AG25) U59.AG28(VSS#AG28) U59.AG29(VSS#AG29) U59.AG31(VSS#AG31) U59.AG33(VSS#AG33) U59.AH5(VSS#AH5) U59.AH12(VSS#AH12) U59.AH15(VSS#AH15) U59.AH18(VSS#AH18) U59.AH21(VSS#AH21) U59.AH24(VSS#AH24) U59.AH26(VSS#AH26) U59.AH28(VSS#AH28) U59.AH30(VSS#AH30) U59.AJ6(VSS#AJ6) U59.AJ8(VSS#AJ8) U59.AJ11(VSS#AJ11) U59.AJ14(VSS#AJ14) U59.AJ17(VSS#AJ17) U59.AJ20(VSS#AJ20) U59.AJ23(VSS#AJ23) U59.AJ26(VSS#AJ26) U59.AJ29(VSS#AJ29) U59.AJ32(VSS#AJ32) U59.AK4(VSS#AK4) U59.AK7(VSS#AK7) U59.AK10(VSS#AK10) U59.AK13(VSS#AK13) U59.AK16(VSS#AK16) U59.AK19(VSS#AK19) U59.AK22(VSS#AK22) U59.AK25(VSS#AK25) U59.AK28(VSS#AK28) U59.AK31(VSS#AK31) U59.AL3(VSS#AL3) U59.AL6(VSS#AL6) U59.AL9(VSS#AL9) U59.AL12(VSS#AL12) U59.AL15(VSS#AL15) U59.AL18(VSS#AL18) U59.AL21(VSS#AL21) U59.AL24(VSS#AL24) U59.AL27(VSS#AL27) U59.AL30(VSS#AL30) U59.AL33(VSS#AL33) U59.AM2(VSS#AM2) U59.AM5(VSS#AM5) U59.AM8(VSS#AM8) U59.AM11(VSS#AM11) U59.AM14(VSS#AM14) U59.AM17(VSS#AM17) U59.AM20(VSS#AM20) U59.AM23(VSS#AM23) U59.AM26(VSS#AM26) U59.AM29(VSS#AM29) U59.AM32(VSS#AM32) U59.AM33(VSS#AM33) U59.AN1(VSS#AN1) U59.AN4(VSS#AN4) U59.AN7(VSS#AN7) U59.AN10(VSS#AN10) U59.AN13(VSS#AN13) U59.AN16(VSS#AN16) U59.AN19(VSS#AN19) U59.AN22(VSS#AN22) U59.AN25(VSS#AN25) U59.AN28(VSS#AN28) U59.AN31(VSS#AN31) U59.AN32(VSS#AN32) U59.B3(VSS#B3) U59.B6(VSS#B6) U59.B22(VSS#B22) U59.B24(VSS#B24) U59.B26(VSS#B26) U59.B28(VSS#B28) U59.B30(VSS#B30) U59.B32(VSS#B32) U59.C2(VSS#C2) U59.C5(VSS#C5) U59.C11(VSS#C11) U59.C13(VSS#C13) U59.C15(VSS#C15) U59.C17(VSS#C17) U59.C21(VSS#C21) U59.C23(VSS#C23) U59.C25(VSS#C25) U59.C27(VSS#C27) U59.C29(VSS#C29) U59.C31(VSS#C31) U59.C33(VSS#C33) U59.D1(VSS#D1) U59.D4(VSS#D4) U59.D7(VSS#D7) U59.D26(VSS#D26) U59.D28(VSS#D28) U59.D30(VSS#D30) U59.D32(VSS#D32) U59.E3(VSS#E3) U59.E6(VSS#E6) U59.E8(VSS#E8) U59.E23(VSS#E23) U59.E25(VSS#E25) U59.E27(VSS#E27) U59.E29(VSS#E29) U59.E31(VSS#E31) U59.F2(VSS#F2) U59.F5(VSS#F5) U59.F7(VSS#F7) U59.F14(VSS#F14) U59.F16(VSS#F16) U59.F18(VSS#F18) U59.F20(VSS#F20) U59.F22(VSS#F22) U59.F24(VSS#F24) U59.G1(VSS#G1) U59.G4(VSS#G4) U59.G9(VSS#G9) U59.G11(VSS#G11) U59.G13(VSS#G13) U59.G15(VSS#G15) U59.G17(VSS#G17) U59.G19(VSS#G19) U59.G21(VSS#G21) U59.G23(VSS#G23) U59.G25(VSS#G25) U59.G27(VSS#G27) U59.H2(VSS#H2) U59.H5(VSS#H5) U59.H8(VSS#H8) U59.H10(VSS#H10) U59.H12(VSS#H12) U59.H14(VSS#H14) U59.H16(VSS#H16) U59.H18(VSS#H18) U59.H20(VSS#H20) U59.H22(VSS#H22) U59.H24(VSS#H24) U59.H26(VSS#H26) U59.H28(VSS#H28) U59.J1(VSS#J1) U59.J6(VSS#J6) U59.J7(VSS#J7) U59.J9(VSS#J9) U59.J13(VSS#J13) U59.J15(VSS#J15) U59.J17(VSS#J17) U59.J19(VSS#J19) U59.J21(VSS#J21) U59.K2(VSS#K2) U59.K5(VSS#K5) U59.K8(VSS#K8) U59.K12(VSS#K12) U59.K14(VSS#K14) U59.K16(VSS#K16) U59.K18(VSS#K18) U59.K20(VSS#K20) U59.K22(VSS#K22) U59.K27(VSS#K27) U59.K29(VSS#K29) U59.L3(VSS#L3) U59.L6(VSS#L6) U59.L7(VSS#L7) U59.L9(VSS#L9) U59.L11(VSS#L11) U59.L13(VSS#L13) U59.L15(VSS#L15) U59.L17(VSS#L17) U59.L19(VSS#L19) U59.L23(VSS#L23) U59.M1(VSS#M1) U59.M4(VSS#M4) U59.M8(VSS#M8) U59.M12(VSS#M12) U59.M14(VSS#M14) U59.M16(VSS#M16) U59.M18(VSS#M18) U59.M20(VSS#M20) U59.M22(VSS#M22) U59.M24(VSS#M24) U59.M28(VSS#M28) U59.N2(VSS#N2) U59.N5(VSS#N5) U59.N7(VSS#N7) U59.N9(VSS#N9) U59.N11(VSS#N11) U59.N13(VSS#N13) U59.N15(VSS#N15) U59.N17(VSS#N17) U59.N21(VSS#N21) U59.N23(VSS#N23) U59.N25(VSS#N25) U59.N29(VSS#N29) U59.P3(VSS#P3) U59.P10(VSS#P10) U59.P12(VSS#P12) U59.P14(VSS#P14) U59.P16(VSS#P16) U59.P18(VSS#P18) U59.P20(VSS#P20) U59.P22(VSS#P22) U59.P24(VSS#P24) U59.P26(VSS#P26) U59.R3(VSS#R3) U59.R6(VSS#R6) U59.R9(VSS#R9) U59.R11(VSS#R11) U59.R17(VSS#R17) U59.R19(VSS#R19) U59.R21(VSS#R21) U59.R23(VSS#R23) U59.R25(VSS#R25) U59.R28(VSS#R28) U59.T2(VSS#T2) U59.T5(VSS#T5) U59.T8(VSS#T8) U59.T10(VSS#T10) U59.T18(VSS#T18) U59.T20(VSS#T20) U59.T22(VSS#T22) U59.T24(VSS#T24) U59.T26(VSS#T26) U59.U1(VSS#U1) U59.U4(VSS#U4) U59.U7(VSS#U7) U59.U9(VSS#U9) U59.U11(VSS#U11) U59.U17(VSS#U17) U59.U23(VSS#U23) U59.U25(VSS#U25) U59.U27(VSS#U27) U59.U29(VSS#U29) U59.U33(VSS#U33) U59.V3(VSS#V3) U59.V6(VSS#V6) U59.V8(VSS#V8) U59.V10(VSS#V10) U59.V12(VSS#V12) U59.V18(VSS#V18) U59.V20(VSS#V20) U59.V22(VSS#V22) U59.V28(VSS#V28) U59.W2(VSS#W2) U59.W5(VSS#W5) U59.W9(VSS#W9) U59.W11(VSS#W11) U59.W17(VSS#W17) U59.W19(VSS#W19) U59.W23(VSS#W23) U59.W27(VSS#W27) U59.W29(VSS#W29) U59.Y1(VSS#Y1) U59.Y6(VSS#Y6) U59.Y8(VSS#Y8) U59.Y10(VSS#Y10) U59.Y12(VSS#Y12) U59.Y18(VSS#Y18) U59.Y20(VSS#Y20) U59.Y22(VSS#Y22) U59.Y26(VSS#Y26) U59.Y28(VSS#Y28) U60.1(A1) U60.2(A0) U60.7(GND) U61.B3(A0) U61.C1(GND) U61.C3(A1) U62.5(GND) U62.9(EP) U63.3(GND) U63.7(EP) U64.C1(GND) U64.C3(A1) U65.1(A1) U65.7(GND) U66.3(GND) U66.7(EP) U67.3(GND#3) U67.7(GND#7) U68.5(REFGND1) U68.6(REFGND2) U68.21(FB_B2) U68.36(VBACKUP) U68.57(GND) U69.2(S) U70.1(S1) U71.A3(VSS#A3) U71.A10(VSS#A10) U71.AB3(VSS#AB3) U71.AB5(VSS#AB5) U71.AB8(VSS#AB8) U71.AB10(VSS#AB10) U71.C1(VSS#C1) U71.C5(VSS#C5) U71.C8(VSS#C8) U71.C12(VSS#C12) U71.D2(VSS#D2) U71.D4(VSS#D4) U71.D9(VSS#D9) U71.D11(VSS#D11) U71.E1(VSS#E1) U71.E5(VSS#E5) U71.E8(VSS#E8) U71.E12(VSS#E12) U71.G1(VSS#G1) U71.G3(VSS#G3) U71.G5(VSS#G5) U71.G8(VSS#G8) U71.G10(VSS#G10) U71.G12(VSS#G12) U71.J1(VSS#J1) U71.J3(VSS#J3) U71.J10(VSS#J10) U71.J12(VSS#J12) U71.K2(VSS#K2) U71.K4(VSS#K4) U71.K9(VSS#K9) U71.K11(VSS#K11) U71.N2(VSS#N2) U71.N4(VSS#N4) U71.N9(VSS#N9) U71.N11(VSS#N11) U71.P1(VSS#P1) U71.P3(VSS#P3) U71.P10(VSS#P10) U71.P12(VSS#P12) U71.T1(VSS#T1) U71.T3(VSS#T3) U71.T5(VSS#T5) U71.T8(VSS#T8) U71.T10(VSS#T10) U71.T12(VSS#T12) U71.V1(VSS#V1) U71.V5(VSS#V5) U71.V8(VSS#V8) U71.V12(VSS#V12) U71.W2(VSS#W2) U71.W4(VSS#W4) U71.W9(VSS#W9) U71.W11(VSS#W11) U71.Y1(VSS#Y1) U71.Y5(VSS#Y5) U71.Y8(VSS#Y8) U71.Y12(VSS#Y12) U72.4(VSS) U73.4(VSS) U75.5(GND) U75.9(EP) U76.6(GND) U76.17(EP) U78.4(GND) U79.B3(VSS) U80.2(1DIR) U80.3(2DIR) U80.8(GND1) U80.9(GND2) U80.14(2\O\E\) U80.15(1\O\E\) U81.3(AGND) U81.6(OSC) U81.9(PGND) U81.16(VCCX) U81.25(EP) U81.A1 U81.A2 U81.A3 U81.A4 U82.2(GND) U83.7(GND) U84.C1(GND) U85.3(GND) U85.7(EP) U86.3(GND) U87.6(GND) U87.11(RS_1/2) U87.17(TPAD) U88.1(GND) U89.6(GND) U89.11(RS_1/2) U89.17(TPAD) U92.3(GND) U93.B3(A0) U93.C1(GND) U94.2(A0) U94.7(GND) U97.3(GND) U98.10(GND) U99.C1(GND) U100.7(GND) U101.3(GND) U102.3(GND) U103.3(GND) U104.2(GND) U105.B3(A0) U105.C1(GND) U106.2(A0) U106.7(GND) U107.3(GND) U108.8(GND) U109.8(GND) U109.15(EP) U110.2(GND) U111.3(GND) U112.8(GND) U113.2(D) U113.4(GND) U114.C1(GND) U114.C3(A1) U115.1(A1) U115.7(GND) U116.C1(GND) U117.7(GND) U118.1(A1) U118.7(GND) U119.C1(GND) U119.C3(A1) U120.7(GND) U121.C1(GND) U122.2(GND#2) U122.4(GND#4) U122.6(GND#6) U123.2(GND) U124.2(GND) U125.6(GND) U125.11(PAD) U126.2(SOURCE) U127.3(GND) U128.1(A1) U128.7(GND) U129.C1(GND) U129.C3(A1) U130.2(GND) U131.2(GND) U132.6(GND) U132.17(EP) U133.2(SOURCE) U134.3(GND) U135.4(V-) U136.4(V-) U137.2(S) U138.6(GND) U138.11(PAD) U139.1(GND) U139.7(PAD) U140.2(SOURCE) U141.4(V-) U142.1(GND) U142.7(PAD) U143.2(1DIR) U143.7(2A2) U143.8(GND1) U143.9(GND2) U143.14(2\O\E\) U143.15(1\O\E\) U144.1(GND#1) U144.5(GND#5) U144.10(AGND) U144.11(GND#11) U144.13(TEST) U144.15(GND#15) U144.25(GND#25) U144.35(GND#35) U144.47(GND#47) U144.51(GND#51) U145.1(GND1) U145.5(GND2) U145.10(AGND) U145.11(GND3) U145.13(TEST) U145.15(GND4) U145.25(GND5) U145.35(GND6) U145.47(GND7) U145.51(GND8) U146.4(V-) U147.5(VSS) U148.2(GND) U149.2(GND) U150.2(GND) U151.2(GND) U152.2(GND) U153.2(GND) U154.2(AGNDAD2) U154.11(DGND2) U154.16(AGNDDA1) U154.33(AGNDDA2) U154.47(DGND1) U154.50(AGNDAD1) U154.65(EP) U155.3(GND) U156.4(GND) U157.4(GND) U158.10(GND) U160.2(GND) U161.3(GND) U162.2(SOURCE) U163.2(GND) U164.3(GND) U165.2(A) U165.3(GND) U167.3(GND) U168.3(GND) U169.6(GND) U169.11(PAD) U170.10(GNDA) U170.17(GND#17) U170.48(GND#48) U170.55(GND#55) U170.58(GND#58) U170.64(W\A\K\E\) U170.66(XOSC0) U170.80(GND#80) U170.114(GND#114) U171.B3(A0) U171.C1(GND) U172.2(A0) U172.7(GND) U173.25(GND) U173.33(EP) U174.6(GND) U174.11(PAD) U175.3(GND) U176.3(GND) U177.8(GND) U179.2(SOURCE) U181.7(GND) U182.6(GND) U183.2(GND) U184.7(GND) U185.C1(GND) U186.6(GND) U186.11(PAD) U187.23(GND#23) U187.26(GND#26) U187.52(GND#52) U187.64(GND#64) U187.65(GND#65) U188.C1(GND) U189.7(GND) U190.3(GND) U191.4(GND) U192.C1(GND) U193.7(GND) U194.B3(A0) U194.C1(GND) U195.2(A0) U195.7(GND) U196.3(GND) U197.4(GND) U198.C1(GND) U199.7(GND) U200.4(GND) U201.3(GND#3) U201.7(GND#7) U202.4(GND) U203.7(GND) U204.C1(GND) U206.8(GND) U207.C1(GND) U208.7(GND) U209.2(A0) U209.7(GND) U210.B3(A0) U210.C1(GND) U211.C1(GND) U212.7(GND) U213.3(GND) U214.C1(GND) U214.C3(A1) U215.1(A1) U215.7(GND) U216.2(S) U217.2(S) U218.1(A1) U218.7(GND) U219.C1(GND) U219.C3(A1) U220.3(GND) U221.7(GND) U222.C1(GND) U223.C1(GND) U224.7(GND) U225.B3(A0) U225.C1(GND) U226.2(A0) U226.7(GND) U227.8(GND) U228.2(SDX) U228.3(SCX) U228.6(GND#6) U228.7(GND#7) U229.2(A0) U229.7(GND) U230.C1(GND) U231.C1(GND) U232.7(GND) U233.11(GND1) U233.12(GND2) U233.13(GND3) U233.25(EP) U234.3(GND) U235.C1(GND) U236.7(GND) U238.C1(GND) U239.7(GND) U240.1(S1) U240.2(S2) U240.3(S3) U241.43(GND) U242.11(GND) U242.21(PAD) U243.25(GND) U243.33(EP) U244.8(GND1) U244.9(GND2) U245.B3(GND) U245.C1(VSSQ#C1) U245.E5(VSSQ#E5) U246.B3(VSS) U246.C1(VSSQ#C1) U246.E5(VSSQ#E5) U247.3(GND) U248.8(GND1) U248.9(GND2) U249.2(GND) U250.4(GND) U251.2(GND) U252.2(GND) U253.3(GND) U254.3(GND) U255.2(GND) U256.4(VSS) U257.3(GND) U258.2(GND) U259.2(1DIR) U259.8(GND1) U259.9(GND2) U259.14(2\O\E\) U260.6(GND) U260.11(PAD) U261.49(EP) U262.49(EP) U263.2(SOURCE) U264.2(1DIR) U264.8(GND1) U264.9(GND2) U264.14(2\O\E\) U264.15(1\O\E\) U265.4(GND) U266.6(GND) U266.11(PAD) U267.4(V-) U268.8(GND) U269.7(GND) U270.2(1DIR) U270.7(2A2) U270.8(GND1) U270.9(GND2) U270.14(2\O\E\) U270.15(1\O\E\) U271.2(SOURCE) U272.2(SOURCE) U273.2(1DIR) U273.8(GND1) U273.9(GND2) U273.14(2\O\E\) U273.15(1\O\E\) U274.3(GND) U275.5(VSS) U276.2(GND) U277.2(GND) U278.3(GND) U279.2(GND) U281.1(IN1) U281.2(GND) U5028.2 U5028.4 U5029.2 U5029.4 U5030.2 U5030.4 U5031.2 U5031.4 U5036.2 U5036.4 U5037.2 U5037.4 U5038.2 U5038.4 U5039.2 U5039.4 U5049.2 U5049.4 U5050.2 U5050.4 U5051.2 U5051.4 U5052.2 U5052.4 U5053.2 U5053.4 U5054.2 U5054.4 U5055.2 U5055.4 U5064.2 U5064.4 U5072.2 U5072.4 U5073.2 U5073.4 U5074.2 U5074.4 U5075.2 U5075.4 U5077.2 U5077.4 U5078.2 U5078.4 U5079.2 U5079.4 U5080.2 U5080.4 U5090.2 U5090.4 U5091.2 U5091.4 U5092.2 U5092.4 U5093.2 U5093.4 U5099.2 U5099.4 U50100.2 U50100.4 U50101.2 U50101.4 U50102.2 U50102.4 U50103.2 U50103.4 U50104.2 U50104.4 U50105.2 U50105.4 U50106.2 U50106.4 U50107.2 U50107.4 U50108.2 U50108.4 U50109.2 U50109.4 U50110.2 U50110.4 U50111.2 U50111.4 U50112.2 U50112.4 U50113.2 U50113.4 U50114.2 U50114.4 U50115.2 U50115.4 U50116.2 U50116.4 U50117.2 U50117.4 U50118.2 U50118.4 U50119.2 U50119.4 U50120.2 U50120.4 U50121.2 U50121.4 U50123.2 U50123.4 U50124.2 U50124.4 U50125.2 U50125.4 U50126.2 U50126.4 U50127.2 U50127.4 U50128.2 U50128.4 U50129.2 U50129.4 U50130.2 U50130.4 U50131.2 U50131.4 U50133.2 U50133.4 U50134.2 U50134.4 U50135.2 U50135.4 U50136.2 U50136.4 U50138.2 U50138.4 U50139.2 U50139.4 U50140.2 U50140.4 U50142.2 U50142.4 U50143.2 U50143.4 U50144.2 U50144.4 U50145.2 U50145.4 U50146.2 U50146.4 U50147.2 U50147.4 U50148.2 U50148.4 U50149.2 U50149.4 U50152.2 U50152.4 U50153.2 U50153.4 U50156.2 U50156.4 U50157.2 U50157.4 U50158.2 U50158.4 U50159.2 U50159.4 U50160.2 U50160.4 U50162.2 U50162.4 U50163.2 U50163.4 U50164.2 U50164.4 U50165.2 U50165.4 U50166.2 U50166.4 U50167.2 U50167.4 U50168.2 U50168.4 U50169.2 U50169.4 U50171.2 U50171.4 U50172.2 U50172.4 U50174.2 U50174.4 U50178.2 U50178.4 U50179.2 U50179.4 U50183.2 U50183.4 U50184.2 U50184.4 U50185.2 U50185.4 U50186.2 U50186.4 U50187.2 U50187.4 U50188.2 U50188.4 U50189.2 U50189.4 U50191.2 U50191.4 U50192.2 U50192.4 Y5.2(GND1) Y5.4(GND2) Y6.2(GND1) Y6.4(GND2) Y9.2 Y9.4
V1V1_VDDUSB: C30.1 C41.1 C562.1 C563.1 C564.1 C589.1 C590.1 C592.1 C593.1 L20.2 U11.19(VDD#19) U11.25(VDD#25) U11.37(VDD#37) U11.45(VDD#45) U11.53(VDD#53) U11.60(VDD#60) U11.63(VDD#63)
V1V8_FT2232: C428.1 C445.2 C500.1 C513.1 TP243.1(TP) U144.12(VCORE#12) U144.37(VCORE#37) U144.49(VREGOUT) U144.64(VCORE#64)
V1V8_FT4232: C429.1 C449.2 C502.1 C516.1 TP322.1(TP) U145.12(VCORE#12) U145.37(VCORE#37) U145.49(VREGOUT) U145.64(VCORE#64)
V3V3_DP0: C23.1 C560.1 C579.2 C580.1 J9.20(PWR) R791.1 TP256.1(TP) U174.9(OUT1) U174.10(OUT2)
V3V3_DP1: C22.1 C565.1 C566.1 C570.2 J8.20(PWR) R766.1 TP255.1(TP) U169.9(OUT1) U169.10(OUT2)
V3V3_FT2232: C430.1 C456.1 C458.1 C480.1 C489.1 C521.2 C1217.1 C1235.1 C1252.1 C1255.1 L40.1 L43.1 R667.2 R669.2 R670.2 R701.2 R1284.2 TP244.1(TP) U144.20(VCCIO#20) U144.31(VCCIO#31) U144.42(VCCIO#42) U144.50(VREGIN) U144.56(VCCIO#56) U147.6(ORG*) U147.8(VCC) U259.16(VCCB) U270.16(VCCB)
V3V3_FT4232: C431.1 C457.1 C460.1 C481.1 C490.1 C501.1 C1214.1 C1239.1 C1254.1 C1256.1 C1264.2 L41.1 L42.1 R702.2 R1266.2 R1269.2 R1270.2 R1285.2 TP246.1(TP) U143.16(VCCB) U145.20(VCCIO#20) U145.31(VCCIO#31) U145.42(VCCIO#42) U145.50(VREGIN) U145.56(VCCIO#56) U264.16(VCCB) U273.16(VCCB) U275.6(ORG*) U275.8(VCC)
V3V3_REF_CDCI1: C164.1 C165.1 C166.2 FL8.3(OUT) U40.3(VDDREF)
V3V3_REF_CDCI2: C67.1 C71.1 C81.2 FL1.3(OUT) U22.3(VDDREF)
V3V3_VAUX_PCIE0: J14.B10(3.3VAUX) R825.2
V3V3_VAUX_PCIE1: J17.B10(3.3VAUX) R872.2
V3V3_VCO_CDCI1: C167.2 C168.1 C169.1 FL9.3(OUT) U40.24(VDDVCO)
V3V3_VCO_CDCI2: C98.2 C102.1 C104.1 FL6.3(OUT) U22.24(VDDVCO)
V3V3_VDD33USB: C567.1 C569.1 C573.1 C591.1 C594.1 L19.1 U11.2(VDD33#2) U11.20(VDD33#20) U11.31(VDD33#31) U11.48(VDD33#48)
V3V3_XDS_FB: C29.2 R17.1 R23.2 U6.5(NR/FB)
V5V0: C248.1 C252.2 R289.2 R308.1 R308.2 R308.3 R357.2 U46.6(VCCX)
V5V0_OPAMP: C448.1 C465.1 C473.1 C474.1 C518.1 C522.1 C1211.1 FL59.2 U135.8(V+) U136.8(V+) U141.8(V+) U146.8(V+)
V5V0_VOUT: C411.1 C412.1 C1230.1 FL56.2 R1229.2 R1274.2
V12V0_VOUT: C1237.1 C1249.1 C1250.1 FL198.2 U267.8(V+)
V12V0_VSUP1: C378.1 C1166.1 C1167.1 D42.2(A) D43.2(A) D44.1(K) D45.1(K) U109.10(VSUP)
VBAT_LIN: D45.2(A) J28.1
VBAT_RTC: B1.1(+) U256.3(VBAT)
VBAT_XDS: C550.1 R751.2 U170.68(VBAT)
VBUS_5V_CONN1: C21.1 C32.1 J5.1 U9.4(OUT)
VBUS_5V_CONN2: C11.1 C25.1 J5.5 U160.4(OUT)
VBUS_USBC_CONN: C1.1 J4.A4(VBUS1) J4.A9(VBUS2) J4.B4(VBUS3) J4.B9(VBUS4) R9.1 R732.2 TP1.1(TP) U1.8(DRAIN2) U8.15(BUS)
VBUS_XDS_USB: C13.1 J1.1(VBUS) R69.1 R749.2 TP2.1(TP) U2.6(VCC) U6.1(IN1) U6.2(IN2) U6.8(EN)
VCC1V2_UFS: C635.1 C636.1 C637.1 C638.1 C639.1 C640.1 C641.1 C642.1 FL62.1 U26.A4(VCCQ#A4) U26.A5(VCCQ#A5) U26.B4(VCCQ#B4) U26.B5(VCCQ#B5) U26.C4(VCCQ#C4) U26.C5(VCCQ#C5) U26.E5(VCCQ#E5) U26.F5(VCCQ#F5)
VCC1V8_EMMC: C789.1 C802.1 C803.1 C804.1 R274.1 R278.1 R284.1 R293.1 R299.1 R307.1 R317.1 R322.1 R960.1 R961.1 R966.1 U52.C6(VCCQ#C6) U52.M4(VCCQ#M4) U52.N4(VCCQ#N4) U52.P3(VCCQ#P3) U52.P5(VCCQ#P5)
VCC1V8_UFS: C609.1 C610.1 C612.1 C620.1 C631.1 C632.1 C633.1 C634.1 FL60.1 U26.A6(VCCQ2#A6) U26.A7(VCCQ2#A7) U26.B6(VCCQ2#B6) U26.B7(VCCQ2#B7) U26.C6(VCCQ2#C6) U26.C7(VCCQ2#C7) U26.K6(VCCQ2#K6) U26.K7(VCCQ2#K7)
VCC3V3_EMMC: C786.1 C788.1 C790.1 FL98.2 U52.E6(VCC#E6) U52.F5(VCC#F5) U52.J10(VCC#J10) U52.K9(VCC#K9)
VCC3V3_UFS: C613.1 C614.1 C615.1 C616.1 C617.1 C618.1 C619.1 FL61.1 U26.B8(VCC#B8) U26.B9(VCC#B9) U26.C8(VCC#C8) U26.C9(VCC#C9) U26.E8(VCC#E8) U26.K8(VCC#K8) U26.N8(VCC#N8) U26.N9(VCC#N9) U26.P8(VCC#P8) U26.P9(VCC#P9)
VCC3V3_XDS: C14.1 C15.1 C18.2 C24.1 C29.1 C31.1 C59.1 C60.1 C551.1 C598.1 C599.1 R19.2 R23.1 R49.2 R52.1 R139.1 R140.1 R736.1 R738.1 R742.1 R751.1 R761.2 R767.2 R768.2 R784.2 R789.2 R952.1 R1304.2 TP13.1(TP) U6.3(OUT1) U6.4(OUT2) U10.23(VCCB1) U10.24(VCCB2) U170.7(VDD#7) U170.8(VDDA) U170.16(VDD#16) U170.26(VDD#26) U170.28(VDD#28) U170.39(VDD#39) U170.47(VDD#47) U170.51(VDD#51) U170.52(VDD#52) U170.69(VDD#69) U170.79(VDD#79) U170.90(VDD#90) U170.101(VDD#101) U170.113(VDD#113) U170.122(VDD#122)
VCC_1V1: C49.1 C423.1 C442.1 C477.1 C1180.1 C1181.1 C1191.1 C1225.1 C1228.2 C1231.1 L20.1 R1265.1 TP240.1(TP) U262.6(VDDA1P0) U262.24(VDD1P0#24) U262.31(VDD1P0#31) U262.42(VDD1P0#42) U266.9(OUT1) U266.10(OUT2)
VCC_1V2: C136.1 C142.1 C148.1 C151.1 C157.1 C604.1 C605.1 C682.1 C700.1 C701.2 FL62.2 FL63.2 R866.1 R875.1 TP259.1(TP) U186.9(OUT1) U186.10(OUT2) U187.17(VCC#17) U187.33(VCC#33) U187.49(VCC#49) U187.59(VCC#59) U187.62(VCC#62)
VCC_12V0: C26.1 C27.2 C28.1 C118.1 C259.1 C407.1 C410.1 C537.2 C611.1 C692.1 C693.1 C879.1 C886.1 C906.1 C907.2 C937.1 C1259.1 C1265.1 D44.2(A) FL198.1 J14.A2(+12V#A2) J14.A3(+12V#A3) J14.B1(+12V#B1) J14.B2(+12V#B2) J14.B3(+12V#B3) J17.A2(+12V#A2) J17.A3(+12V#A3) J17.B1(+12V#B1) J17.B2(+12V#B2) J17.B3(+12V#B3) J24.2 J47.2 J54.2 J54.4 J54.6 J55.1 J55.3 J57.1 J57.3 R418.2 R465.1 R724.1 TP133.1(TP) U8.1(IN1) U8.2(IN2) U8.3(IN3) U148.10(VSUP)
VCC_12V0_IN+: C1057.2 R1082.1 U238.D3(IN+) U239.10(VIN+)
VCC_12V0_IN-: C1057.1 R1083.1 U238.D1(BUS) U238.D2(IN-) U239.8(VBUS) U239.9(VIN-)
VCC_12V0_N: R418.1 R1083.2
VCC_12V0_P: R418.4 R1082.2
VCC_CSI_IO: C316.2 C342.1 C810.1 C816.1 C1105.2 C1163.1 C1165.1 C1192.1 J55.38 J55.40 J57.38 J57.40 R501.1 R510.1 R1134.1 R1233.2 R1240.2 R1241.2 TP225.1(TP) U80.1(VCCA) U88.2(VREF1) U242.2(VCCA)
VCC_LM5140: C219.2 C222.2 D34.2(ANODE) D35.2(ANODE) U46.15(VCC#15) U46.16(VCC#16)
VCC_LM5141: C308.1 D38.2(ANODE) U81.10(VCC)
VCC_LM5143: C108.2 C114.2 D31.2(ANODE) D32.2(ANODE) U25.15(VCC#15) U25.16(VCC#16)
VCC_USBC_PD_5V: C6.2 C8.1 D40.2(ANODE) R746.1 R747.2 R748.2 TP4.1(TP) U8.21(VCC)
VCCA_1V2: C134.1 C137.1 C138.1 C140.1 C141.1 C152.1 C685.1 C711.1 C712.1 FL63.1 U187.3(VCCA#3) U187.14(VCCA#14) U187.18(VCCA#18) U187.31(VCCA#31) U187.36(VCCA#36) U187.41(VCCA#41) U187.43(VCCA#43) U187.48(VCCA#48)
VCCA_3V3: C176.1 C260.1 C261.1 C264.1 C265.1 C266.1 C278.1 C282.1 C284.1 C291.1 C296.1 C320.1 C331.1 C338.1 C353.1 C354.1 C438.2 C446.2 C928.1 C929.1 C963.1 C973.1 C985.1 C1001.1 C1015.1 C1025.1 C1035.1 C1039.1 C1050.1 C1269.1 FL40.1 FL40.3 FL41.1 FL41.3 L36.1 LD10.2 Q3.4(S2) R206.1 R220.1 R338.3 R417.1 R504.2 R538.2 R547.2 R627.2 R908.1 R982.1 R1063.2 R1277.2 R1278.2 R1309.1 R1310.1 TP30.1(TP) U30.1(S1) U30.2(S2) U30.3(S3) U41.6(IN) U62.1(VIN1) U62.2(VIN2) U62.4(VBIAS) U63.6(IN) U66.6(IN) U67.6(IN) U68.4(VCCA) U68.8(PVIN_LDO4) U68.10(PVIN_LDO3) U68.12(PVIN_LDO12) U68.35(PVIN_B5) U68.45(PVIN_B3) U68.48(VIO_IN) U68.54(PVIN_B4) U70.4(S2) U75.1(VIN1) U75.2(VIN2) U75.4(VBIAS) U85.6(IN) U87.8(VDD) U89.8(VDD) U139.6(VIN) U234.5(VCC) U279.5(VCC)
VCCA_3V3_CORE: FL22.1 FL22.3 FL23.1 FL23.3 FL24.1 FL24.3 FL25.1 FL25.3 FL32.1 FL32.3 FL33.1 FL33.3 FL34.1 FL34.3 FL35.1 FL35.3 R185.4 R185.6 R223.1 R234.1 R269.1 U42.5(VIN1) U42.9(VIN2) U42.11(MODE/SYNC) U48.5(VIN1) U48.9(VIN2)
VCCA_3V3_CORE_IN+: C722.2 R927.1 U203.10(VIN+) U204.D3(IN+)
VCCA_3V3_CORE_IN-: C722.1 R928.1 U203.8(VBUS) U203.9(VIN-) U204.D1(BUS) U204.D2(IN-)
VCCA_3V3_CORE_N: R185.5 R928.2 TP279.1(TP)
VCCA_3V3_CORE_P: R185.2 R927.2 TP278.1(TP)
VCCA_3V3_CPU_AVS: FL10.1 FL10.3 FL11.1 FL11.3 FL12.1 FL12.3 FL13.1 FL13.3 FL14.1 FL14.3 FL15.1 FL15.3 FL16.1 FL16.3 FL17.1 FL17.3 FL18.1 FL18.3 FL19.1 FL19.3 FL20.1 FL20.3 FL21.1 FL21.3 R180.4 R180.6 R188.1 R191.1 R194.1 R196.1 U35.5(VIN1) U35.9(VIN2) U35.11(MODE/SYNC) U36.5(VIN1) U36.9(VIN2) U37.5(VIN1) U37.9(VIN2)
VCCA_3V3_CPU_AVS_IN+: C146.2 R179.1 U31.D3(IN+) U32.10(VIN+)
VCCA_3V3_CPU_AVS_IN-: C146.1 R178.1 U31.D1(BUS) U31.D2(IN-) U32.8(VBUS) U32.9(VIN-)
VCCA_3V3_CPU_AVS_N: R178.2 R180.5 TP34.1(TP)
VCCA_3V3_CPU_AVS_P: R179.2 R180.2 TP35.1(TP)
VCCA_3V3_DDR: C293.1 C294.1 C1059.1 C1060.1 FL47.1 FL47.3 FL48.1 FL48.3 R338.2 U68.17(PVIN_B2) U68.26(PVIN_B1)
VCCA_3V3_DDR_IN+: C801.2 R974.1 U211.D3(IN+) U212.10(VIN+)
VCCA_3V3_DDR_IN-: C801.1 R973.1 U211.D1(BUS) U211.D2(IN-) U212.8(VBUS) U212.9(VIN-)
VCCA_3V3_DDR_N: R338.1 R973.2 TP301.1(TP)
VCCA_3V3_DDR_P: R338.4 R974.2 TP302.1(TP)
VCCAD_5V0: C475.1 C482.1 C483.1 C504.1 C505.1 FL57.2 U154.3(VCCAD2) U154.49(VCCAD1)
VCCDA_5V0: C526.1 C527.1 C528.1 C529.1 C531.1 FL58.2 U154.14(VCCDA1) U154.34(VCCDA2)
VDD1_DDR_1V8: C228.1 C311.1 C343.1 C783.1 C787.1 C791.1 C814.1 C817.1 C872.1 C884.1 C912.1 C934.1 C936.1 C952.1 C954.1 C979.1 C1024.1 C1033.1 C1066.1 C1068.1 C1085.1 C1090.1 C1092.1 R485.2 TP171.1(TP) U54.F1(VDD1#F1) U54.F12(VDD1#F12) U54.G4(VDD1#G4) U54.G9(VDD1#G9) U54.T4(VDD1#T4) U54.T9(VDD1#T9) U54.U1(VDD1#U1) U54.U12(VDD1#U12) U71.F1(VDD1#F1) U71.F12(VDD1#F12) U71.G4(VDD1#G4) U71.G9(VDD1#G9) U71.T4(VDD1#T4) U71.T9(VDD1#T9) U71.U1(VDD1#U1) U71.U12(VDD1#U12) U87.4(VMON5)
VDD1_DDR_1V8_IN+: C402.2 R594.1 U128.10(VIN+) U129.D3(IN+)
VDD1_DDR_1V8_IN-: C402.1 R595.1 U128.8(VBUS) U128.9(VIN-) U129.D1(BUS) U129.D2(IN-)
VDD1_DDR_1V8_N: R485.1 R595.2 TP215.1(TP)
VDD1_DDR_1V8_P: R485.4 R594.2 TP214.1(TP)
VDD1_DDR_1V8_PG: R511.1 R1300.2 TP173.1(TP) U85.5(PG)
VDD1_DDR_1V8_REG: C319.1 C334.1 R485.3 R505.2 R511.2 U85.1(OUT)
VDD12_CDCI1: C187.2 C191.1 C197.1 FL27.3(OUT) U40.16(VDDO12)
VDD12_CDCI2: C85.1 C86.1 C87.2 FL4.3(OUT) U22.16(VDDO12)
VDD34_CDCI1: C186.2 C190.1 C196.1 FL26.3(OUT) U40.15(VDDO34)
VDD34_CDCI2: C72.1 C73.1 C74.2 FL3.3(OUT) U22.15(VDDO34)
VDD_1V0: C416.1 C417.2 C425.1 C443.1 C471.1 C1178.1 C1179.1 C1190.1 C1222.1 R611.1 TP219.1(TP) U125.9(OUT1) U125.10(OUT2) U261.6(VDDA1P0) U261.24(VDD1P0#24) U261.31(VDD1P0#31) U261.42(VDD1P0#42)
VDD_1V8_CDCEL: C75.1 C83.1 C89.1 FL2.3(OUT) R99.2 U23.3(VDD)
VDD_2V5: C476.1 C478.1 C1204.2 C1210.1 C1224.1 C1226.1 R1207.1 R1248.1 TP232.1(TP) U260.9(OUT1) U260.10(OUT2) U262.3(VDDA2P5#3) U262.9(VDDA2P5#9)
VDD_CORE_0V8: C175.1 C193.1 C200.1 C203.1 C218.1 C220.1 C225.1 C236.1 C237.1 C243.1 C341.1 C995.1 C1008.1 C1290.1 C1291.1 C2586.1 C2587.1 C2588.1 C2589.1 C2590.1 C2591.1 C2592.1 L27.2 L28.2 R226.3 R266.1 R1045.1 TP62.1(TP) TP70.1(TP) U42.3(VOSNS) U48.3(VOSNS) U59.AA24(VDD_CORE#AA24) U59.AA26(VDD_CORE#AA26) U59.AA28(VDD_CORE#AA28) U59.AB23(VDD_CORE#AB23) U59.AB25(VDD_CORE#AB25) U59.AB27(VDD_CORE#AB27) U59.AC22(VDD_CORE#AC22) U59.AC24(VDD_CORE#AC24) U59.AC26(VDD_CORE#AC26) U59.AC28(VDD_CORE#AC28) U59.AD11(VDD_CORE#AD11) U59.AD15(VDD_CORE#AD15) U59.AD17(VDD_CORE#AD17) U59.AD21(VDD_CORE#AD21) U59.AD23(VDD_CORE#AD23) U59.AD25(VDD_CORE#AD25) U59.AD27(VDD_CORE#AD27) U59.AE10(VDD_CORE#AE10) U59.AE12(VDD_CORE#AE12) U59.AE14(VDD_CORE#AE14) U59.AE16(VDD_CORE#AE16) U59.AE18(VDD_CORE#AE18) U59.AE20(VDD_CORE#AE20) U59.AE22(VDD_CORE#AE22) U59.AE24(VDD_CORE#AE24) U59.AE28(VDD_CORE#AE28) U59.AF19(VDD_CORE#AF19) U59.K9(VDD_CORE#K9) U59.K11(VDD_CORE#K11) U59.K15(VDD_CORE#K15) U59.K17(VDD_CORE#K17) U59.L10(VDD_CORE#L10) U59.L12(VDD_CORE#L12) U59.L14(VDD_CORE#L14) U59.L16(VDD_CORE#L16) U59.M9(VDD_CORE#M9) U59.M11(VDD_CORE#M11) U59.M13(VDD_CORE#M13) U59.M15(VDD_CORE#M15) U59.M17(VDD_CORE#M17) U59.N10(VDD_CORE#N10) U59.N12(VDD_CORE#N12) U59.N14(VDD_CORE#N14) U59.N16(VDD_CORE#N16) U59.N22(VDD_CORE#N22) U59.N24(VDD_CORE#N24) U59.N26(VDD_CORE#N26) U59.P9(VDD_CORE#P9) U59.P11(VDD_CORE#P11) U59.P25(VDD_CORE#P25) U59.R10(VDD_CORE#R10) U59.R22(VDD_CORE#R22) U59.R24(VDD_CORE#R24) U59.R26(VDD_CORE#R26) U59.T23(VDD_CORE#T23) U59.T25(VDD_CORE#T25) U59.U22(VDD_CORE#U22) U59.U24(VDD_CORE#U24) U59.U26(VDD_CORE#U26) U59.U28(VDD_CORE#U28) U59.V23(VDD_CORE#V23) U59.V27(VDD_CORE#V27) U59.W22(VDD_CORE#W22) U59.W24(VDD_CORE#W24) U59.W26(VDD_CORE#W26) U59.W28(VDD_CORE#W28) U59.Y23(VDD_CORE#Y23) U59.Y27(VDD_CORE#Y27) U87.10(VMON2) U5036.1 U5036.3 U5037.1 U5037.3 U5038.1 U5038.3 U5039.1 U5039.3 U5064.1 U5064.3 U5072.1 U5072.3 U5073.1 U5073.3 U5074.1 U5074.3 U5075.1 U5075.3 U5077.1 U5077.3 U5078.1 U5078.3 U5079.1 U5079.3 U5080.1 U5080.3 U5099.1 U5099.3 U50100.1 U50100.3 U50101.1 U50101.3 U50102.1 U50102.3 U50103.1 U50103.3 U50104.1 U50104.3 U50105.1 U50105.3 U50107.1 U50107.3 U50108.1 U50108.3 U50109.1 U50109.3 U50114.1 U50114.3 U50116.1 U50116.3 U50118.1 U50118.3 U50121.1 U50121.3 U50124.1 U50124.3 U50128.1 U50128.3 U50131.1 U50131.3 U50136.1 U50136.3 U50139.1 U50139.3 U50140.1 U50140.3 U50147.1 U50147.3 U50148.1 U50148.3 U50156.1 U50156.3 U50157.1 U50157.3 U50159.1 U50159.3 U50162.1 U50162.3 U50164.1 U50164.3 U50165.1 U50165.3 U50166.1 U50166.3 U50167.1 U50167.3 U50171.1 U50171.3 U50172.1 U50172.3 U50174.1 U50174.3
VDD_CORE_0V8_N: R898.2 TP263.1(TP)
VDD_CORE_0V8_P: R904.2 TP264.1(TP)
VDD_CORE_HCPS_SW1: L27.1 U42.7(SW)
VDD_CORE_HCPS_SW2: L28.1 U48.7(SW)
VDD_CPU_AVS: C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C206.1 C207.1 C208.1 C209.1 C210.1 C211.1 C212.1 C213.1 C214.1 C215.1 C335.1 C922.1 C944.1 C992.1 C996.1 C1292.1 C1293.1 C2582.1 C2583.1 C2584.1 C2585.1 L24.2 L25.2 L26.2 R93.1 R205.2 R208.2 TP22.1(TP) TP59.1(TP) U59.AA8(VDD_CPU#AA8) U59.AA10(VDD_CPU#AA10) U59.AA12(VDD_CPU#AA12) U59.AA20(VDD_CPU#AA20) U59.AB9(VDD_CPU#AB9) U59.AB11(VDD_CPU#AB11) U59.AB13(VDD_CPU#AB13) U59.AB15(VDD_CPU#AB15) U59.AB17(VDD_CPU#AB17) U59.AB19(VDD_CPU#AB19) U59.AB21(VDD_CPU#AB21) U59.AC8(VDD_CPU#AC8) U59.AC12(VDD_CPU#AC12) U59.AC14(VDD_CPU#AC14) U59.AC16(VDD_CPU#AC16) U59.AC18(VDD_CPU#AC18) U59.AC20(VDD_CPU#AC20) U59.AD9(VDD_CPU#AD9) U59.H19(VDD_CPU#H19) U59.H21(VDD_CPU#H21) U59.J18(VDD_CPU#J18) U59.J20(VDD_CPU#J20) U59.L18(VDD_CPU#L18) U59.L20(VDD_CPU#L20) U59.L25(VMON2_IR_VCPU) U59.M19(VDD_CPU#M19) U59.N18(VDD_CPU#N18) U59.N20(VDD_CPU#N20) U59.P15(VDD_CPU#P15) U59.P17(VDD_CPU#P17) U59.P19(VDD_CPU#P19) U59.P21(VDD_CPU#P21) U59.R12(VDD_CPU#R12) U59.R20(VDD_CPU#R20) U59.T9(VDD_CPU#T9) U59.T11(VDD_CPU#T11) U59.T17(VDD_CPU#T17) U59.T19(VDD_CPU#T19) U59.T21(VDD_CPU#T21) U59.U8(VDD_CPU#U8) U59.U10(VDD_CPU#U10) U59.U18(VDD_CPU#U18) U59.U20(VDD_CPU#U20) U59.V11(VDD_CPU#V11) U59.V19(VDD_CPU#V19) U59.V21(VDD_CPU#V21) U59.W8(VDD_CPU#W8) U59.W10(VDD_CPU#W10) U59.W12(VDD_CPU#W12) U59.W18(VDD_CPU#W18) U59.W20(VDD_CPU#W20) U59.Y9(VDD_CPU#Y9) U59.Y17(VDD_CPU#Y17) U59.Y19(VDD_CPU#Y19) U59.Y21(VDD_CPU#Y21) U87.12(VMON1) U5028.1 U5028.3 U5029.1 U5029.3 U5030.1 U5030.3 U5031.1 U5031.3 U5090.1 U5090.3 U5091.1 U5091.3 U5092.1 U5092.3 U5093.1 U5093.3 U50106.1 U50106.3 U50110.1 U50110.3 U50111.1 U50111.3 U50112.1 U50112.3 U50113.1 U50113.3 U50115.1 U50115.3 U50117.1 U50117.3 U50119.1 U50119.3 U50120.1 U50120.3 U50123.1 U50123.3 U50125.1 U50125.3 U50126.1 U50126.3 U50127.1 U50127.3 U50129.1 U50129.3 U50130.1 U50130.3 U50133.1 U50133.3 U50134.1 U50134.3 U50135.1 U50135.3 U50138.1 U50138.3 U50142.1 U50142.3 U50143.1 U50143.3 U50144.1 U50144.3 U50145.1 U50145.3 U50146.1 U50146.3 U50149.1 U50149.3 U50152.1 U50152.3 U50153.1 U50153.3 U50158.1 U50158.3 U50160.1 U50160.3 U50168.1 U50168.3 U50178.1 U50178.3 U50179.1 U50179.3 U50191.1 U50191.3 U50192.1 U50192.3
VDD_CPU_AVS_N: R911.2 TP271.1(TP)
VDD_CPU_AVS_P: R919.2 TP277.1(TP)
VDD_CPU_HCPS_GOSNS: C154.1 C156.1 C158.1 R186.1 R201.1 R203.1 U35.2(GOSNS) U36.2(GOSNS) U37.2(GOSNS)
VDD_CPU_HCPS_SW1: L24.1 U35.7(SW)
VDD_CPU_HCPS_SW2: L25.1 U36.7(SW)
VDD_CPU_HCPS_SW3: L26.1 U37.7(SW)
VDD_CPU_HCPS_VOSNS: R205.1 R208.1 U35.3(VOSNS) U36.3(VOSNS) U37.3(VOSNS)
VDD_DDR_1V1: C227.1 C229.1 C230.1 C240.1 C275.1 C298.1 C299.1 C307.1 C309.1 C310.1 C312.1 C315.1 C784.1 C792.1 C793.1 C794.1 C795.1 C806.1 C811.1 C828.1 C838.1 C839.1 C846.1 C877.1 C890.1 C897.1 C913.1 C914.1 C915.1 C933.1 C935.1 C953.1 C955.1 C962.1 C978.1 C981.1 C982.1 C1000.1 C1010.1 C1011.1 C1029.1 C1037.1 C1044.1 C1051.1 C1053.1 C1054.1 C1062.1 C1069.1 C1071.1 C1072.1 C1074.1 C1081.1 C1083.1 C1084.1 C1091.1 L33.2 L34.2 R544.1 R557.2 R978.1 R1012.1 R1019.1 R1020.1 R1040.1 R1041.1 R1054.1 R1121.1 TP167.1(TP) TP170.1(TP) TP183.1(TP) U54.A4(VDD2#A4) U54.A9(VDD2#A9) U54.AA3(VDDQ#AA3) U54.AA5(VDDQ#AA5) U54.AA8(VDDQ#AA8) U54.AA10(VDDQ#AA10) U54.AB4(VDD2#AB4) U54.AB9(VDD2#AB9) U54.B3(VDDQ#B3) U54.B5(VDDQ#B5) U54.B8(VDDQ#B8) U54.B10(VDDQ#B10) U54.D1(VDDQ#D1) U54.D5(VDDQ#D5) U54.D8(VDDQ#D8) U54.D12(VDDQ#D12) U54.F3(VDDQ#F3) U54.F5(VDD2#F5) U54.F8(VDD2#F8) U54.F10(VDDQ#F10) U54.H1(VDD2#H1) U54.H5(VDD2#H5) U54.H8(VDD2#H8) U54.H12(VDD2#H12) U54.K1(VDD2#K1) U54.K3(VDD2#K3) U54.K10(VDD2#K10) U54.K12(VDD2#K12) U54.N1(VDD2#N1) U54.N3(VDD2#N3) U54.N10(VDD2#N10) U54.N12(VDD2#N12) U54.R1(VDD2#R1) U54.R5(VDD2#R5) U54.R8(VDD2#R8) U54.R12(VDD2#R12) U54.U3(VDDQ#U3) U54.U5(VDD2#U5) U54.U8(VDD2#U8) U54.U10(VDDQ#U10) U54.W1(VDDQ#W1) U54.W5(VDDQ#W5) U54.W8(VDDQ#W8) U54.W12(VDDQ#W12) U59.A2(VDDS_DDR#A2) U59.AH1(VDDS_DDR#AH1) U59.G10(VDDS_DDR#G10) U59.G12(VDDS_DDR#G12) U59.G14(VDDS_DDR#G14) U59.G16(VDDS_DDR#G16) U59.G18(VDDS_DDR#G18) U59.H9(VDDS_DDR#H9) U59.H11(VDDS_DDR#H11) U59.H13(VDDS_DDR#H13) U59.H15(VDDS_DDR#H15) U59.H17(VDDS_DDR#H17) U59.J8(VDDS_DDR#J8) U59.J10(VDDS_DDR#J10) U59.J12(VDDS_DDR_C1) U59.J14(VDDS_DDR#J14) U59.J16(VDDS_DDR#J16) U59.K7(VDDS_DDR#K7) U59.L8(VDDS_DDR#L8) U59.M7(VDDS_DDR#M7) U59.N8(VDDS_DDR_C0) U59.P7(VDDS_DDR#P7) U59.R8(VDDS_DDR#R8) U68.22(FB_B1) U71.A4(VDD2#A4) U71.A9(VDD2#A9) U71.AA3(VDDQ#AA3) U71.AA5(VDDQ#AA5) U71.AA8(VDDQ#AA8) U71.AA10(VDDQ#AA10) U71.AB4(VDD2#AB4) U71.AB9(VDD2#AB9) U71.B3(VDDQ#B3) U71.B5(VDDQ#B5) U71.B8(VDDQ#B8) U71.B10(VDDQ#B10) U71.D1(VDDQ#D1) U71.D5(VDDQ#D5) U71.D8(VDDQ#D8) U71.D12(VDDQ#D12) U71.F3(VDDQ#F3) U71.F5(VDD2#F5) U71.F8(VDD2#F8) U71.F10(VDDQ#F10) U71.H1(VDD2#H1) U71.H5(VDD2#H5) U71.H8(VDD2#H8) U71.H12(VDD2#H12) U71.K1(VDD2#K1) U71.K3(VDD2#K3) U71.K10(VDD2#K10) U71.K12(VDD2#K12) U71.N1(VDD2#N1) U71.N3(VDD2#N3) U71.N10(VDD2#N10) U71.N12(VDD2#N12) U71.R1(VDD2#R1) U71.R5(VDD2#R5) U71.R8(VDD2#R8) U71.R12(VDD2#R12) U71.U3(VDDQ#U3) U71.U5(VDD2#U5) U71.U8(VDD2#U8) U71.U10(VDDQ#U10) U71.W1(VDDQ#W1) U71.W5(VDDQ#W5) U71.W8(VDDQ#W8) U71.W12(VDDQ#W12) U5049.1 U5049.3 U5050.1 U5050.3 U5051.1 U5051.3 U5052.1 U5052.3 U5053.1 U5053.3 U5054.1 U5054.3 U5055.1 U5055.3 U50163.1 U50163.3 U50169.1 U50169.3 U50183.1 U50183.3 U50184.1 U50184.3 U50185.1 U50185.3 U50186.1 U50186.3 U50187.1 U50187.3 U50188.1 U50188.3 U50189.1 U50189.3
VDD_DDR_1V1_IN+: C337.2 R520.1 U83.10(VIN+) U84.D3(IN+)
VDD_DDR_1V1_IN-: C337.1 R509.1 U83.8(VBUS) U83.9(VIN-) U84.D1(BUS) U84.D2(IN-)
VDD_DDR_1V1_N: R509.2 TP172.1(TP)
VDD_DDR_1V1_P: R520.2 TP174.1(TP)
VDD_DDR_SOC_1V1_IN+: C358.2 R555.1 U93.D3(IN+) U94.10(VIN+)
VDD_DDR_SOC_1V1_IN-: C358.1 R551.1 U93.D1(BUS) U93.D2(IN-) U94.8(VBUS) U94.9(VIN-)
VDD_DDR_SOC_1V1_N: R551.2 TP178.1(TP)
VDD_DDR_SOC_1V1_P: R555.2 TP181.1(TP)
VDD_GPIORET_IO_3V3: C359.1 C427.1 R425.1 R432.2 R438.1 R647.2 TP152.1(TP) U89.2(VMON6) U134.5(VCC)
VDD_GPIORET_IO_3V3_IN+: C1073.2 R1110.1 U235.D3(IN+) U236.10(VIN+)
VDD_GPIORET_IO_3V3_IN-: C1073.1 R1106.1 U235.D1(BUS) U235.D2(IN-) U236.8(VBUS) U236.9(VIN-)
VDD_GPIORET_IO_3V3_LS: C292.1 R432.3 R1092.2 U75.7(VOUT1) U75.8(VOUT2)
VDD_GPIORET_IO_3V3_N: R432.1 R1106.2 TP319.1(TP)
VDD_GPIORET_IO_3V3_P: R432.4 R1110.2 TP320.1(TP)
VDD_GPIORET_WK_0V8: C323.1 R415.2 R421.1 R1051.1 TP139.1(TP) U89.10(VMON2)
VDD_GPIORET_WK_0V8_IN+: C1052.2 R1091.1 U231.D3(IN+) U232.10(VIN+)
VDD_GPIORET_WK_0V8_IN-: C1052.1 R1084.1 U231.D1(BUS) U231.D2(IN-) U232.8(VBUS) U232.9(VIN-)
VDD_GPIORET_WK_0V8_N: R415.1 R1084.2 TP316.1(TP)
VDD_GPIORET_WK_0V8_P: R415.4 R1091.2 TP317.1(TP)
VDD_GPIORET_WK_0V8_PG: R413.1 R1299.2 TP137.1(TP) U66.5(PG)
VDD_GPIORET_WK_0V8_REG: C274.1 C283.1 R406.2 R413.2 R415.3 U66.1(OUT)
VDD_IO_1V8: C848.1 C849.1 C864.1 Q3.2(G1) R369.3 TP115.1(TP) U41.4(EN) U59.AE8(VDDS_MMC0#AE8) U59.AF7(VDDS_MMC0#AF7) U63.4(EN) U68.50(FB_B4)
VDD_IO_1V8_IN+: C251.2 R370.1 U56.10(VIN+) U57.D3(IN+)
VDD_IO_1V8_IN-: C251.1 R359.1 U56.8(VBUS) U56.9(VIN-) U57.D1(BUS) U57.D2(IN-)
VDD_IO_1V8_N: R359.2 R369.4 TP114.1(TP)
VDD_IO_1V8_P: R369.1 R370.2 TP118.1(TP)
VDD_IO_1V8_REG: C253.1 C892.1 L30.2 R352.3 R369.2
VDD_IO_3V3: C336.1 C918.1 C938.1 C1271.1 R316.2 R426.1 R1014.2 U59.T28(VDDSHV0) U87.2(VMON6) U281.5(VCC)
VDD_IO_3V3_IN+: C858.2 R991.1 U218.10(VIN+) U219.D3(IN+)
VDD_IO_3V3_IN-: C858.1 R983.1 U218.8(VBUS) U218.9(VIN-) U219.D1(BUS) U219.D2(IN-)
VDD_IO_3V3_LS: C258.1 R382.2 R930.2 R1014.3 U62.7(VOUT1) U62.8(VOUT2)
VDD_IO_3V3_N: R983.2 R1014.1 TP303.1(TP)
VDD_IO_3V3_P: R991.2 R1014.4 TP304.1(TP)
VDD_MCU_0V85: C328.1 C971.1 C972.1 C999.1 FL43.1 FL43.3 FL44.1 FL44.3 FL45.1 FL45.3 FL46.1 FL46.3 FL170.1 FL170.3 FL177.1 FL177.3 R424.1 R427.2 R580.1 TP143.1(TP) TP204.1(TP) U59.J22(VDD_MCU#J22) U59.K21(VDD_MCU#K21) U59.K23(VDD_MCU#K23) U59.L24(VDD_MCU#L24) U59.M21(VDD_MCU#M21) U59.M23(VDD_MCU#M23) U59.M25(VDD_MCU#M25) U68.37(FB_B5) U69.1(G) U89.12(VMON1)
VDD_MCU_0V85_N: R388.2 R427.1 TP125.1(TP)
VDD_MCU_0V85_P: R393.2 R427.4 TP129.1(TP)
VDD_MCU_0V85_REG: C273.1 C994.1 L32.2 R427.3 R1057.3
VDD_MCU_2V5: C461.1 C462.2 C470.1 C472.1 C1221.1 C1223.1 R643.1 R648.1 TP234.1(TP) U138.9(OUT1) U138.10(OUT2) U261.3(VDDA2P5#3) U261.9(VDDA2P5#9)
VDD_MCU_RAM_0V85: FL42.1 R1057.2 TP145.1(TP)
VDD_MCU_RAM_0V85_IN+: C272.2 R412.1 U64.D3(IN+) U65.10(VIN+)
VDD_MCU_RAM_0V85_IN-: C272.1 R408.1 U64.D1(BUS) U64.D2(IN-) U65.8(VBUS) U65.9(VIN-)
