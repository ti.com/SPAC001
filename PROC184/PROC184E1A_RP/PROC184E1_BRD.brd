# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UFS0_RX1_P: length 81.8
  L3-SIGNAL1 w0.079: v5(148.18,147.32) v3(147.84,147.32) ; v3(130.32,92.63) v5(130.54,92.91)
  L4-GND2 w0.089: v5(130.54,92.91) v7(130.85,93.22) ; v5(148.18,147.32) v7(148.57,147.42)
  L12-SIGNAL5 w0.089: v7(148.57,147.42) 148.34,147.65 arc(148.29,147.73) 148.27,147.83 148.27,148.35 arc(148.18,148.78) 147.94,149.15 arc(147.81,149.35) 147.76,149.58 147.76,150.52 arc(147.59,150.93) 147.18,151.11 144.86,151.11 arc(144.56,151.16) 144.31,151.33 arc(144.17,151.43) 144,151.46 142.53,151.46 arc(141.67,151.1) 141.31,150.24 141.31,147.98 arc(141.36,147.75) 141.49,147.55 141.88,147.16 arc(142.08,146.86) 142.14,146.52 142.14,139.07 arc(142.52,137.19) 143.58,135.59 148.73,130.45 arc(149.34,129.53) 149.55,128.45 149.55,122.36 arc(149.45,121.85) 149.16,121.42 148.03,120.28 arc(147.77,119.9) 147.68,119.45 147.68,116.23 arc(147.53,115.47) 147.1,114.82 143.1,110.83 arc(142.71,110.24) 142.57,109.54 142.57,108.89 arc(142.5,108.53) 142.3,108.23 141.21,107.14 arc(140.93,106.72) 140.83,106.22 140.83,104.23 arc(140.69,103.56) 140.32,103 137.69,100.36 arc(137.53,100.26) 137.36,100.23 136.43,100.23 arc(136.1,100.16) 135.83,99.98 134.45,98.6 arc(134.31,98.51) 134.15,98.48 132.8,98.48 arc(132.4,98.4) 132.06,98.17 131.64,97.75 arc(131.44,97.44) 131.36,97.08 131.36,95.85 arc(131.33,95.77) 131.26,95.74 arc(131.18,95.71) 131.15,95.63 131.15,95.53 arc(131.18,95.46) 131.26,95.42 arc(131.33,95.39) 131.36,95.32 131.36,94.95 arc(131.34,94.82) 131.27,94.71 131.21,94.66 arc(131.1,94.5) 131.06,94.31 131.06,93.74 arc(131.01,93.46) v7(130.85,93.22)
  vias: v1(130.32,92.63)
UFS0_TX0_N: length 69.4
  L3-SIGNAL1 w0.079: v3(132.72,94.23) v5(132.94,94.51) ; v5(145.18,147.32) v3(144.84,147.32)
  L4-GND2 w0.089: v5(132.94,94.51) v7(133.25,94.82) ; v7(145.57,147.42) v5(145.18,147.32)
  L12-SIGNAL5 w0.089: v7(133.25,94.82) 133.24,94.83 arc(133.12,95) 133.08,95.2 133.08,95.31 arc(133.16,95.5) 133.35,95.58 133.79,95.58 arc(133.98,95.54) 134.14,95.44 134.79,94.78 arc(134.99,94.65) 135.22,94.6 136.68,94.6 arc(137.92,95.11) 138.43,96.35 138.43,98.25 arc(138.51,98.68) 138.75,99.05 144.39,104.68 arc(144.53,104.9) 144.59,105.15 144.59,105.93 arc(144.67,106.36) 144.92,106.73 145.47,107.28 arc(145.72,107.66) 145.8,108.1 145.8,109.24 arc(145.93,109.87) 146.28,110.4 149.63,113.74 arc(150.02,114.34) 150.16,115.03 150.16,117.67 arc(150.31,118.41) 150.73,119.04 151.82,120.13 arc(152.14,120.61) 152.25,121.17 152.25,129.14 arc(151.92,130.78) 150.99,132.17 145.56,137.6 arc(145.18,138.17) 145.05,138.84 145.05,145.51 arc(145.11,145.67) 145.27,145.73 145.89,145.73 arc(146.18,145.86) 146.31,146.15 146.31,146.3 arc(146.26,146.52) 146.13,146.71 146,146.85 arc(145.93,146.95) 145.91,147.07 145.91,147.28 arc(145.87,147.38) 145.76,147.42 v7(145.57,147.42)
  vias: v1(132.72,94.23)
UFS0_TX0_P: length 69.4
  L3-SIGNAL1 w0.079: v5(145.18,146.82) v3(144.84,146.82) ; v3(131.92,94.23) v5(132.14,94.51)
  L4-GND2 w0.089: v7(145.57,146.71) v5(145.18,146.82) ; v5(132.14,94.51) v7(132.45,94.82)
  L12-SIGNAL5 w0.089: v7(132.45,94.82) 132.45,94.72 arc(132.66,94.51) 132.87,94.72 132.87,95.31 arc(133.01,95.65) 133.35,95.8 133.79,95.8 arc(134.06,95.74) 134.29,95.59 134.94,94.94 arc(135.07,94.85) 135.22,94.82 136.68,94.82 arc(137.76,95.27) 138.21,96.35 138.21,98.25 arc(138.31,98.76) 138.6,99.2 144.24,104.83 arc(144.33,104.98) 144.37,105.15 144.37,105.93 arc(144.47,106.45) 144.77,106.89 145.31,107.43 arc(145.52,107.74) 145.59,108.1 145.59,109.24 arc(145.73,109.95) 146.13,110.55 149.47,113.9 arc(149.82,114.42) 149.94,115.03 149.94,117.67 arc(150.11,118.49) 150.57,119.19 151.66,120.28 arc(151.94,120.69) 152.03,121.17 152.03,129.14 arc(151.72,130.7) 150.84,132.02 145.41,137.45 arc(144.98,138.09) 144.83,138.84 144.83,138.84 144.83,145.51 arc(144.96,145.82) 145.27,145.95 145.89,145.95 arc(146.03,146.01) 146.09,146.15 146.09,146.3 arc(146.06,146.44) 145.98,146.56 arc(145.81,146.67) 145.61,146.71 v7(145.57,146.71)
  vias: v1(131.92,94.23)
UFS0_TX1_N: length 66.9
  L3-SIGNAL1 w0.079: v5(143.5,147.32) v3(143.84,147.32) ; v3(131.92,93.43) v5(132.14,93.71)
  L4-GND2 w0.089: v5(132.14,93.71) v7(132.45,94.02) ; v7(143.11,147.42) 143.43,147.33 v5(143.5,147.32)
  L12-SIGNAL5 w0.089: v7(143.11,147.42) 143.3,147.23 arc(143.37,147.19) 143.44,147.17 143.54,147.17 arc(143.8,147.07) 143.9,146.82 143.9,137.87 arc(143.97,137.5) 144.19,137.18 150.55,130.81 arc(150.86,130.36) 150.96,129.82 150.96,121.66 arc(150.84,121.03) 150.48,120.5 149.36,119.37 arc(149.13,119.03) 149.05,118.62 149.05,115.71 arc(148.88,114.88) 148.41,114.18 145.45,111.22 arc(144.83,110.29) 144.61,109.19 144.61,108.06 arc(144.55,107.73) 144.36,107.44 143.41,106.49 arc(143.21,106.19) 143.14,105.84 143.14,105.09 arc(143.01,104.42) 142.63,103.86 138.05,99.28 137.82,99.05 arc(137.59,98.9) 137.32,98.84 136.45,98.84 arc(136.09,98.77) 135.79,98.57 133.72,96.5 arc(133.62,96.43) 133.49,96.41 133.08,96.41 arc(132.88,96.37) 132.71,96.25 132.3,95.84 arc(132.14,95.6) 132.08,95.32 132.08,94.48 arc(132.1,94.39) 132.15,94.32 v7(132.45,94.02)
  vias: v1(131.92,93.43)
UFS0_TX1_P: length 67
  L3-SIGNAL1 w0.079: v3(131.12,93.43) v5(131.34,93.71) ; v5(143.5,146.82) v3(143.84,146.82)
  L4-GND2 w0.089: v7(143.11,146.71) v5(143.5,146.82) ; v5(131.34,93.71) v7(131.65,94.02)
  L12-SIGNAL5 w0.089: v7(143.11,146.71) 143.3,146.9 arc(143.37,146.94) 143.44,146.96 143.54,146.96 arc(143.64,146.92) 143.68,146.82 143.68,137.87 arc(143.77,137.41) 144.03,137.03 150.4,130.66 arc(150.66,130.27) 150.75,129.82 150.75,121.66 arc(150.64,121.12) 150.33,120.65 149.2,119.53 arc(148.93,119.11) 148.83,118.62 148.83,115.71 arc(148.68,114.96) 148.26,114.33 145.3,111.37 arc(144.63,110.37) 144.4,109.19 144.4,108.06 arc(144.35,107.81) 144.2,107.6 143.25,106.65 arc(143.01,106.28) 142.92,105.84 142.92,105.09 arc(142.81,104.51) 142.48,104.01 arc(142.47,104.01) 142.47,104.01 137.67,99.2 arc(137.51,99.1) 137.32,99.06 136.45,99.06 arc(136.01,98.97) 135.64,98.72 134.39,97.47 arc(134.27,97.43) 134.16,97.47 134.13,97.5 arc(133.91,97.5) 133.91,97.28 133.94,97.25 arc(133.98,97.14) 133.94,97.02 133.57,96.65 arc(133.53,96.63) 133.49,96.62 133.08,96.62 arc(132.8,96.57) 132.56,96.41 132.14,95.99 arc(131.94,95.68) 131.86,95.32 131.86,94.33 arc(131.85,94.24) 131.79,94.16 v7(131.65,94.02)
  vias: v1(131.12,93.43)
USB0_D_N: length 99.6
  L3-SIGNAL1 w0.091: v3(121.52,90.23) v5(121.74,90.51)
  L4-GND2 w0.108: v5(121.74,90.51) v7(122.05,90.82)
  L7-SIGNAL3 w0.127: v2(137.74,165.53) 138.08,165.18 arc(138.14,165.1) 138.16,165 138.16,164.79 arc(138.22,164.47) 138.41,164.19 139.06,163.54 arc(139.44,163.28) 139.88,163.2 145.27,163.2 arc(145.48,163.15) 145.66,163.03 145.89,162.81 arc(146,162.65) 146.03,162.46 146.03,158.5 arc(145.96,158.15) 145.76,157.85 141.23,153.32 arc(141.05,153.05) 140.99,152.74 140.99,151.87 arc(140.91,151.49) 140.69,151.16 140.15,150.61 arc(139.88,150.21) 139.78,149.74 139.78,148.41 arc(139.73,148.15) 139.58,147.93 123.72,132.06 arc(123.33,131.49) 123.2,130.8 123.2,129.1 arc(123.19,129.05) 123.16,129.01 123.07,128.92 arc(123.03,128.89) 122.98,128.88 122.66,128.88 arc(122.57,128.92) 122.53,129.01 v2(122.53,129.34)
  L13-GND5 w0.108: v7(122.05,90.82) 122.26,91.03 v9(122.34,91.11)
  L14-SIGNAL6 w0.091: v9(122.34,91.11) 122.15,91.11 arc(122.08,91.14) 122.05,91.22 122.05,91.75 arc(122,91.99) 121.86,92.2 121.28,92.77 arc(121.12,93.01) 121.06,93.3 121.06,95.86 arc(121.16,96.33) 121.42,96.72 122.64,97.93 arc(122.8,98.04) 122.99,98.08 123.82,98.08 arc(124.17,98.15) 124.48,98.35 125.08,98.96 arc(125.32,99.32) 125.41,99.75 125.41,101.97 arc(125.45,102.16) 125.55,102.33 127.82,104.59 arc(127.97,104.82) 128.02,105.09 128.02,116.44 arc(127.87,117.24) 127.42,117.91 123.77,121.56 arc(123.59,121.83) 123.53,122.14 123.53,128.3 arc(123.39,128.64) 123.05,128.78 122.71,128.78 arc(122.58,128.83) 122.53,128.96 v2(122.53,129.34)
  vias: v1(121.52,90.23)
USB0_D_P: length 99.6
  L3-SIGNAL1 w0.091: v3(120.72,90.23) v5(120.94,90.51)
  L4-GND2 w0.108: v5(120.94,90.51) v7(121.25,90.82)
  L7-SIGNAL3 w0.127: v2(138.88,165.53) 138.54,165.18 arc(138.48,165.1) 138.46,165 138.46,164.79 arc(138.51,164.58) 138.62,164.41 139.28,163.75 arc(139.56,163.57) 139.88,163.5 145.27,163.5 arc(145.6,163.44) 145.88,163.25 146.1,163.02 arc(146.28,162.76) 146.34,162.46 146.34,158.5 arc(146.24,158.03) 145.98,157.64 141.44,153.1 arc(141.33,152.94) 141.29,152.74 141.29,151.87 arc(141.19,151.37) 140.91,150.94 140.36,150.4 arc(140.16,150.09) 140.09,149.74 140.09,148.41 arc(140.01,148.03) 139.8,147.71 123.94,131.85 arc(123.62,131.37) 123.5,130.8 123.5,129.1 arc(123.47,128.94) 123.38,128.8 123.28,128.7 arc(123.14,128.61) 122.98,128.58 122.66,128.57 122.66,128.56 122.57,128.47 arc(122.54,128.43) 122.53,128.38 v2(122.53,128.09)
  L13-GND5 w0.108: v7(121.25,90.82) 121.46,91.03 v9(121.54,91.11)
  L14-SIGNAL6 w0.091: v2(122.53,128.09) 122.53,128.27 arc(122.62,128.48) 122.82,128.56 123.05,128.56 arc(123.23,128.48) 123.31,128.3 123.31,122.14 arc(123.39,121.74) 123.62,121.4 127.26,117.76 arc(127.66,117.16) 127.81,116.44 127.81,105.09 arc(127.77,104.9) 127.66,104.74 125.4,102.48 arc(125.24,102.25) 125.19,101.97 125.19,99.75 arc(125.12,99.4) 124.93,99.11 124.32,98.51 arc(124.09,98.35) 123.82,98.3 122.99,98.3 arc(122.71,98.24) 122.48,98.09 121.27,96.88 arc(120.96,96.41) 120.85,95.86 120.85,93.3 arc(120.92,92.93) 121.13,92.62 121.7,92.04 arc(121.79,91.91) 121.83,91.75 121.83,91.22 arc(121.83,91.21) 121.83,91.2 121.83,91.2 arc(121.8,91.13) 121.74,91.11 v9(121.54,91.11)
  vias: v1(120.72,90.23)
USB0_DATA_N: length 13.3
  TOP w0.114: L7.4 148.94,173.7 149.23,173.41 149.23,173.05 148.96,172.78 144.3,172.78 143.63,173.45 139.07,173.45 138.68,173.07 138.68,172.52 v2(138.24,172.08)
USB0_DATA_P: length 13.3
  TOP w0.114: L7.1 149.79,173.97 149.79,173.7 149.5,173.4 149.5,172.94 149.07,172.51 144.19,172.51 143.52,173.18 139.18,173.18 138.95,172.96 138.95,172.52 v2(139.39,172.08)
USB0_DRVVBUS: length 32
  L14-SIGNAL6 w0.089: v2(142.07,163.93) 142.12,163.97 147.1,163.97 149.11,165.98 149.11,169.67 150.92,171.49 151.45,171.49 153.99,171.49 155.47,171.49 156.03,170.93 158.99,170.93 159.52,171.46 159.52,176.16 v2(161.08,177.72)
  BOTTOM w0.127: U177.11 142.83,163.71 142.62,163.93 v2(142.07,163.93)
USB0_DRVVBUS_MUX: length 133.6
  L7-SIGNAL3 w0.109: v2(86.34,94.09) 86.34,94.09 85.75,94.67 79.49,94.67 77.17,96.98 77.17,119.05 78.18,120.06 80.95,120.06 82.36,121.47 82.36,123.95 83.6,125.19 95.47,125.19 101.51,119.14 108.92,119.14 109.64,118.42 112.71,118.42 114.97,120.68 114.97,122.84 121.1,128.97 121.1,130.49 138.77,148.16 138.77,150.6 139.74,151.57 139.74,153.14 142.84,156.24 142.84,159.97 v2(145.28,162.41)
  BOTTOM w0.127: U177.9 v2(145.28,162.41)
USB0_ID: length 47.6
  L14-SIGNAL6 w0.089: v2(177.88,179.5) 177.61,179.77 158.26,179.77 150.71,172.22 150.71,172.22 148.47,169.98 148.47,169.98 147.83,169.33 v2(147.83,167.08)
  BOTTOM w0.127: v2(177.88,179.5) 178.27,179.11 178.27,176.41 179,175.67 182.51,175.67 182.72,175.46 182.72,174.81 U165.4 ; v2(147.83,167.08) 147.83,166.99 148.39,166.42 149.42,166.42 U177.2
USB0_ID_MUX: length 92
  L3-SIGNAL1 w0.089: v3(118.32,90.23) v5(118.04,90.46)
  L4-GND2 w0.102: v5(118.04,90.46) v7(117.73,90.77)
  L7-SIGNAL3 w0.109: v2(147.62,165.27) 147.09,164.75 147.09,157.61 142.62,153.14 142.62,150.85 141.64,149.86 141.64,147.6 130.24,136.2 130.24,133.91 v2(121.4,125.06)
  L10-SIGNAL4 w0.109: v2(121.4,125.06) 122.03,124.43 122.03,104.67 120.2,102.85 120.2,98.91 119.03,97.74 118.14,97.74 116.55,96.15 116.55,91.41 117.2,90.77 v7(117.73,90.77)
  BOTTOM w0.127: U177.4 147.88,165.01 v2(147.62,165.27)
  vias: v1(118.31,90.23)
USB0_RCALIB: length 37
  L3-SIGNAL1 w0.089: v3(116.72,90.23) v5(116.44,90.46)
  L4-GND2 w0.102: v5(116.44,90.46) v7(116.13,90.77)
  L10-SIGNAL4 w0.109: v2(121.39,123.12) 121.75,122.75 121.75,105.03 119.92,103.2 119.92,99.31 118.85,98.25 117.89,98.25 116.06,96.42 116.06,93.83 115.73,93.5 115.73,92.99 116.28,92.44 116.28,92.29 115.73,91.75 115.73,91.43 116.13,91.03 v7(116.13,90.77)
  vias: v1(116.71,90.23)
USB0_VBUS_MUX: length 93.5
  TOP w0.305: v2(118.72,89.83) 119.12,89.44 U59.AG19
  L7-SIGNAL3 w0.381: 149.54,161.66 149.54,161.68 v2(150.76,162.9) ; 149.54,161.66 v2(148.3,162.9) ; 149.54,161.66 149.54,154.3 147.58,152.34 147.58,149.15 146.54,148.11 146.54,146.81 135.42,135.69 135.42,130.47 v2(136.32,129.57)
  L10-SIGNAL4 w0.305: v2(118.72,89.83) 118.24,90.31 118.24,91.18 118.02,91.41 118.02,91.98 119.82,93.78 119.82,94.54 123.22,97.94 123.22,101.09 123.71,101.58 125.26,101.58 126.65,102.97 126.65,109.8 127.67,110.82 127.67,113.08 130.26,115.67
  L10-SIGNAL4 w0.381: 130.26,115.67 130.26,123.52 v2(136.32,129.57)
  BOTTOM w0.305: v2(150.76,162.9) 150.6,163.06 U177.7 148.46,163.06 v2(148.3,162.9)
USB0_VBUS_SOC: length 2.6
  BOTTOM w0.305: v2(148.3,164.53) 148.46,164.36 U177.5 150.6,164.36 v2(150.76,164.53)
  vias: v2(139.57,177.42) v2(139.57,176.51)
USB1_DN1_D_N: length 74.2
  TOP w0.114: v2(75.63,166.78) 75.42,166.57 74.36,166.57 74.26,166.68 U11.34
  L5-SIGNAL2 w0.108: v2(75.63,166.78) 75.82,166.6 78.77,166.6 84.59,172.42 95.31,172.42 97.03,174.14 103.11,174.14 106.28,177.32 129.23,177.32 133.25,181.33 135.12,181.33 135.91,180.54 135.91,179.31 135.62,179.02 133.95,179.02 v2(133.78,178.85)
  BOTTOM w0.114: v2(133.78,178.85) 134.01,179.07 134.53,179.07 134.82,178.78 L39.2
USB1_DN1_D_P: length 74.3
  TOP w0.114: v2(75.63,166.07) 75.41,166.29 74.37,166.29 74.26,166.18 U11.33
  L5-SIGNAL2 w0.108: v2(133.78,179.56) 133.78,179.43 133.96,179.25 134.31,179.25 134.45,179.4 134.45,179.54 134.6,179.68 134.8,179.68 134.94,179.54 134.94,179.4 135.09,179.25 135.52,179.25 135.67,179.41 135.67,180.44 135.02,181.1 133.34,181.1 129.33,177.08 106.38,177.08 103.2,173.91 97.13,173.91 95.4,172.18 84.69,172.18 78.87,166.36 75.74,166.36 75.63,166.25 v2(75.63,166.07)
  BOTTOM w0.114: L39.3 134.81,179.63 134.52,179.34 134.01,179.34 v2(133.78,179.56)
USB1_DN1_PE: length 2.1
  TOP w0.127: v2(59.84,172.13) 60.59,172.13 60.64,172.18 U11.4
USB1_DN2_D_N: length 45
  TOP w0.114: v2(76.01,170.78) 75.79,170.56 74.37,170.56 74.26,170.68 U11.42
  L14-SIGNAL6 w0.091: v2(76.01,170.78) 76.3,170.49 79.54,170.49 82.49,173.44 82.49,180.45 78.61,184.34 62.23,184.34 60.64,184.34 60.55,184.24 60.55,183.98 60.45,183.89 60.32,183.89 60.23,183.98 60.23,184.24 60.13,184.34 59.6,184.34 v2(59.35,184.08)
  BOTTOM w0.114: v2(59.35,184.08) 59.1,184.33 58.58,184.33 58.29,184.04 L38.1
USB1_DN2_D_P: length 45.1
  TOP w0.114: U11.41 74.26,170.18 74.37,170.3 75.79,170.3 v2(76.01,170.07)
  L14-SIGNAL6 w0.091: v2(76.01,170.07) 76.21,170.28 79.63,170.28 82.71,173.35 82.71,180.54 78.7,184.55 59.64,184.55 v2(59.35,184.84)
  BOTTOM w0.114: L38.4 58.29,184.89 58.58,184.6 59.1,184.6 v2(59.35,184.84)
USB1_DN2_PE: length 13.7
  TOP w0.127: U11.3 60.44,172.68 v2(59.84,173.28)
  BOTTOM w0.127: R740.2 59.71,182.56 60.85,181.41 60.85,174.29 v2(59.84,173.28)
USB1_DN3_D_N: length 45.1
  TOP w0.114: L8.1 38.53,172.08 38.24,172.37 37.76,172.37 v2(37.52,172.12) ; U11.50 70.91,176.47 71.02,176.59 71.02,176.77 70.63,177.16 70.63,177.64 v2(70.41,177.86)
  L5-SIGNAL2 w0.108: v2(37.52,172.12) 37.52,172.35 37.63,172.46 45.68,172.46 49.62,176.4 53.11,176.4 55.41,178.7 55.41,179.48 58.41,182.48 66.8,182.48 66.8,182.48 66.93,182.48 68.14,181.27 68.14,180.76 69.31,179.59 69.82,179.59 70.73,178.68 70.73,178.05 70.54,177.86 v2(70.41,177.86)
USB1_DN3_D_P: length 45.1
  TOP w0.114: L8.4 38.56,172.93 38.27,172.63 37.76,172.63 v2(37.52,172.88) ; U11.49 71.41,176.46 71.29,176.58 71.29,176.88 70.9,177.27 70.9,177.64 v2(71.12,177.86)
  L5-SIGNAL2 w0.108: v2(71.12,177.86) 70.97,178.01 70.97,178.77 69.92,179.83 69.41,179.83 68.38,180.86 68.38,181.36 67.03,182.72 66.9,182.72 58.31,182.72 55.18,179.58 55.18,178.79 53.02,176.63 49.52,176.63 45.58,172.7 37.7,172.7 v2(37.52,172.88)
USB1_DN3_PE: length 24.1
  TOP w0.127: U11.1 60.58,173.68 v2(59.84,174.42)
  L3-SIGNAL1 w0.089: v2(59.84,174.42) 57.94,174.42 52.45,168.93 41.76,168.93 40.96,169.73 v3(40.81,169.73)
USB1_DN4_D_N: length 168.6
  TOP w0.114: U11.57 67.41,176.53 67.52,176.65 67.52,178.04 v2(67.28,178.29)
  L14-SIGNAL6 w0.091: v2(67.28,178.29) 67.48,178.09 67.48,177.78 67.39,177.69 54.61,177.69 53.15,176.23 48.32,176.23 42.6,170.51 35.78,170.51 34.73,171.56 26.08,171.56 20.47,165.95 20.47,162.77 17.93,160.24 17.93,156.53 18.26,156.2 18.26,154.66 17.75,154.15 17.75,151.48 18.39,150.83 18.39,144.23 13.1,138.94 13.1,134.3 12.54,133.75 12.54,122.1 26.64,108 26.64,106.03 27,105.66 27,102.11 25.88,100.99 25.88,89.85 28.9,86.82 28.9,71.71 30.96,69.65 31.58,69.65 v2(31.73,69.5)
  BOTTOM w0.114: v2(31.73,69.5) 31.98,69.75 32.84,69.75 32.96,69.63 J56.115
USB1_DN4_D_P: length 168.6
  TOP w0.114: U11.56 67.91,176.53 67.79,176.65 67.79,178.04 v2(68.04,178.29)
  L14-SIGNAL6 w0.091: v2(68.04,178.29) 67.89,178.29 67.7,178.1 67.7,177.69 67.48,177.47 54.7,177.47 53.24,176.01 48.41,176.01 42.69,170.29 35.69,170.29 34.64,171.34 26.17,171.34 20.68,165.86 20.68,162.68 18.15,160.15 18.15,156.62 18.47,156.29 18.47,154.57 17.97,154.06 17.97,151.57 18.61,150.92 18.61,144.14 13.32,138.85 13.32,134.21 12.76,133.65 12.76,122.19 26.85,108.09 26.85,106.12 27.22,105.75 27.22,102.02 26.1,100.9 26.1,89.94 29.12,86.91 29.12,71.8 31.05,69.87 31.55,69.87 31.73,70.04 v2(31.73,70.26)
  BOTTOM w0.114: v2(31.73,70.26) 31.98,70.01 32.84,70.01 32.96,70.13 J56.117
USB1_DN4_PE: length 157
  TOP w0.127: U11.64 63.91,176.54 63.66,176.79 62.61,176.79 62.48,176.66 v2(62.48,176.15)
  L14-SIGNAL6 w0.089: v2(62.48,176.15) 60.11,176.15 59.01,175.06 53.27,175.06 47.03,168.82 31.67,168.82 23.29,160.44 20.77,160.44 19.06,158.73 19.06,143.75 14.74,139.43 14.74,131.57 15.53,130.79 15.53,121.17 26.14,110.56 26.14,109.48 27.85,107.77 27.85,102.3 26.44,100.89 26.44,89.94 32.24,84.14 32.24,68.92 v2(31.78,68.46)
  BOTTOM w0.127: J56.113 32.45,69.13 v2(31.78,68.46)
USB1_DRVVBUS: length 110.9
  L3-SIGNAL1 w0.089: v2(142.32,161.82) 151.36,161.82 v2(152.31,162.77)
  L5-SIGNAL2 w0.102: v2(58.81,165.34) 59.22,165.75 61.88,165.75 63.16,164.47 67.02,164.47 67.24,164.47 73.26,164.47 73.9,165.11 95.51,165.11 99.91,169.51 125.11,169.51 126.22,170.62 133.49,170.62 136.22,173.35 137.58,173.35 138.68,172.26 138.68,168.41 138.32,168.05 138.32,164.68 141.16,161.84 142.3,161.84 v2(142.32,161.82)
  BOTTOM w0.127: U177.10 142.48,163.06 R807.1 142.07,162.07 v2(142.32,161.82)
USB1_HUB_AUTOEN#: length 2.2
  TOP w0.127: v2(59.84,167.39) 60.54,167.39 60.82,167.68 U11.13
USB1_HUB_D_N: length 82.2
  TOP w0.114: v2(136.7,171.72) 136.95,171.47 136.95,170.98 137.67,170.26 137.67,170.1 137.68,169.91 137.56,169.79 U12.4 ; v2(66.59,162.26) 66.3,162.54 66.3,163.22 66.41,163.33 U11.22
  L5-SIGNAL2 w0.108: v2(136.7,171.72) 136.95,171.72 137.06,171.83 137.06,172.3 136.71,172.65 136.3,172.65 132.67,169.01 100.14,169.01 95.1,163.98 84.01,163.98 84.01,163.98 83.67,163.98 83.57,163.87 69.24,163.87 69.1,163.73 69.1,163.62 68.96,163.47 68.76,163.47 68.61,163.62 68.61,163.73 68.47,163.87 66.93,163.87 66.26,163.2 66.26,162.58 v2(66.59,162.26)
USB1_HUB_D_P: length 82.2
  TOP w0.114: U12.3 138.06,169.77 137.94,169.88 137.94,170.1 137.94,170.37 137.22,171.09 137.22,171.47 v2(137.47,171.72) ; v2(65.83,162.26) 66.04,162.47 66.04,163.2 65.91,163.33 U11.21
  L5-SIGNAL2 w0.108: v2(65.83,162.26) 66.03,162.46 66.03,163.3 66.84,164.11 83.47,164.11 83.57,164.21 84.11,164.21 95,164.21 100.04,169.25 132.57,169.25 136.2,172.88 136.81,172.88 137.29,172.4 137.29,171.89 v2(137.47,171.72)
USB1_HUB_FULLPWRMGMT#: length 2.4
  TOP w0.127: U11.8 61.15,170.18 60.51,170.82 R31.2
USB1_HUB_GANGED: length 2.4
  TOP w0.127: U11.10 60.48,169.18 R48.2
USB1_HUB_PWRCTR_POL: length 2.1
  TOP w0.127: U11.9 v2(59.84,169.68)
USB1_HUB_R1: length 3.1
  TOP w0.127: R82.2 72.66,162.71 72.35,163.02 71.66,163.02 71.41,163.28 U11.32
USB1_HUB_REFCLK: length 32.4
  TOP w0.127: R81.2 71.56,160 v2(71.92,159.65)
  L3-SIGNAL1 w0.089: v3(98.65,155.86) v5(98.99,155.86)
  L4-GND2 w0.102: v5(98.99,155.86) v7(99.4,155.86)
  L5-SIGNAL2 w0.102: v7(99.4,155.86) 95.61,159.65 v2(71.92,159.65)
USB1_HUB_TEST: length 2.6
  TOP w0.127: R79.2 63.48,162.62 63.91,163.04 U11.17
USB1_HUB_VBUS: length 3.1
  TOP w0.127: U11.16 R59.2 R58.2
USB1_HUB_XI: length 2.3
  TOP w0.127: R81.1 70.72,162.52 70.41,162.83 U11.30
USB1_HUB_XO: length 2.2
  TOP w0.127: R88.1 69.71,163 69.91,163.2 U11.29
USB1_ID: length 1.7
  BOTTOM w0.127: R797.2 U177.3
USB1_VBUS_SOC: length 3.1
  BOTTOM w0.305: R806.2 R804.1 150.93,163.88 150.76,163.71 U177.6
USB2.0_MUX_OEN: length 12.7
  TOP w0.127: v2(136.52,167.1) 137.3,167.1 137.56,167.37 U12.6
  L14-SIGNAL6 w0.089: v2(142.07,165.32) 140.7,166.7 136.92,166.7 v2(136.52,167.1)
  BOTTOM w0.127: U177.15 143.06,166.31 v2(142.07,165.32) 143.03,164.36 U177.12
USB2.0_MUX_SEL: length 32.5
  TOP w0.127: U12.9 139.06,167.34 v2(139.05,167.33)
  L5-SIGNAL2 w0.102: v2(157.41,164.5) 155.19,166.72 152.4,166.72 152.16,166.96 v2(151.3,166.96) 151.65,166.61 151.65,162.84 150.64,161.84 143.68,161.84 142.22,163.3 141.09,163.3 139.85,164.54 139.85,166.53 v2(139.05,167.33)
  BOTTOM w0.127: U173.13 v2(157.41,164.5) ; R785.2 R790.1 U177.1
USB_3V3_IN+: length 4.8
  BOTTOM w0.127: R888.1 150.87,127.47 150.98,127.58 C699.2 150.98,128.62 151.19,128.83 U184.10 151.19,130.79 U185.D3
USB_3V3_IN-: length 6.3
  BOTTOM w0.127: 151.9,128.62 151.69,128.83 U184.9 ; 151.9,128.62 152.19,128.91 U184.8 152.19,130.78 152.39,130.98 152.39,131.19 ; 151.9,128.62 C699.1 151.9,127.54 152.01,127.43 R887.1 ; 152.39,131.19 U185.D2 ; 152.39,131.19 U185.D1
USB_CONN#1_D_N: length 10.1
  TOP w0.114: J5.2 44.76,178.43 44.76,177.51 42.65,175.4 42.65,174.98 42.99,174.64 U9.5 42.99,173.69 42.65,173.35 42.65,172.82 42.19,172.37 41.08,172.37 40.78,172.08 L8.2
USB_CONN#1_D_P: length 10.1
  TOP w0.114: L8.3 40.78,172.93 41.07,172.63 42.08,172.63 42.38,172.93 42.38,173.36 42.04,173.7 U9.6 42.04,174.64 42.38,174.98 42.38,175.51 44.49,177.62 44.49,178.48 43.88,179.09 J5.3
USB_CONN#2_D_N: length 17
  BOTTOM w0.114: L38.2 55.73,184.04 55.43,184.34 55.11,184.34 54.87,184.1 54.87,182.04 54.53,181.69 54.08,181.69 53.74,181.35 U160.5 53.26,181.35 52.92,181.69 49.84,181.69 48.33,183.21 44.67,183.21 44.37,182.92 44.37,182.26 44.92,181.71 J5.6
USB_CONN#2_D_P: length 17
  BOTTOM w0.114: L38.3 55.86,184.89 55.73,184.89 55.45,184.61 55,184.61 54.61,184.21 54.61,182.15 54.42,181.96 54.08,181.96 53.74,182.3 U160.6 53.26,182.3 52.92,181.96 49.95,181.96 48.44,183.47 44.55,183.47 44.11,183.03 44.11,182.4 J5.7
USB_DM_FT2232: length 19.1
  TOP w0.114: J48.2 188.78,4.95 188.6,5.14 188.59,5.14 188.59,7.24 188.71,7.36 ; U144.7 189.54,14.33 189.66,14.44 189.66,15.13 v3(189.47,15.32) ; U156.3 188.71,7.36 ; 188.71,7.36 188.59,7.47 188.59,8.8 v3(188.79,8.99)
  L3-SIGNAL1 w0.091: v3(188.79,8.99) 188.79,8.03 188.54,7.78 187.41,7.78 186.84,8.36 186.84,11.73 189.68,14.58 189.68,15.11 v3(189.47,15.32)
USB_DM_FT4232: length 20
  TOP w0.114: v3(211.27,6.42) 210.7,6.42 U157.5 210.57,6.42 209.44,6.42 209.2,6.17 209.2,5.14 209.39,4.95 J49.2 ; v3(215.56,15.2) 215.76,15 215.76,14.44 215.64,14.33 U145.7
  L3-SIGNAL1 w0.091: v3(211.27,6.42) 211.29,6.44 212.63,6.44 212.73,6.54 212.73,6.85 212.64,6.94 211.87,6.94 211.45,7.36 211.45,10.97 213.71,13.24 214.92,13.24 215.78,14.1 215.78,14.98 v3(215.56,15.2)
USB_DP_FT2232: length 19
  TOP w0.114: U144.8 190.04,14.33 189.93,14.44 189.93,15.13 v3(190.12,15.32) ; 187.7,6.36 188.21,6.36 ; 188.21,6.36 188.33,6.24 188.33,5.14 188.13,4.95 J48.3 ; 188.21,6.36 188.33,6.47 188.33,8.8 v3(188.13,8.99)
  L3-SIGNAL1 w0.091: v3(188.13,8.99) 187.92,8.78 187.92,8.62 188.04,8.49 188.48,8.49 188.57,8.4 188.57,8.12 188.45,8 187.5,8 187.06,8.45 187.06,11.64 189.9,14.49 189.9,15.11 v3(190.12,15.32)
USB_DP_FT4232: length 20
  TOP w0.114: v3(212.75,7.36) U157.3 211.6,7.36 210.93,6.69 209.33,6.69 208.93,6.29 208.93,5.14 208.74,4.95 J49.3 ; U145.8 216.14,14.33 216.02,14.44 216.02,15 v3(216.22,15.2)
  L3-SIGNAL1 w0.091: v3(212.75,7.36) 212.55,7.16 211.96,7.16 211.67,7.45 211.67,10.88 213.8,13.02 215.01,13.02 216,14.01 216,14.98 v3(216.22,15.2)
USBC_CC1: length 40.2
  TOP w0.127: v2(150.69,178.87) 150.01,179.55 150.01,181.07 150.32,181.38 J4.A5
  L3-SIGNAL1 w0.089: v2(181.41,185.32) 181.41,183.48 178.52,180.59 159.51,180.59 157.79,178.87 v2(150.69,178.87)
  BOTTOM w0.127: U164.2 150.69,178.88 v2(150.69,178.87) ; v2(181.41,185.32) 181.66,185.06 U158.1
USBC_CC2: length 48.4
  TOP w0.127: J4.B5 148.57,184.82 v2(148.95,185.2)
  L3-SIGNAL1 w0.089: v2(182.38,185.31) 181.88,185.81 181.24,185.81 180.98,185.56 180.98,183.36 178.43,180.81 161.83,180.81 161.03,181.61 159.8,181.61 157.46,179.27 148.49,179.27 v2(148.09,178.88)
  BOTTOM w0.127: v2(182.38,185.31) 182.06,184.99 U158.2 ; v2(148.95,185.2) 148.95,180.55 148.7,180.3 U164.1 v2(148.09,178.88)
USBC_CTRL1_SW: length 2.5
  BOTTOM w0.127: U162.3 R764.1 R763.2
USBC_CURRENT_MODE: length 2.7
  BOTTOM w0.127: R731.2 183.54,185.92 183.22,185.61 183.22,184.69 183.01,184.48 U158.3
USBC_DATA_CONN_N: length 13.9
  TOP w0.114: L7.3 148.94,175.94 149.23,176.23 149.23,176.96 149.12,177.07 U5.1 148.7,177.25 149.22,177.77 149.22,177.93 148.53,178.61 148.53,179.8 149.19,180.45 149.19,182.45 149.07,182.56 v3(148.82,182.56)
  L3-SIGNAL1 w0.091: v3(149.57,184.26) 149.44,184.13 149.44,183.62 149.13,183.31 148.78,183.31 148.38,182.91 148.38,182.11 148.62,181.87 149.11,181.87 149.26,182.02 149.26,182.79 149.14,182.9 148.93,182.9 148.82,182.79 v3(148.82,182.56)
USBC_DATA_CONN_P: length 14
  TOP w0.114: v3(149.82,182.56) 149.57,182.56 149.45,182.45 149.45,180.34 148.8,179.69 148.8,178.72 149.48,178.04 149.48,177.76 150,177.24 U5.2 149.61,177.07 149.5,176.96 149.5,176.22 149.79,175.93 L7.2
  L3-SIGNAL1 w0.091: v3(149.82,182.56) 149.56,182.56 149.47,182.47 149.47,181.93 149.2,181.65 148.53,181.65 148.16,182.02 148.16,183 148.69,183.53 149.04,183.53 149.22,183.71 149.22,184.11 v3(149.07,184.26)
USBC_DIR_SOC: length 366.8
  L3-SIGNAL1 w0.089: v3(125.52,72.63) v5(125.79,72.4)
  L4-GND2 w0.102: v5(125.79,72.4) v7(126.1,72.1)
  L5-SIGNAL2 w0.102: v2(129.93,60.91) 132.62,58.22 132.62,46.56 130.77,44.71 100.76,44.71 96.2,49.28 78.01,49.28 74.56,52.73 69.63,52.73 68.32,54.04 62.48,54.04 v2(62.44,54)
  L7-SIGNAL3 w0.109: v2(62.53,82.55) 62.53,75.1 63.56,74.07 63.56,67.34 62.44,66.22 v2(62.44,54) ; v2(129.93,60.91) 126.58,64.26 126.58,71.62 v7(126.1,72.1)
  L12-SIGNAL5 w0.102: v2(179.3,183.67) 156.57,183.67 154.13,181.24 143.33,181.24 141.25,183.32 86.22,183.32 83.12,186.42 68.21,186.42 67.1,185.31 67.1,185.22 59.82,177.93 59.82,175.25 59.41,174.84 59.41,159.17 65.37,153.21 65.37,134.28 60.29,129.2 60.29,115.93 59.37,115.01 59.37,107.4 59.14,107.17 59.14,96.62 57.4,94.88 57.4,84.42 59.26,82.55 v2(62.53,82.55)
  BOTTOM w0.127: U158.11 180.13,184.08 179.73,183.67 v2(179.3,183.67)
  vias: v1(125.52,72.63)
USBC_ID: length 6.9
  BOTTOM w0.127: U165.1 180.82,178.21 179.84,179.19 179.84,181 R745.1 180.58,181.77 180.58,182.89 180.97,183.28 U158.9
USBC_MODE_SEL0: length 24.9
  TOP w0.127: SW2.4 v2(150.35,170.25) ; U7.1 v2(154.84,177.55)
  L5-SIGNAL2 w0.102: v2(161.07,167.15) 159.7,168.52 154.89,168.52 153.7,169.7 150.89,169.7 v2(150.35,170.25) 150.35,172 154.84,176.49 v2(154.84,177.55)
  BOTTOM w0.127: U173.6 v2(161.07,167.15)
USBC_MODE_SEL1: length 34.2
  TOP w0.127: v2(156.1,181.78) 156.34,181.54 U4.1 ; SW2.3 v2(151.62,170.25)
  L5-SIGNAL2 w0.102: v2(156.1,181.78) 156.1,177.37 151.21,172.48 151.21,170.66 v2(151.62,170.25) 152.05,170.68 154.34,170.68 155.14,169.88 161.86,169.88 162.41,169.33 162.41,168.58 v2(161.98,168.15)
  BOTTOM w0.127: v2(156.1,181.78) 156.1,180.21 155.86,179.97 U162.1 ; v2(161.98,168.15) 161.48,167.65 U173.5
USBC_OUT1: length 7.2
  BOTTOM w0.127: TP253.1 184.49,180.02 184.34,179.86 R753.2 183,180.36 182.71,180.65 182.71,181.47 183,181.76 R743.1 183.39,182.38 183.26,182.51 182.23,182.51 182.06,182.67 U158.7
USBC_OUT2: length 4.5
  BOTTOM w0.127: TP254.1 181.26,179.84 181.26,181.03 R744.2 181.66,182.08 U158.8
USBC_PD_BOOT: length 1.7
  TOP w0.127: U8.32 173.42,173.77 v2(173.13,173.48)
  BOTTOM w0.127: v2(173.13,173.48) 172.88,173.22 C568.2
USBC_PD_CC1: length 5.7
  TOP w0.127: U8.20 176.51,178.44 176.92,178.85 v2(176.92,178.9)
  L5-SIGNAL2 w0.102: v2(180.59,180.92) 178.58,178.9 v2(176.92,178.9)
USBC_PD_CSN/OUT: length 44.8
  TOP w0.203: C7.1 181.77,180.49 181.77,183.47 180.63,184.61 178.9,184.61 178.55,184.26 176.82,184.26 174.35,186.72 169.99,186.72 169.43,187.28 R6.2
  TOP w0.254: v2(180.83,176.1) 180.5,175.77 U8.13
  L5-SIGNAL2 w0.381: v2(166.77,188.24) 166.77,186.84 167.57,186.04 174.68,186.04 176.72,184.01 178.01,184.01 180.17,181.85 180.96,181.85 181.64,181.16 181.64,179.92 180.83,179.1 v2(180.83,176.1)
USBC_PD_CSP: length 3.7
  TOP w0.254: U8.14 179.95,176.27 180.32,176.64 180.32,177.35 R11.1
USBC_PD_CTRL1: length 26.6
  TOP w0.127: v2(177.02,170.67) 176.51,171.18 U8.5
  L5-SIGNAL2 w0.102: v2(159.18,179.3) 160.33,178.15 160.33,176.08 164.71,171.7 176.53,171.7 177.02,171.21 v2(177.02,170.67)
  BOTTOM w0.127: U161.4 v2(159.18,179.3)
USBC_PD_CTRL2: length 1.5
  TOP w0.127: U8.6 R28.1
USBC_PD_FAULT#: length 2.3
  TOP w0.127: v2(174,178.92) 174,178.91 174,178.74 174.51,178.22 U8.24
  BOTTOM w0.127: v2(174,178.92) 174.34,179.25 R748.1
USBC_PD_ILIMIT: length 2.3
  TOP w0.127: R18.1 180.55,175.27 U8.12
USBC_PD_IMON: length 2.6
  TOP w0.127: U8.11 179.91,174.77 R24.1
USBC_PD_LD_DET#: length 18.2
  TOP w0.127: U8.23 175.01,178.77 174.92,178.87 v2(174.92,178.93)
  BOTTOM w0.127: v2(174.92,178.93) 174.92,178.59 175.17,178.34 176.06,178.34 176.34,178.62 176.34,179.19 176.6,179.46 R746.2 177.01,179.89 177.45,180.34 R752.1 178.35,180.34 178.59,180.1 178.59,176.52 178.98,176.13 179.84,176.13 180.22,176.52 182.76,176.52 184.16,175.11 U166.1
USBC_PD_LS_GD: length 14.4
  TOP w0.127: v2(179.71,174.04) 179.48,174.27 U8.10 ; U1.5 v2(178.98,185.95)
  L14-SIGNAL6 w0.089: v2(179.71,174.04) 180.16,174.48 180.16,178.83 179.74,179.25 179.74,185.19 v2(178.98,185.95)
USBC_PD_POL#: length 2.2
  TOP w0.127: v2(175.83,178.92) 175.51,178.61 U8.22
  BOTTOM w0.127: R747.1 175.86,179.47 175.86,179.39 175.83,179.36 v2(175.83,178.92)
USBC_PD_RT/SYNC: length 2.7
  TOP w0.127: U8.9 179.26,173.77 179.87,173.16 180.38,173.16 R26.1
USBC_PD_SW:
  vias: v2(161.92,179.35) v2(161.92,178.53) v2(161.92,177.72) v2(166.11,179.35) v2(166.11,178.53) v2(166.11,177.72) v2(172.4,175.74) v2(172.4,174.98) v2(173.16,175.74) v2(173.16,174.98) v2(173.16,174.22)
USBC_PORT: length 33.8
  TOP w0.127: R8.1 158.78,180.03 158.54,179.79 v2(158.54,178.68) 158.54,176.73 R16.1
  L3-SIGNAL1 w0.089: v2(158.54,178.68) 158.54,179.32 159.6,180.38 178.64,180.38 183.03,184.77 v2(183.74,184.77)
  BOTTOM w0.127: v2(183.74,184.77) 183.68,184.71 183.68,184.26 183.49,184.08 U158.4
USBC_PORT_SW1: length 2.4
  TOP w0.127: R10.2 155.57,178.68 U4.3
USBC_PORT_SW2: length 1.5
  TOP w0.127: U7.3 157.2,175.82 R16.2
USBC_PWR_EN: length 21.9
  TOP w0.127: U8.4 v2(176.01,170.65)
  L14-SIGNAL6 w0.089: v2(176.01,170.65) 166.62,170.65 164.56,168.59 161.5,168.59 v2(161.07,168.15)
  BOTTOM w0.127: R783.2 162.77,168.6 161.8,168.6 161.35,168.15 v2(161.07,168.15) U173.4
USBC_SS_RX1_CONN_N: length 9.9
  TOP w0.114: J4.B10 151.07,184.73 arc(151.08,184.79) 151.11,184.83 151.15,184.87 arc(151.18,184.91) 151.19,184.96 151.19,185.21 arc(151.36,185.62) 151.76,185.79 152.66,185.79 arc(152.89,185.75) 153.09,185.65 arc(153.23,185.55) 153.4,185.51 155.34,185.51 arc(155.44,185.53) 155.53,185.59 155.71,185.77 D2.1 155.94,185.77 156.12,185.59 arc(156.21,185.53) 156.31,185.51 157.41,185.51 arc(157.89,185.31) 158.09,184.83 158.09,184.58 arc(158.12,184.45) 158.19,184.35 158.38,184.15 L3.2
USBC_SS_RX1_CONN_P: length 9.1
  TOP w0.114: L3.3 157.53,184.15 157.71,184.33 arc(157.8,184.46) 157.83,184.6 157.83,184.83 arc(157.71,185.12) 157.41,185.24 156.33,185.24 arc(156.22,185.22) 156.12,185.16 155.95,184.99 D4.1 155.7,184.99 155.53,185.16 arc(155.43,185.22) 155.32,185.24 153.4,185.24 arc(153.14,185.3) 152.92,185.44 arc(152.8,185.5) 152.66,185.52 151.76,185.52 arc(151.55,185.43) 151.45,185.21 151.45,184.96 arc(151.46,184.91) 151.49,184.87 151.53,184.83 arc(151.56,184.79) 151.57,184.73 J4.B11
USBC_SS_RX1_N: length 70.9
  TOP w0.114: v2(158.34,180.9) 158.16,181.09 arc(158.11,181.16) 158.09,181.24 158.09,181.53 arc(158.11,181.61) 158.16,181.68 158.19,181.71 arc(158.33,181.93) L3.1
  L12-SIGNAL5 w0.108: v2(158.34,180.9) 158.31,180.87 arc(158.19,180.69) 158.15,180.48 158.15,180.15 arc(158.05,179.64) 157.76,179.21 154.82,176.27 arc(154.7,176.09) 154.66,175.87 arc(154.56,175.41) 154.3,175.02 151.56,172.27 arc(151.22,171.77) 151.1,171.17 151.1,170.01 arc(150.98,169.42) 150.65,168.91 137.13,155.39 137.12,155.39 arc(136.37,154.26) 136.1,152.92 136.1,131.19 arc(135.93,130.3) 135.42,129.55 134.37,128.5 arc(134.02,127.97) 133.9,127.35 133.9,124.94 arc(133.7,124.47) 133.23,124.28 132.37,124.28 arc(132.03,124.42) 131.88,124.77 131.88,125.01 arc(131.81,125.18) 131.64,125.25 v8(131.6,125.25)
  L13-GND5 w0.108: v8(131.6,125.25) v9(131.6,125.58)
  L14-SIGNAL6 w0.091: v9(131.6,125.58) v11(131.6,125.91)
USBC_SS_RX1_P: length 71.8
  TOP w0.114: v2(157.58,180.9) 157.76,181.09 arc(157.81,181.16) 157.83,181.24 157.83,181.53 arc(157.81,181.61) 157.76,181.68 157.73,181.71 arc(157.59,181.93) L3.4
  L12-SIGNAL5 w0.108: v8(132.61,125.25) 132.61,125.67 arc(132.37,125.92) 132.12,125.67 132.12,124.77 arc(132.19,124.59) 132.37,124.51 133.23,124.51 arc(133.54,124.64) 133.66,124.94 133.66,127.35 arc(133.8,128.06) 134.21,128.67 135.26,129.71 arc(135.71,130.39) 135.87,131.19 135.87,152.92 arc(136.15,154.35) 136.96,155.56 150.48,169.08 arc(150.77,169.51) 150.87,170.01 150.87,171.17 arc(151,171.86) 151.39,172.44 154.13,175.18 arc(154.35,175.5) 154.42,175.87 arc(154.48,176.18) 154.65,176.44 157.59,179.38 arc(157.83,179.73) 157.91,180.15 157.91,180.68 arc(157.85,180.84) 157.69,180.9 v2(157.58,180.9)
  L13-GND5 w0.108: v9(132.61,125.58) v8(132.61,125.25)
  L14-SIGNAL6 w0.091: v11(132.61,125.91) v9(132.61,125.58)
USBC_SS_RX2_CONN_N: length 4.8
  TOP w0.114: J4.A10 147.32,182.09 arc(147.31,182.03) 147.28,181.99 147.24,181.95 arc(147.21,181.91) 147.2,181.86 147.2,181.01 arc(147.22,180.92) 147.28,180.83 147.37,180.75 arc(147.44,180.64) D6.1 arc(147.44,180.39) 147.37,180.29 147.28,180.2 arc(147.22,180.12) 147.2,180.02 147.2,179.9 arc(147.15,179.64) 147,179.41 146.95,179.36 arc(146.86,179.23) 146.83,179.07 146.83,178.87 arc(146.84,178.78) 146.89,178.71 146.92,178.68 arc(147.07,178.46) L5.2
USBC_SS_RX2_CONN_P: length 4.8
  TOP w0.114: J4.A11 146.82,182.09 arc(146.83,182.03) 146.86,181.99 146.9,181.95 arc(146.93,181.91) 146.94,181.86 146.94,181.01 arc(146.92,180.92) 146.87,180.84 146.78,180.75 arc(146.71,180.64) D5.1 arc(146.71,180.38) 146.78,180.27 146.87,180.18 arc(146.92,180.11) 146.94,180.02 146.94,179.9 arc(146.91,179.74) 146.81,179.6 146.76,179.55 arc(146.61,179.33) 146.56,179.07 146.56,178.87 arc(146.54,178.78) 146.5,178.71 146.47,178.68 arc(146.32,178.46) L5.3
USBC_SS_RX2_N: length 59.1
  TOP w0.114: v2(147.08,175.21) 146.89,175.4 arc(146.84,175.47) 146.83,175.55 146.83,175.84 arc(146.84,175.92) 146.89,175.99 146.92,176.02 arc(147.07,176.24) L5.1
  L12-SIGNAL5 w0.108: v8(129.91,128.27) 130.08,128.27 arc(130.24,128.33) 130.3,128.49 130.3,128.7 arc(130.34,128.93) 130.47,129.12 133.24,131.89 arc(133.68,132.53) 133.86,133.29 arc(133.86,133.34) 133.86,133.38 133.86,133.38 133.86,155.5 arc(134.13,156.85) 134.89,157.99 138.88,161.98 arc(139.46,162.85) 139.67,163.88 139.67,166.34 arc(139.79,166.97) 140.15,167.51 141.53,168.88 arc(141.79,169.28) 141.89,169.75 141.89,170.37 arc(141.96,170.72) 142.16,171.03 144.04,172.91 arc(144.33,173.34) 144.43,173.84 144.43,175.74 arc(144.62,176.21) 145.09,176.41 146.49,176.41 arc(146.81,176.28) 146.94,175.96 146.94,175.54 arc(146.97,175.36) v2(147.08,175.21)
  L13-GND5 w0.108: v8(129.91,128.27) v9(129.91,128.6)
  L14-SIGNAL6 w0.091: v9(129.91,128.6) v11(129.91,128.92)
USBC_SS_RX2_P: length 59.1
  TOP w0.114: v2(146.31,175.21) 146.5,175.4 arc(146.54,175.47) 146.56,175.55 146.56,175.84 arc(146.54,175.92) 146.5,175.99 146.47,176.02 arc(146.32,176.24) L5.4
  L12-SIGNAL5 w0.108: v8(130.93,128.27) 130.75,128.27 arc(130.6,128.33) 130.53,128.49 130.53,128.7 arc(130.56,128.84) 130.64,128.96 131.03,129.34 arc(131.15,129.39) 131.27,129.34 131.32,129.29 arc(131.56,129.29) 131.56,129.53 131.5,129.58 arc(131.45,129.7) 131.5,129.82 133.41,131.72 arc(133.9,132.44) 134.09,133.28 134.09,133.28 134.09,133.49 134.09,155.5 arc(134.34,156.76) 135.06,157.82 139.04,161.81 arc(139.68,162.76) 139.9,163.88 139.9,166.34 arc(140.01,166.88) 140.32,167.34 141.69,168.72 arc(142.01,169.19) 142.12,169.75 142.12,170.37 arc(142.17,170.63) 142.32,170.86 144.21,172.74 arc(144.54,173.25) 144.66,173.84 144.66,175.74 arc(144.79,176.05) 145.09,176.17 146.49,176.17 arc(146.64,176.11) 146.7,175.96 146.7,175.57 arc(146.6,175.32) 146.35,175.21 v2(146.31,175.21)
  L13-GND5 w0.108: v8(130.93,128.27) v9(130.93,128.6)
  L14-SIGNAL6 w0.091: v9(130.93,128.6) v11(130.93,128.92)
USBC_SS_TX1_CONN_N: length 4.8
  TOP w0.114: J4.A3 151.32,182.09 arc(151.33,182.03) 151.36,181.99 151.4,181.95 arc(151.43,181.91) 151.44,181.86 151.44,181.01 arc(151.42,180.92) 151.37,180.84 151.28,180.75 arc(151.21,180.64) D7.1 arc(151.21,180.39) 151.28,180.29 151.36,180.2 arc(151.42,180.12) 151.44,180.02 151.44,179.9 arc(151.49,179.64) 151.64,179.41 151.7,179.36 arc(151.78,179.23) 151.82,179.07 151.82,178.87 arc(151.8,178.78) 151.75,178.71 151.72,178.68 arc(151.58,178.46) L6.3
USBC_SS_TX1_CONN_P: length 4.8
  TOP w0.114: J4.A2 151.82,182.09 arc(151.81,182.03) 151.78,181.99 151.74,181.95 arc(151.71,181.91) 151.7,181.86 151.7,181.01 arc(151.72,180.92) 151.78,180.83 151.87,180.75 arc(151.94,180.64) D8.1 arc(151.94,180.38) 151.86,180.27 151.77,180.18 arc(151.72,180.11) 151.7,180.02 151.7,179.9 arc(151.74,179.74) 151.83,179.6 151.88,179.55 arc(152.03,179.33) 152.08,179.07 152.08,178.87 arc(152.1,178.78) 152.15,178.71 152.17,178.68 arc(152.32,178.46) L6.2
USBC_SS_TX1_N: length 63.6
  TOP w0.114: v2(151.57,175.21) 151.75,175.4 arc(151.8,175.47) 151.82,175.55 151.82,175.84 arc(151.8,175.92) 151.75,175.99 151.72,176.02 arc(151.58,176.24) L6.4
  L12-SIGNAL5 w0.108: v2(151.57,175.21) 151.6,175.21 arc(151.76,175.15) 151.83,174.98 151.83,174.74 arc(151.78,174.47) 151.63,174.25 151.16,173.79 arc(150.95,173.7) 150.73,173.79 150.72,173.79 arc(150.29,173.79) 150.29,173.36 150.29,173.35 arc(150.38,173.13) 150.29,172.92 148.73,171.36 arc(148.46,170.94) 148.36,170.45 148.36,169.7 arc(148.25,169.15) 147.94,168.68 135.92,156.66 arc(135.12,155.46) 134.84,154.04 134.84,132.76 arc(134.53,131.25) 133.68,129.96 131.73,128.01 arc(131.29,127.72) 130.77,127.62 127.35,127.62 arc(127.22,127.67) 127.16,127.8 127.16,128.14 arc(127.19,128.22) 127.27,128.25 v8(127.55,128.25)
  L13-GND5 w0.108: v9(127.55,128.58) v8(127.55,128.25)
  L14-SIGNAL6 w0.091: v11(127.55,128.9) v9(127.55,128.58)
USBC_SS_TX1_P: length 63.6
  TOP w0.114: v2(152.33,175.21) 152.14,175.4 arc(152.1,175.47) 152.08,175.55 152.08,175.84 arc(152.1,175.92) 152.15,175.99 152.17,176.02 arc(152.32,176.24) L6.1
  L12-SIGNAL5 w0.108: v2(152.33,175.21) 152.29,175.21 arc(152.13,175.15) 152.07,174.98 152.07,174.74 arc(152,174.39) 151.8,174.09 148.9,171.19 arc(148.67,170.85) 148.59,170.45 148.59,169.7 arc(148.47,169.06) 148.1,168.51 136.09,156.49 arc(135.34,155.37) 135.07,154.04 135.07,132.76 arc(134.75,131.16) 133.84,129.8 131.89,127.85 arc(131.38,127.5) 130.77,127.38 127.35,127.38 arc(127.05,127.51) 126.93,127.8 126.93,128.14 arc(126.89,128.22) 126.82,128.25 v8(126.54,128.25)
  L13-GND5 w0.108: v8(126.54,128.25) v9(126.54,128.58)
  L14-SIGNAL6 w0.091: v9(126.54,128.58) v11(126.54,128.9)
USBC_SS_TX2_CONN_N: length 10
  TOP w0.114: J4.B3 147.57,184.73 arc(147.56,184.79) 147.53,184.83 147.49,184.87 arc(147.46,184.91) 147.45,184.96 147.45,185.21 arc(147.26,185.68) 146.8,185.87 144.36,185.87 arc(144.04,185.8) 143.77,185.62 arc(143.65,185.54) 143.5,185.51 143.31,185.51 arc(143.2,185.53) 143.11,185.59 142.93,185.77 D1.1 142.7,185.77 142.53,185.59 arc(142.44,185.53) 142.33,185.51 141.21,185.51 arc(140.77,185.33) 140.59,184.89 140.59,184.6 arc(140.56,184.46) 140.48,184.33 140.3,184.15 L2.3
USBC_SS_TX2_CONN_P: length 9.1
  TOP w0.114: J4.B2 147.07,184.73 arc(147.08,184.79) 147.11,184.83 147.15,184.87 arc(147.18,184.91) 147.19,184.96 147.19,185.21 arc(147.07,185.49) 146.8,185.6 144.36,185.6 arc(144.14,185.56) 143.96,185.44 arc(143.75,185.29) 143.5,185.24 143.33,185.24 arc(143.21,185.22) 143.11,185.16 142.94,184.99 D3.1 142.69,184.99 142.52,185.16 arc(142.43,185.22) 142.31,185.24 141.21,185.24 arc(140.96,185.14) 140.86,184.89 140.86,184.58 arc(140.89,184.45) 140.96,184.35 141.15,184.15 L2.2
USBC_SS_TX2_N: length 58.7
  TOP w0.114: v2(140.35,180.9) 140.53,181.09 arc(140.58,181.16) 140.59,181.24 140.59,181.53 arc(140.58,181.61) 140.53,181.68 140.5,181.71 arc(140.35,181.93) L2.4
  L12-SIGNAL5 w0.108: v2(140.35,180.9) 140.37,180.88 arc(140.51,180.67) 140.55,180.44 140.55,171.21 arc(140.36,170.22) 139.8,169.39 133.38,162.97 arc(132.95,162.33) 132.8,161.58 132.8,134.25 arc(132.53,132.88) 131.76,131.72 131.14,131.1 arc(130.71,130.82) 130.21,130.72 129.12,130.72 arc(128.95,130.79) 128.87,130.96 128.87,131.13 arc(128.91,131.21) 128.98,131.24 v8(129.26,131.24)
  L13-GND5 w0.108: v9(129.26,131.57) v8(129.26,131.24)
  L14-SIGNAL6 w0.091: v11(129.26,131.9) v9(129.26,131.57)
USBC_SS_TX2_P: length 59.5
  TOP w0.114: v2(141.11,180.9) 140.92,181.09 arc(140.88,181.16) 140.86,181.24 140.86,181.53 arc(140.88,181.61) 140.93,181.68 140.95,181.71 arc(141.1,181.93) L2.1
  L12-SIGNAL5 w0.108: v2(141.11,180.9) 140.89,180.69 arc(140.82,180.57) 140.79,180.44 140.79,171.21 arc(140.58,170.13) 139.97,169.22 133.55,162.8 arc(133.17,162.24) 133.04,161.58 133.04,134.25 arc(132.75,132.79) 131.93,131.56 131.3,130.94 arc(130.8,130.6) 130.21,130.48 129.12,130.48 arc(128.78,130.62) 128.64,130.96 128.64,131.13 arc(128.61,131.21) 128.53,131.24 v8(128.25,131.24)
  L13-GND5 w0.108: v8(128.25,131.24) v9(128.25,131.57)
  L14-SIGNAL6 w0.091: v9(128.25,131.57) v11(128.25,131.9)
USBC_VBUS_DET: length 2
  BOTTOM w0.127: R732.1 184.05,183.68 U158.5
USBC_VCON_FAULT#: length 3.4
  BOTTOM w0.127: TP252.1 184.42,182.39 R739.2 184.06,183.28 U158.6
USER_INPUT1: length 15.7
  TOP w0.127: v2(142.73,170.25) SW2.10
  L5-SIGNAL2 w0.102: v2(153.53,169.27) 153.12,168.87 144.11,168.87 v2(142.73,170.25)
  BOTTOM w0.127: U173.22 153.67,168.65 153.53,168.79 v2(153.53,169.27)
USER_LED1: length 41.9
  L3-SIGNAL1 w0.089: v2(154.26,173.7) 154.29,173.7 160.75,180.16 178.73,180.16 182.93,184.37 184.39,184.37 184.72,184.69 v3(184.72,185.6)
  BOTTOM w0.127: U173.23 154.56,169.15 154.08,169.63 153.81,169.63 153.6,169.83 153.6,173.08 154.23,173.7 v2(154.26,173.7)
USER_LED2: length 43
  L3-SIGNAL1 w0.089: v2(154.26,172.63) 154.82,173.19 154.82,173.92 160.84,179.95 178.82,179.95 183.02,184.15 186.54,184.15 v3(187.89,185.5)
  BOTTOM w0.127: v2(154.26,172.63) 154.26,172.6 154.35,172.51 154.4,172.51 154.62,172.3 154.62,169.91 154.87,169.65 U173.24
V_3V3: length 50.8
  L3-SIGNAL1 w0.254: v3(204.03,157.66) 204.38,158 204.38,158.8 198.38,164.8 185.48,164.8 184.46,165.81 184.46,166.34 v3(183.94,166.86) ; v3(203.92,143.52) 204.26,143.18 204.26,142.39 202.98,141.1 190.67,141.1 184.46,134.89 184.46,134.36 v3(183.94,133.84)
  vias: v2(165.76,157.4) v2(165.76,156.26) v2(165.76,155.11) v2(165.76,153.97) v2(165.76,152.83) v2(165.76,147.87) v2(165.76,146.73) v2(165.76,145.59) v2(165.76,144.44) v2(165.76,143.3) v2(166.9,157.4) v2(166.9,156.26) v2(166.9,155.11) v2(166.9,153.97) v2(166.9,152.83) v2(166.9,147.87) v2(166.9,146.73) v2(166.9,145.59) v2(166.9,144.44) v2(166.9,143.3) v2(168.05,157.4) v2(168.05,156.26) v2(168.05,155.11) v2(168.05,153.97) v2(168.05,152.83) v2(168.05,147.87) v2(168.05,146.73) v2(168.05,145.59) v2(168.05,144.44) v2(168.05,143.3) v2(169.79,158.54) v2(169.79,157.4) v2(169.79,150.92) v2(169.79,149.78) v2(169.87,143.3) v2(169.87,142.16) v2(170.93,158.54) v2(170.93,157.4) v2(170.93,150.92) v2(170.93,149.78) v2(171.01,143.3) v2(171.01,142.16) v2(172.08,158.54) v2(172.08,157.4) v2(172.08,150.92) v2(172.08,149.78) v2(172.15,143.3) v2(172.15,142.16) v2(180.55,168.73) v2(180.55,167.46) v2(180.55,166.19) v2(180.55,164.92) v2(180.55,163.65) v2(180.6,137.27) v2(180.6,136) v2(180.6,134.73) v2(180.6,133.46) v2(180.6,132.19) v2(181.72,168.73) v2(181.72,167.46) v2(181.72,166.19) v2(181.72,164.92) v2(181.72,163.65) v2(181.77,137.27) v2(181.77,136) v2(181.77,134.73) v2(181.77,133.46) v2(181.77,132.19) v2(182.89,168.73) v2(182.89,167.46) v2(182.89,166.19) v2(182.89,164.92) v2(182.89,163.65) v2(182.94,137.27) v2(182.94,136) v2(182.94,134.73) v2(182.94,133.46) v2(182.94,132.19)
V_12V0: length 28.5
  TOP w0.254: U81.17 v2(206.01,60.46)
  L12-SIGNAL5 w0.203: v2(230.72,65.97) 230.72,64.83 230.44,64.55 219.27,64.55 218.38,63.66 211.38,63.66 208.19,60.46 v2(206.01,60.46)
VBUS_5V_WIFI/BT:
  vias: v2(137.64,176.38) v2(138.55,176.38)
VCAP_MCU_VDDS0: length 3.2
  TOP w0.305: U59.J25 114.31,75.03 v2(113.92,74.63)
  BOTTOM w0.127: C1048.1 113.52,72.7 113.52,74.24 v2(113.92,74.63)
VCAP_MCU_VDDS1: length 3.2
  TOP w0.305: v2(115.52,74.63) 115.91,75.03 U59.J23
  BOTTOM w0.127: v2(115.52,74.63) 115.91,74.24 115.91,72.75 C1046.1
VCAP_MCU_VDDS2: length 0.6
  TOP w0.305: v2(114.72,74.63) 115.11,75.03 U59.J24
VCAP_VDDS0: length 0.6
  TOP w0.305: U59.T27 112.71,80.63 v2(112.32,80.23)
VCAP_VDDS2: length 0.6
  TOP w0.305: v2(112.32,78.63) 112.71,79.03 U59.P27
  vias: v2(101.87,76.05)
VCAP_VDDS5: length 0.6
  TOP w0.305: U59.M27 112.71,77.43 v2(112.32,77.03)
VCAPL: length 3
  TOP w0.254: C53.1 209.58,163.02 209.26,163.35 U16.4
VCOMAD: length 24.4
  TOP w0.381: U136.2 40.87,25.51 v2(41.21,25.18) 41.52,25.49 U136.1 ; 27.82,21.17 26.87,20.21 U141.3 ; 27.82,21.17 v2(29.06,21.17) ; 27.82,21.17 27.52,21.47 U141.5 ; 29.4,25.28 C444.1 v2(28.15,27.08) ; 29.4,25.28 30.39,26.28 U135.3 ; 29.4,25.28 29.74,24.94 U135.5 ; U146.3 31.04,12.89 31.3,12.63 v2(31.3,12.11) ; R666.1 19.6,18.55 19.7,18.45 C487.1 v2(19.7,17.01) ; v2(19.7,24.43) C450.1 19.7,22.99 19.6,22.89 R657.1 ; v2(31.69,19.41) U146.5
VCOMAD_CODEC: length 13.8
  TOP w0.254: v2(40.17,15.7) 40.17,15.28 40.46,14.99 U154.1
  TOP w0.381: U136.3 40.22,23.74 39.57,23.09 U136.5 39.57,19.14 40.17,18.55 v2(40.17,15.7)
  BOTTOM w0.381: v2(40.17,15.7) 40.42,15.45 C1238.1
VCOMAD_SPARE: length 6.1
  TOP w0.127: TP233.1 42.82,23.05 41.03,23.05 40.87,22.89 U136.7 40.87,21.16 40.7,20.99 40.37,20.99 40.22,21.14 U136.6
VCOMDA: length 3.4
  TOP w0.254: U154.15 40.12,7.99 39.94,7.81 39.94,6.76 39.24,6.06 C544.1
VCSP_USBC_PD: length 57.7
  TOP w0.203: R6.1 169.43,185.91 169.86,186.34 174.18,186.34 176.72,183.8 178.7,183.8 179.08,184.18 180.45,184.18 181.42,183.22 181.42,180.59 C7.2
  TOP w0.254: R11.2 181.19,180.16 C7.2
  L5-SIGNAL2 w0.381: v2(190.64,176.06) 188.68,178.02 188.68,182.86 182.08,189.46 166.86,189.46 165.92,188.53 165.92,186.79 v2(166.58,186.13)
  BOTTOM w0.381: U166.3 v2(190.64,176.06)
VDA_ADC0_REFN: length 9.4
  TOP w0.305: v2(113.12,69.83) 113.51,70.23 U59.C26
  BOTTOM w0.254: R1039.1 R1037.1 112.12,63.74 C976.2 111.98,67.75 112.43,68.2 112.43,68.56 C940.2 112.2,68.85 R1027.1 112.74,69.46 v2(113.12,69.83)
VDA_ADC0_REFP: length 10.3
  TOP w0.305: v2(113.92,70.63) 114.31,71.03 U59.D25
  BOTTOM w0.254: C950.1 114.03,70.21 114.03,69.85 113.01,68.83 113.01,67.89 112.5,67.39 112.5,64.75 C976.1 114.28,63.88 FL175.2 R1049.1
VDA_ADC1_REFN: length 12.3
  TOP w0.305: v2(110.72,70.63) 111.11,71.03 U59.D29
  BOTTOM w0.254: R1023.1 109.25,63.86 C905.2 109.24,67.12 108.57,67.79 108.57,69.9 109.48,70.82 110.22,70.82 C911.2 ; C925.2 111.35,70 v2(110.72,70.63) 111.08,71 R1022.1
VDA_ADC1_REFP: length 8.4
  TOP w0.305: U59.C30 110.31,70.23 v2(109.92,69.83)
  BOTTOM w0.254: FL132.2 110.63,63.87 C905.1 110.64,67.52 109.41,68.76 109.41,69.32 v2(109.92,69.83)
VDA_ADC_1V8: length 13.2
  TOP w0.305: U59.J28 111.91,75.03 v2(111.52,74.63) ; U59.K28 111.91,75.83 v2(111.52,75.43)
  L12-SIGNAL5 w0.254: v2(101.86,74.38) 102.32,73.92 108.5,73.92 109.21,74.63 v2(111.52,74.63)
  L12-SIGNAL5 w0.305: v2(111.52,74.63) v2(111.52,75.43)
  BOTTOM w0.381: C1018.1 101.87,74.38 v2(101.86,74.38) 101.86,74.96 FL176.1
VDA_CSIRX0_1_0V8: length 27
  TOP w0.305: U59.AG24 115.12,89.44 v2(114.72,89.83)
  L10-SIGNAL4 w0.152: 112.23,94.64 112.23,94.44 112.53,94.13 112.53,93.62 112.59,93.57 113.1,93.57 113.33,93.33 113.33,92.82 113.33,91.4 113.57,91.17 113.9,91.17 114.13,90.93 114.13,90.42 v2(114.72,89.83)
  L10-SIGNAL4 w0.254: v2(112.71,99.62) 112.16,100.17 112.16,104.08 111.72,104.53 111.72,107.98 112.2,108.47 112.2,110.97 v2(111.72,111.45)
  L10-SIGNAL4 w0.305: v2(112.71,99.62) 112.71,95.91 112.23,95.43 112.23,94.64
  BOTTOM w0.305: v2(112.71,99.62) 113.46,99.62 C826.1
  BOTTOM w0.381: FL71.2 v2(111.72,111.45)
VDA_CSIRX0_1_1V8: length 31.4
  TOP w0.305: U59.AF26 113.52,88.64 v2(113.12,89.03) ; v2(113.92,89.03) 114.32,88.64 U59.AF25
  L10-SIGNAL4 w0.152: v2(113.12,89.03) 112.72,89.43 112.72,90.75 112.3,91.17 110.32,91.17 110.13,91.35 110.13,92.72 109.92,92.94
  L10-SIGNAL4 w0.254: v4(109.3,111.45) 110.46,110.29 110.46,108.26 109.93,107.74 109.93,103.6 110.36,103.18 110.36,100.32 v2(111.06,99.62)
  L10-SIGNAL4 w0.305: v2(111.06,99.62) 109.92,98.48 109.92,92.94 ; v2(113.92,89.03) v2(113.12,89.03)
  BOTTOM w0.305: v2(113.12,89.03) 112.95,88.87 C851.1
  BOTTOM w0.381: FL76.2 108.14,111.75 108.44,111.45 v4(109.3,111.45)
VDA_CSIRX2_0V8: length 23.4
  TOP w0.305: U59.AG26 113.52,89.44 v2(113.12,89.83)
  L10-SIGNAL4 w0.152: 110.72,93.71 110.93,93.5 110.93,92.15 111.12,91.97 112.3,91.97 113.12,91.15 v2(113.12,89.83)
  L10-SIGNAL4 w0.254: 111.6,99.16 111.6,101.65 111.17,102.09 111.17,105.8 v2(110.57,106.4)
  L10-SIGNAL4 w0.305: 110.72,93.71 110.72,98.27 111.6,99.16
  BOTTOM w0.381: FL89.2 109.52,107.51 109.01,107 109,107 109.6,106.4 v2(110.57,106.4)
  BOTTOM w0.508: C749.1 109.01,107
VDA_CSIRX2_1V8: length 25.3
  TOP w0.305: v2(112.32,89.03) 112.72,88.64 U59.AF27 ; U59.AG27 112.72,89.44 v2(112.32,89.83)
  L10-SIGNAL4 w0.254: v4(106.51,107) 107.58,105.94 107.58,101.71 v2(109.66,99.62) 108.44,98.4 108.44,91.26 108.87,90.83 109.46,90.83 110,90.28 111.86,90.28 v2(112.32,89.83)
  L10-SIGNAL4 w0.305: v2(112.32,89.83) v2(112.32,89.03)
  BOTTOM w0.381: FL81.2 v4(106.51,107)
