# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
C_DP0_TX3_N: length 100.2
  TOP w0.094: v3(122.35,165.99) 122.22,166.12 arc(122.13,166.25) 122.1,166.39 122.1,167.76 arc(122.13,167.87) 122.19,167.96 C40.1
  L3-SIGNAL1 w0.079: v3(122.35,165.99) v5(122.35,165.67) ; v3(116.72,92.63) v5(116.44,92.86)
  L4-GND2 w0.089: v5(122.35,165.67) v7(122.35,165.27) ; v5(116.44,92.86) v7(116.13,93.17)
  L12-SIGNAL5 w0.089: v7(122.35,165.27) 122.13,165.06 arc(122.09,164.99) 122.07,164.91 122.07,164.77 arc(122.15,164.58) 122.35,164.5 124.97,164.5 arc(125.57,164.38) 126.07,164.04 127.17,162.94 arc(127.77,162.05) 127.98,160.99 127.98,160.01 arc(127.89,159.55) 127.63,159.17 125.46,156.99 arc(125.32,156.79) 125.27,156.54 125.27,155.32 arc(125.37,155.09) 125.6,154.99 127.55,154.99 arc(128.1,154.44) 127.55,153.9 125.6,153.9 arc(125.37,153.8) 125.27,153.57 125.27,151.97 arc(125.37,151.73) 125.6,151.64 127.61,151.64 arc(128.15,151.09) 127.61,150.54 125.6,150.54 arc(125.37,150.45) 125.27,150.21 125.27,148.29 arc(125.37,148.06) 125.6,147.96 127.69,147.96 arc(128.24,147.42) 127.69,146.87 125.6,146.87 arc(125.37,146.77) 125.27,146.54 125.27,139.17 arc(125.18,138.73) 124.93,138.36 117.73,131.16 arc(117.42,130.7) 117.32,130.17 117.32,119.84 arc(117.26,119.57) 117.11,119.34 116.92,119.15 arc(116.85,119.04) 116.82,118.91 116.82,117.61 arc(116.78,117.42) 116.67,117.25 116.23,116.81 arc(116.12,116.65) 116.09,116.46 116.09,94.47 arc(116.04,94.25) 115.92,94.07 115.87,94.01 arc(115.85,93.98) 115.84,93.95 115.84,93.5 arc(115.85,93.46) 115.87,93.43 v7(116.13,93.17)
  vias: v1(116.71,92.63)
C_DP0_TX3_P: length 100.2
  TOP w0.094: v3(121.58,165.99) 121.71,166.12 arc(121.8,166.25) 121.83,166.39 121.83,167.76 arc(121.8,167.87) 121.74,167.96 C39.1
  L3-SIGNAL1 w0.079: v3(115.92,92.63) v5(115.64,92.86) ; v3(121.58,165.99) v5(121.58,165.67)
  L4-GND2 w0.089: v5(115.64,92.86) v7(115.33,93.17) ; v5(121.58,165.67) v7(121.58,165.27)
  L12-SIGNAL5 w0.089: v7(121.58,165.27) 121.8,165.06 arc(121.84,164.99) 121.86,164.91 121.86,164.77 arc(122,164.43) 122.35,164.28 124.97,164.28 arc(125.48,164.18) 125.92,163.89 127.02,162.79 arc(127.57,161.97) 127.76,160.99 arc(127.76,160.99) 127.76,160.98 127.76,160.01 arc(127.69,159.64) 127.48,159.32 125.3,157.15 arc(125.12,156.87) 125.05,156.54 125.05,155.32 arc(125.21,154.93) 125.6,154.78 127.55,154.78 arc(127.88,154.44) 127.55,154.11 125.6,154.11 arc(125.21,153.95) 125.05,153.57 125.05,151.97 arc(125.21,151.58) 125.6,151.42 127.61,151.42 arc(127.94,151.09) 127.61,150.76 125.6,150.76 arc(125.21,150.6) 125.05,150.21 125.05,148.29 arc(125.21,147.91) 125.6,147.75 127.69,147.75 arc(128.02,147.42) 127.69,147.09 125.6,147.09 arc(125.21,146.93) 125.05,146.54 125.05,139.17 arc(124.98,138.82) 124.78,138.51 117.58,131.31 arc(117.23,130.78) 117.1,130.17 117.1,119.84 arc(117.07,119.65) 116.96,119.49 116.77,119.3 arc(116.65,119.12) 116.61,118.91 116.61,117.61 arc(116.58,117.5) 116.52,117.4 116.08,116.96 arc(115.92,116.73) 115.87,116.46 115.87,94.47 arc(115.84,94.34) 115.77,94.22 115.71,94.17 arc(115.65,94.07) 115.62,93.95 115.62,93.5 arc(115.62,93.46) 115.6,93.43 v7(115.33,93.17)
  vias: v1(115.91,92.63)
C_DP1_AUX_N: length 2.8
  BOTTOM w0.094: U187.35 104.52,134.56 arc(104.52,134.59) 104.5,134.62 104.44,134.68 arc(104.42,134.71) 104.41,134.74 104.41,135.04 arc(104.36,135.32) 104.2,135.55 104.11,135.65 arc(104.02,135.78) 103.99,135.93 103.99,136.03 arc(104,136.08) 104.04,136.13 C664.1
C_DP1_AUX_P: length 2.8
  BOTTOM w0.094: U187.34 104.02,134.56 arc(104.03,134.59) 104.05,134.62 104.11,134.68 arc(104.13,134.71) 104.14,134.74 104.14,135.04 arc(104.1,135.21) 104.01,135.35 103.91,135.45 arc(103.76,135.67) 103.71,135.93 103.71,136.03 arc(103.7,136.08) 103.67,136.13 C665.1
C_DP1_TX0_N: length 2.8
  BOTTOM w0.094: U187.38 106.02,134.56 arc(106.02,134.59) 106,134.62 105.94,134.68 arc(105.92,134.71) 105.91,134.74 105.91,135.06 arc(105.86,135.32) 105.72,135.54 105.61,135.65 arc(105.52,135.78) 105.49,135.93 105.49,136.03 arc(105.5,136.08) 105.54,136.13 C662.1
C_DP1_TX0_P: length 2.8
  BOTTOM w0.094: C663.1 105.17,136.13 arc(105.2,136.08) 105.21,136.03 105.21,135.93 arc(105.26,135.67) 105.41,135.45 105.52,135.34 arc(105.6,135.21) 105.64,135.06 105.64,134.74 arc(105.63,134.71) 105.61,134.68 105.55,134.62 arc(105.53,134.59) 105.52,134.56 U187.37
C_DP1_TX1_N: length 2.8
  BOTTOM w0.094: U187.40 107.02,134.56 arc(107.02,134.59) 107,134.62 106.94,134.68 arc(106.92,134.71) 106.91,134.74 106.91,135 arc(106.94,135.13) 107.01,135.24 107.16,135.39 arc(107.29,135.59) 107.34,135.82 107.34,136.03 arc(107.35,136.08) 107.38,136.13 C660.1
C_DP1_TX1_P: length 2.8
  BOTTOM w0.094: U187.39 106.52,134.56 arc(106.53,134.59) 106.55,134.62 106.61,134.68 arc(106.63,134.71) 106.64,134.74 106.64,135 arc(106.68,135.24) 106.82,135.44 106.96,135.58 arc(107.03,135.69) 107.06,135.82 107.06,136.03 arc(107.05,136.08) 107.01,136.13 C661.1
C_DP1_TX2_N: length 2.8
  BOTTOM w0.094: U187.45 109.52,134.56 arc(109.52,134.59) 109.5,134.62 109.44,134.68 arc(109.42,134.71) 109.41,134.74 109.41,135.15 arc(109.37,135.39) 109.23,135.59 109.06,135.76 arc(109.01,135.84) 108.99,135.92 108.99,136.03 arc(109,136.08) 109.04,136.13 C658.1
C_DP1_TX2_P: length 2.8
  BOTTOM w0.094: U187.44 109.02,134.56 arc(109.03,134.59) 109.05,134.62 109.11,134.68 arc(109.13,134.71) 109.14,134.74 109.14,135.15 arc(109.11,135.28) 109.04,135.39 108.86,135.57 arc(108.75,135.73) 108.71,135.92 108.71,136.03 arc(108.7,136.08) 108.67,136.13 C659.1
C_DP1_TX3_N: length 2.8
  BOTTOM w0.094: C656.1 110.88,136.13 arc(110.85,136.08) 110.84,136.03 110.84,135.74 arc(110.79,135.49) 110.65,135.28 110.53,135.16 arc(110.44,135.04) 110.41,134.89 110.41,134.74 arc(110.42,134.71) 110.44,134.68 110.5,134.62 arc(110.52,134.59) 110.52,134.56 U187.47
C_DP1_TX3_P: length 2.8
  BOTTOM w0.094: C657.1 110.51,136.13 arc(110.55,136.08) 110.56,136.03 110.56,135.74 arc(110.53,135.6) 110.45,135.48 110.33,135.36 arc(110.19,135.14) 110.14,134.89 110.14,134.74 arc(110.13,134.71) 110.11,134.68 110.05,134.62 arc(110.03,134.59) 110.02,134.56 U187.46
C_PCIE0_TX0_N: length 170.7
  L3-SIGNAL1 w0.104: v3(125.52,91.83) v5(125.74,92.11)
  L4-GND2 w0.121: v5(125.74,92.11) v7(126.05,92.42)
  L13-GND5 w0.121: v7(126.05,92.42) 126.26,92.2 v9(126.34,92.13)
  L14-SIGNAL6 w0.104: v11(36.4,150.03) 36.21,149.84 arc(36.16,149.75) 36.14,149.65 36.14,148.91 arc(36.18,148.68) 36.31,148.49 39.05,145.75 arc(39.6,145.38) 40.25,145.25 51.97,145.25 arc(52.59,145.38) 53.12,145.73 59.87,152.48 arc(60.51,152.91) 61.26,153.06 121.9,153.06 arc(123.09,152.82) 124.1,152.15 130.72,145.52 138.88,137.36 arc(139.54,136.38) 139.77,135.23 139.77,105.7 arc(139.65,105.09) 139.3,104.57 136.09,101.36 arc(135.88,101.22) 135.62,101.17 134.54,101.17 arc(134.36,101.13) 134.21,101.03 133.25,100.07 arc(133.14,100) 133.01,99.97 132.61,99.97 arc(132.47,99.95) 132.36,99.87 132.21,99.72 arc(132.14,99.62) 132.12,99.5 132.12,96.45 arc(132.05,96.1) 131.85,95.8 131.16,95.12 arc(130.8,94.88) 130.38,94.79 127.38,94.79 arc(126.95,94.62) 126.78,94.19 126.78,93.36 arc(126.75,93.23) 126.68,93.12 126.09,92.52 arc(126.06,92.49) 126.06,92.45 126.06,92.23 arc(126.09,92.16) 126.16,92.13 v9(126.34,92.13)
  vias: v1(125.52,91.83)
C_PCIE0_TX0_P: length 170.7
  L3-SIGNAL1 w0.104: v3(124.72,91.83) v5(124.94,92.11)
  L4-GND2 w0.121: v5(124.94,92.11) v7(125.25,92.42)
  L13-GND5 w0.121: v9(125.54,92.13) 125.46,92.2 v7(125.25,92.42)
  L14-SIGNAL6 w0.104: v9(125.54,92.13) 125.72,92.13 arc(125.79,92.16) 125.82,92.23 125.82,92.45 arc(125.85,92.58) 125.92,92.69 126.52,93.28 arc(126.54,93.32) 126.55,93.36 126.55,94.19 arc(126.79,94.78) 127.38,95.02 130.38,95.02 arc(130.71,95.09) 131,95.28 131.68,95.96 arc(131.83,96.19) 131.89,96.45 131.89,99.5 arc(131.93,99.7) 132.04,99.88 132.2,100.03 arc(132.39,100.16) 132.61,100.2 133.01,100.2 arc(133.05,100.21) 133.08,100.23 134.04,101.19 arc(134.27,101.35) 134.54,101.4 135.62,101.4 arc(135.79,101.43) 135.93,101.53 139.14,104.73 arc(139.43,105.18) 139.54,105.7 139.54,135.23 arc(139.32,136.29) 138.72,137.2 130.63,145.29 123.93,151.98 arc(123,152.61) 121.9,152.83 61.26,152.83 arc(60.6,152.7) 60.04,152.32 53.28,145.56 arc(52.68,145.16) 51.97,145.02 40.25,145.02 arc(39.51,145.17) 38.89,145.59 36.37,148.11 36.15,148.33 arc(35.97,148.6) 35.9,148.91 35.9,149.65 arc(35.88,149.75) 35.83,149.84 v11(35.64,150.03)
  vias: v1(124.72,91.83)
C_PCIE0_TX1_N: length 166.9
  L3-SIGNAL1 w0.104: v3(127.12,93.43) v5(127.34,93.71)
  L4-GND2 w0.121: v5(127.34,93.71) v7(127.65,94.02)
  L13-GND5 w0.121: v9(127.94,93.73) 127.86,93.8 v7(127.65,94.02)
  L14-SIGNAL6 w0.104: v9(127.94,93.73) 127.76,93.73 arc(127.69,93.76) 127.66,93.83 127.66,93.94 arc(127.7,94.04) 127.8,94.08 130.75,94.08 arc(131.18,94.17) 131.55,94.41 132.91,95.77 arc(133.13,96.1) 133.21,96.5 133.21,98.49 arc(133.28,98.86) 133.49,99.17 134.14,99.82 arc(134.28,99.91) 134.45,99.95 135.71,99.95 arc(136.06,100.02) 136.36,100.22 140.77,104.62 arc(140.9,104.83) 140.95,105.07 140.95,135.45 arc(140.65,136.96) 139.79,138.24 124.66,153.37 arc(123.66,154.04) 122.48,154.28 60.55,154.28 arc(59.94,154.16) 59.43,153.81 52.9,147.29 arc(52.03,146.7) 50.99,146.5 41.42,146.5 arc(40.51,146.87) 40.14,147.78 40.14,149.65 arc(40.16,149.75) 40.21,149.84 v11(40.4,150.03)
  vias: v1(127.12,93.43)
C_PCIE0_TX1_P: length 166.9
  L3-SIGNAL1 w0.104: v3(126.32,93.43) v5(126.54,93.71)
  L4-GND2 w0.121: v5(126.54,93.71) v7(126.85,94.02)
  L13-GND5 w0.121: v9(127.14,93.73) 127.06,93.8 v7(126.85,94.02)
  L14-SIGNAL6 w0.104: v11(39.64,150.03) 39.83,149.84 arc(39.88,149.75) 39.9,149.65 39.9,147.78 arc(40.35,146.71) 41.42,146.27 50.99,146.27 arc(52.12,146.49) 53.07,147.13 59.59,153.65 arc(60.03,153.94) 60.55,154.05 122.48,154.05 arc(123.57,153.83) 124.5,153.21 139.63,138.08 arc(140.44,136.87) 140.72,135.45 140.72,105.07 arc(140.69,104.91) 140.6,104.78 136.2,100.38 arc(135.97,100.23) 135.71,100.18 134.45,100.18 arc(134.19,100.13) 133.97,99.98 133.33,99.34 arc(133.07,98.95) 132.98,98.49 132.98,96.5 arc(132.92,96.19) 132.74,95.93 131.39,94.57 arc(131.09,94.38) 130.75,94.31 127.8,94.31 arc(127.53,94.2) 127.42,93.94 127.42,93.83 arc(127.39,93.76) 127.32,93.73 v9(127.14,93.73)
  vias: v1(126.32,93.43)
C_PCIE0_TX2_N: length 163.8
  L3-SIGNAL1 w0.104: v3(127.92,91.83) v5(128.14,92.11)
  L4-GND2 w0.121: v5(128.14,92.11) v7(128.45,92.42)
  L13-GND5 w0.121: v7(128.45,92.42) 128.66,92.63 v9(128.74,92.71)
  L14-SIGNAL6 w0.104: v11(44.4,150.03) 44.21,149.84 arc(44.16,149.75) 44.14,149.65 44.14,148.91 arc(44.48,148.08) 45.3,147.74 50.49,147.74 arc(51.53,147.95) 52.41,148.54 58.86,154.99 arc(59.42,155.36) 60.09,155.5 122.74,155.5 arc(124.08,155.23) 125.22,154.47 140.47,139.23 arc(141.8,137.23) 142.27,134.87 142.27,105.11 arc(142.22,104.85) 142.07,104.62 136.65,99.2 136.45,99 arc(136.23,98.86) 135.97,98.81 135.69,98.81 arc(135.51,98.77) 135.35,98.67 134.35,97.67 arc(134.22,97.47) 134.17,97.24 134.17,96.25 arc(134.12,95.99) 133.97,95.76 132.14,93.93 arc(131.55,93.53) 130.84,93.39 128.99,93.39 arc(128.82,93.36) 128.67,93.26 128.48,93.07 arc(128.46,93.04) 128.45,93 128.45,92.81 arc(128.48,92.74) 128.56,92.71 v9(128.74,92.71)
  vias: v1(127.92,91.83)
C_PCIE0_TX2_P: length 163.8
  L3-SIGNAL1 w0.104: v3(127.12,91.83) v5(127.34,92.11)
  L4-GND2 w0.121: v5(127.34,92.11) v7(127.65,92.42)
  L13-GND5 w0.121: v7(127.65,92.42) 127.86,92.63 v9(127.94,92.71)
  L14-SIGNAL6 w0.104: v9(127.94,92.71) 128.12,92.71 arc(128.19,92.74) 128.22,92.81 128.22,93 arc(128.25,93.12) 128.32,93.23 128.51,93.42 arc(128.73,93.57) 128.99,93.62 130.84,93.62 arc(131.46,93.75) 131.98,94.1 133.81,95.93 arc(133.91,96.07) 133.94,96.25 133.94,97.24 arc(134.01,97.56) 134.19,97.83 135.19,98.83 arc(135.42,98.98) 135.69,99.04 135.97,99.04 arc(136.14,99.07) 136.28,99.17 136.48,99.37 141.91,104.79 arc(142,104.93) 142.04,105.11 142.04,134.87 arc(141.59,137.14) 140.3,139.06 125.06,154.3 arc(124,155.02) 122.74,155.27 60.09,155.27 arc(59.51,155.15) 59.02,154.83 52.57,148.37 arc(51.62,147.73) 50.49,147.51 45.3,147.51 arc(44.31,147.92) 43.9,148.91 43.9,149.65 arc(43.88,149.75) 43.83,149.84 v11(43.64,150.03)
  vias: v1(127.12,91.83)
C_PCIE0_TX3_N: length 166.2
  L3-SIGNAL1 w0.104: v3(127.12,91.03) v5(127.34,91.31)
  L4-GND2 w0.121: v5(127.34,91.31) v7(127.65,91.62)
  L13-GND5 w0.121: v9(127.94,91.33) 127.86,91.4 v7(127.65,91.62)
  L14-SIGNAL6 w0.104: v9(127.94,91.33) 127.76,91.33 arc(127.69,91.36) 127.66,91.43 127.66,91.78 arc(127.73,91.95) 127.9,92.02 130.51,92.02 arc(131.19,92.16) 131.77,92.55 133.35,94.13 arc(133.7,94.36) 134.1,94.44 136.16,94.44 arc(136.55,94.52) 136.88,94.74 137.09,94.94 arc(137.35,95.34) 137.45,95.81 137.45,97.76 arc(137.62,98.61) 138.1,99.34 142.63,103.86 arc(142.88,104.03) 143.18,104.09 143.87,104.09 arc(144.34,104.28) 144.53,104.75 144.53,109.72 arc(144.37,110.55) 143.9,111.25 arc(143.54,111.78) 143.42,112.41 143.42,135.41 arc(142.94,137.8) 141.59,139.83 125.25,156.17 arc(124.64,156.57) 123.93,156.72 123.25,156.72 59.48,156.72 arc(58.88,156.6) 58.37,156.26 51.75,149.63 arc(51.01,149.14) 50.13,148.96 48.55,148.96 arc(48.26,149.08) 48.14,149.37 48.14,149.65 arc(48.16,149.75) 48.21,149.84 v11(48.4,150.03)
  vias: v1(127.12,91.03)
C_PCIE0_TX3_P: length 166.2
  L3-SIGNAL1 w0.104: v3(126.32,91.03) v5(126.54,91.31)
  L4-GND2 w0.121: v5(126.54,91.31) v7(126.85,91.62)
  L13-GND5 w0.121: v7(126.85,91.62) 127.06,91.4 v9(127.14,91.33)
  L14-SIGNAL6 w0.104: v11(47.64,150.03) 47.83,149.84 arc(47.88,149.75) 47.9,149.65 47.9,149.37 arc(48.09,148.92) 48.55,148.73 50.13,148.73 arc(51.1,148.92) 51.91,149.47 58.54,156.09 arc(58.97,156.38) 59.48,156.48 123.93,156.48 arc(124.55,156.36) 125.08,156.01 141.42,139.67 arc(142.73,137.71) 143.19,135.41 143.19,112.41 arc(143.33,111.7) 143.74,111.09 arc(144.16,110.46) 144.3,109.72 144.3,104.75 arc(144.18,104.45) 143.87,104.32 143.18,104.32 arc(142.79,104.24) 142.46,104.03 137.94,99.5 arc(137.4,98.7) 137.22,97.76 137.22,95.81 arc(137.14,95.43) 136.92,95.1 136.72,94.9 arc(136.46,94.73) 136.16,94.67 134.1,94.67 arc(133.61,94.57) 133.19,94.29 131.61,92.71 arc(131.1,92.37) 130.51,92.25 127.9,92.25 arc(127.56,92.12) 127.42,91.78 127.42,91.43 arc(127.39,91.36) 127.32,91.33 v9(127.14,91.33)
  vias: v1(126.32,91.03)
C_PCIE1/HYP0_TX0_N: length 147.9
  L3-SIGNAL1 w0.104: v3(125.52,94.23) v5(125.74,94.51)
  L4-GND2 w0.121: v5(125.74,94.51) v7(126.05,94.82)
  L12-SIGNAL5 w0.121: v8(130.11,119.38) 130.11,119.28 arc(130.13,119.16) 130.2,119.05 arc(130.33,118.86) 130.37,118.64 130.37,117.51 130.37,117.05 arc(130.3,116.68) 130.09,116.37 128.19,114.46 arc(128.05,114.26) 128.01,114.03 128.01,103.79 arc(127.86,103.06) 127.45,102.45 126.41,101.41 arc(125.94,100.7) 125.77,99.87 125.77,95.25 arc(125.8,95.1) 125.88,94.98 v7(126.05,94.82)
  L13-GND5 w0.121: v9(129.87,119.61) v8(130.11,119.38)
  L14-SIGNAL6 w0.104: v11(36.4,129.71) 36.21,129.52 arc(36.16,129.43) 36.14,129.33 36.14,128.58 arc(36.2,128.26) 36.38,127.99 36.75,127.62 arc(37.08,127.4) 37.46,127.32 58.66,127.32 arc(59.59,127.5) 60.37,128.03 66.32,133.98 arc(67.19,135.28) 67.49,136.81 67.49,141.18 arc(67.77,141.84) 68.43,142.11 115.46,142.11 arc(116.32,141.94) 117.05,141.45 117.58,140.92 117.89,140.61 arc(118.19,140.16) 118.3,139.63 118.3,136.11 arc(118.42,135.5) 118.76,134.99 123.14,130.61 arc(124.24,128.97) 124.62,127.04 124.62,123.51 arc(124.77,122.77) 125.19,122.14 125.64,121.69 arc(126.15,121.35) 126.75,121.23 127.62,121.23 arc(127.98,121.16) 128.29,120.95 129.48,119.76 arc(129.64,119.65) 129.83,119.61 v9(129.87,119.61)
  vias: v1(125.52,94.23)
C_PCIE1/HYP0_TX0_P: length 147.8
  L3-SIGNAL1 w0.104: v3(124.72,94.23) v5(124.94,94.51)
  L4-GND2 w0.121: v5(124.94,94.51) v7(125.25,94.82)
  L12-SIGNAL5 w0.121: v7(125.25,94.82) 125.38,94.95 arc(125.49,95.11) 125.53,95.29 125.53,99.87 arc(125.71,100.8) 126.23,101.58 127.28,102.62 arc(127.63,103.16) 127.76,103.79 127.76,114.03 arc(127.82,114.36) 128.01,114.64 129.92,116.55 arc(130.07,116.77) 130.13,117.05 130.13,117.51 130.13,118.64 arc(130.1,118.77) 130.03,118.88 arc(129.92,118.95) 129.8,118.97 v8(129.7,118.97)
  L13-GND5 w0.121: v9(129.47,119.2) v8(129.7,118.97)
  L14-SIGNAL6 w0.104: v9(129.47,119.2) 129.47,119.24 arc(129.43,119.43) 129.32,119.59 128.13,120.79 arc(127.89,120.94) 127.62,121 126.75,121 arc(126.06,121.14) 125.47,121.53 125.02,121.98 arc(124.55,122.68) 124.39,123.51 124.39,127.04 arc(124.02,128.88) 122.98,130.44 118.6,134.83 arc(118.2,135.41) 118.07,136.11 118.07,139.63 arc(117.98,140.07) 117.73,140.44 116.88,141.29 arc(116.23,141.72) 115.46,141.88 68.43,141.88 arc(67.93,141.67) 67.73,141.18 67.73,136.81 arc(67.4,135.19) 66.48,133.82 60.53,127.87 arc(59.68,127.29) 58.66,127.09 37.46,127.09 arc(36.99,127.18) 36.59,127.45 36.22,127.82 arc(35.99,128.17) 35.9,128.58 35.9,129.33 arc(35.88,129.43) 35.83,129.52 v11(35.64,129.71)
  vias: v1(124.72,94.23)
C_PCIE1/HYP0_TX1_N: length 149.2
  L3-SIGNAL1 w0.104: v3(119.12,91.03) v5(118.84,91.26)
  L4-GND2 w0.121: v5(118.84,91.26) v7(118.53,91.57)
  L12-SIGNAL5 w0.121: v7(118.53,91.57) 118.3,91.57 arc(118.13,91.64) 118.05,91.81 118.05,91.86 arc(118.13,92.03) 118.3,92.1 118.52,92.1 arc(118.65,92.15) 118.7,92.28 118.7,92.5 arc(118.75,92.77) 118.91,93 119.7,93.79 arc(119.81,93.95) 119.85,94.15 119.85,95.32 arc(119.91,95.63) 120.08,95.89 121.47,97.29 arc(121.72,97.65) 121.8,98.08 121.8,102.56 arc(121.89,102.99) 122.13,103.35 122.53,103.75 arc(122.92,104.32) 123.05,105 123.05,116.2 arc(123.36,117.75) 124.24,119.07 126.25,121.09 arc(126.47,121.41) 126.55,121.79 126.55,122.14 arc(126.51,122.35) v8(126.38,122.54)
  L13-GND5 w0.121: v9(126.38,122.86) v8(126.38,122.54)
  L14-SIGNAL6 w0.104: v9(126.38,122.86) 126.42,122.9 arc(126.52,123.05) 126.55,123.22 126.55,123.59 arc(126.49,123.9) 126.31,124.17 125.96,124.51 arc(125.61,125.05) 125.48,125.68 125.48,127.56 arc(125.08,129.6) 123.93,131.32 119.83,135.42 arc(119.29,136.22) 119.11,137.16 119.11,139.73 arc(118.95,140.52) 118.5,141.19 117.11,142.59 arc(116.55,142.96) 115.88,143.1 66.49,143.1 arc(65.75,142.79) 65.44,142.05 65.44,135.29 arc(65.33,134.7) 64.99,134.2 59.77,128.98 arc(59.03,128.48) 58.16,128.31 42.64,128.31 arc(42.17,128.51) 41.97,128.98 41.97,130.17 arc(41.83,130.5) 41.51,130.63 40.39,130.63 arc(40.21,130.55) 40.14,130.37 40.14,130.3 40.14,130.08 arc(40.16,129.98) 40.21,129.89 v11(40.4,129.71)
  vias: v1(119.11,91.03)
C_PCIE1/HYP0_TX1_P: length 149.3
  L3-SIGNAL1 w0.104: v3(119.92,91.03) v5(119.64,91.26)
  L4-GND2 w0.121: v5(119.64,91.26) v7(119.33,91.57)
  L12-SIGNAL5 w0.121: v7(119.33,91.57) 119.04,91.86 arc(118.97,91.96) 118.95,92.08 118.95,92.5 arc(118.98,92.68) 119.08,92.82 119.87,93.61 arc(120.04,93.86) 120.09,94.15 120.09,95.32 arc(120.14,95.54) 120.26,95.72 121.65,97.11 arc(121.95,97.56) 122.05,98.08 122.05,102.56 arc(122.12,102.89) 122.31,103.18 122.71,103.57 arc(123.15,104.23) 123.3,105 123.3,116.2 arc(123.59,117.66) 124.42,118.9 126.43,120.91 arc(126.7,121.32) 126.8,121.79 126.8,122.14 arc(126.84,122.35) v8(126.96,122.54)
  L13-GND5 w0.121: v9(126.96,122.86) v8(126.96,122.54)
  L14-SIGNAL6 w0.104: v9(126.96,122.86) 126.9,122.92 arc(126.81,123.06) 126.78,123.22 126.78,123.59 arc(126.7,123.99) 126.47,124.33 126.13,124.68 arc(125.82,125.14) 125.71,125.68 125.71,127.56 arc(125.29,129.69) 124.09,131.49 119.99,135.59 arc(119.51,136.31) 119.34,137.16 119.34,139.73 arc(119.16,140.61) 118.67,141.36 117.27,142.75 arc(116.63,143.18) 115.88,143.33 66.49,143.33 arc(65.59,142.95) 65.21,142.05 65.21,135.29 arc(65.11,134.79) 64.83,134.36 59.6,129.14 arc(58.94,128.7) 58.16,128.54 42.64,128.54 arc(42.33,128.67) 42.2,128.98 42.2,130.17 arc(42,130.66) 41.51,130.86 40.39,130.86 arc(40.05,130.72) 39.9,130.37 39.9,130.3 39.9,130.08 arc(39.88,129.98) 39.83,129.89 v11(39.64,129.71)
  vias: v1(119.91,91.03)
CAN_STB: length 386
  TOP w0.127: v2(162.26,13.42) 163.44,12.24 R709.1 162.25,10.7 161.93,10.39 U152.8
  L3-SIGNAL1 w0.089: v2(164.93,166.18) 161.11,166.18 160.36,166.93 160.36,169.24 160.8,169.69 160.8,171.49 159.34,172.95 157.05,172.95 156.76,172.67 156.07,171.98 156.07,170.82 155.75,170.5 154.58,170.5 154.39,170.69 140.8,170.69 138.23,168.12 133.75,168.12 133.01,168.86 132.23,168.86 132.23,168.86 131.9,168.86 131.9,168.86 131.11,168.86 129.35,168.86 126.65,166.16 123.58,166.16 123.13,166.61 120.88,166.61 120.05,165.78 114.88,165.78 114.37,166.29 114.37,167.25 113.63,167.99 111.24,167.99 109.72,169.5 104.51,169.5 103.76,168.76 103.76,167.93 86.15,150.31 80.6,150.31 56.78,126.49 46.69,126.49 43.98,123.77 43.98,120.95 42.2,119.17 42.2,116.15 v2(41.55,115.51)
  L12-SIGNAL5 w0.102: v2(162.26,13.42) 162.26,13.45 163.97,15.15 169.64,15.15 175.01,20.52 177.13,20.52 181.5,24.9 190.89,24.9 198.64,32.65 198.64,37.47 197.14,38.96 197.14,53.01 200.01,55.89 200.01,61.09 201.35,62.43 201.35,79.71 199.96,81.1 199.96,86.61 192.87,93.7 186.73,93.7 184.08,96.35 184.08,102.21 176.69,109.6 163.08,109.6 160.57,112.11 160.57,121.48 157.06,124.99 157.06,139.37 155.74,140.69 155.74,156.7 156.42,157.39 157.24,157.39 160.74,160.88 162.19,160.88 164.93,163.62 v2(164.93,166.18)
  BOTTOM w0.127: J54.102 v2(41.55,115.51)
CAN_WKUP: length 18.9
  TOP w0.127: R658.2 122.34,20.82 120.74,19.22 113.57,19.22 112.67,18.33 112.67,17.36 R684.2 113.18,16.01 113.09,15.92 D39.1
CANIO_RET_WAKE: length 131.8
  TOP w0.127: SW8.2 SW8.3 D37.2 C303.1 R476.2 TP164.1 v2(24.76,60.22)
  L3-SIGNAL1 w0.089: v3(119.12,71.83) v5(118.89,71.55) ; v2(35.8,53.86) 36.78,54.83 37.87,54.83 40.27,57.23 44.43,57.23 48.47,61.27 69.5,61.27 75.22,55.55 103.31,55.55 105.93,52.93 110.94,52.93 113.52,55.51 113.52,55.86 114.56,56.9 116.15,56.9 v5(116.38,57.13)
  L4-GND2 w0.102: v6(116.61,57.37) 116.61,57.36 v5(116.38,57.13) ; v5(118.89,71.55) v6(118.58,71.25)
  L5-SIGNAL2 w0.102: v6(118.58,71.25) 118.95,70.89 118.95,64.73 116.31,62.1 116.31,57.66 v6(116.61,57.37) ; v2(24.76,60.22) 28.03,56.95 31.09,56.95 34.19,53.86 v2(35.8,53.86)
  vias: v1(119.12,71.83)
CANUART_MUX1_SEL1: length 236
  TOP w0.127: R411.2 41.89,76.04 41.92,76.06 R405.1 42.83,76.51 v2(43.31,76.98) 43.56,77.23 U58.56
  L7-SIGNAL3 w0.109: v2(155.91,164.5) 156.4,164.5 161.48,169.57 161.48,173.74 160.82,174.4 152.28,174.4 150.6,172.72 149.66,172.72 146.43,169.48 140.31,169.48 138.95,170.85 130.76,170.85 125.02,176.58 86.05,176.58 79.75,182.88 69.36,182.88 64.82,178.34 64.82,176.28 62.15,173.61 62.15,163.74 60.36,161.95 60.36,153.48 47.93,141.06 47.93,138.26 47.01,137.35 47.01,133.65 47.97,132.69 47.97,130.7 47,129.72 47,121.11 47.63,120.48 47.63,112.06 48.02,111.66 48.02,99.84 48.9,98.96 48.9,82.58 v2(43.31,76.98)
  BOTTOM w0.127: U173.16 v2(155.91,164.5)
CANUART_MUX2_SEL1: length 230.2
  TOP w0.127: U50.56 43.56,94.58 v2(43.31,94.33)
  L7-SIGNAL3 w0.109: v2(43.31,94.33) 43.87,94.9 43.87,99.05 45.34,100.51 45.34,109 45.79,109.45 45.79,110.74 45.37,111.16 44.81,111.16 43.64,112.33 43.64,115.59 42.98,116.24 42.98,125.18 42.08,126.08 42.08,132.67 41.05,133.7 41.05,137.09 42.07,138.11 42.07,139.2 59.86,156.99 59.86,162.3 61.66,164.1 61.66,174.42 60.89,175.18 60.89,177.02 60.52,177.39 60.52,182.03 63.77,185.29 78.58,185.29 86.5,177.37 125.36,177.37 131.15,171.57 134.83,171.57 136.94,173.68 148.05,173.68 150.8,176.42 159.91,176.42 162.39,173.94 162.39,166.98 161.35,165.94 158.27,165.94 v2(155.91,163.59)
  BOTTOM w0.127: U173.15 156.41,164.09 v2(155.91,163.59)
CANUART_MUX_SEL0: length 253.6
  TOP w0.127: U50.1 v2(50.7,94.58) ; v2(49.73,77.97) 50.47,77.23 U58.1 ; SW2.2 v2(152.89,170.25)
  L3-SIGNAL1 w0.089: v2(49.73,77.97) 49.29,78.41 45.42,78.41 44.46,77.45 41.82,77.45 41.18,76.81 34.97,76.81 33.92,77.86 27.3,77.86 25.15,80 v2(24.74,80)
  L7-SIGNAL3 w0.109: v2(152.89,170.25) 152.48,170.66 149.19,170.66 147.78,169.25 140.11,169.25 138.75,170.61 130.66,170.61 127.39,173.88 124.95,173.88 122.49,176.34 85.87,176.34 79.57,182.64 69.46,182.64 65.06,178.24 65.06,176.1 62.46,173.5 62.46,155.26 49.99,142.78 49.99,138.29 49.1,137.4 49.1,133.59 49.99,132.7 49.99,131.48 47.91,129.4 47.91,116.62 48.55,115.97 48.55,115.48 48.07,114.99 48.07,111.96 49.25,110.77 49.25,96.03 v2(50.7,94.58)
  L12-SIGNAL5 w0.102: v2(152.89,170.25) 153.39,170.25 155.14,168.5 155.14,166.57 156.64,165.07 156.64,164.38 157.41,163.61 v2(157.41,163.59)
  L14-SIGNAL6 w0.089: v2(50.7,94.58) 49.73,93.61 v2(49.73,77.97)
  BOTTOM w0.127: U227.1 26.02,79.29 25.67,78.94 R1032.1 v2(24.74,80) ; U173.14 156.91,164.09 v2(157.41,163.59)
CANUART_MUX_SEL2: length 23.2
  TOP w0.127: v2(45.77,77.98) 45.52,77.73 U58.55 43.77,77.73 43.59,77.55 42.05,77.55 R403.2 ; v2(45.77,95.33) 45.52,95.08 U50.55
  L14-SIGNAL6 w0.089: v2(45.77,95.33) 45.33,94.89 45.33,78.42 v2(45.77,77.98)
CDCEL_XIN: length 7.9
  TOP w0.127: Y1.2 92.08,161.78 92.47,161.4 C78.2 92.47,157.92 91.94,157.39 U23.1
CDCEL_XOUT: length 7.9
  TOP w0.127: Y1.1 93.96,161.78 93.58,161.4 C79.2 93.58,157.87 94.06,157.39 U23.20
CDCEL_Y1: length 2.1
  TOP w0.127: R115.1 97.39,155.44 U23.17
CDCEL_Y4: length 2
  TOP w0.127: U23.7 88.87,153.49 88.71,153.32 R126.1
CDCEL_Y5: length 2.2
  TOP w0.127: U23.8 88.9,152.84 R131.1
CDCEL_Y6: length 2.5
  TOP w0.127: R134.1 97.78,151.16 97.37,151.58 97.37,151.87 97.05,152.19 U23.12
CDCEL_Y7: length 3
  TOP w0.127: R138.1 97.44,150.02 97.06,150.4 97.06,151.32 96.84,151.54 U23.11
CDCI1_EEPROMSEL: length 3.2
  TOP w0.127: v2(61.14,118.11) 60.35,118.11 U40.23
  BOTTOM w0.127: R917.1 R921.2 61.35,118.7 61.14,118.49 v2(61.14,118.11)
CDCI1_OE1: length 0.9
  TOP w0.127: U40.20 61.1,116.61 v2(61.2,116.5)
CDCI1_OE1/OE4: length 25.4
  TOP w0.127: v2(54.71,115.86) 55.08,115.86 55.83,116.61 U40.11 ; v2(41.87,112.66) 42.37,112.16 U43.12
  L14-SIGNAL6 w0.089: 54.04,115.43 50.43,115.43 49.71,114.71 47.85,114.71 47.12,113.99 44.13,113.99 43.33,113.19 42.41,113.19 v2(41.87,112.66) ; 54.04,115.43 54.29,115.68 54.29,115.73 54.42,115.86 v2(54.71,115.86) 54.28,115.43 54.04,115.43
  BOTTOM w0.127: R931.1 54.9,115.67 v2(54.71,115.86)
CDCI1_OE2/OE3: length 25.2
  TOP w0.127: U43.13 v2(44.38,110.57) ; v2(62.12,113.19) R230.1 R225.2 61.35,115.35 60.59,116.11 U40.19
  BOTTOM w0.127: v2(62.12,113.19) 62.12,111.66 61.23,110.77 47.34,110.77 46.7,110.13 44.82,110.13 v2(44.38,110.57)
CDCI1_OE3: length 11
  TOP w0.127: U40.12 56.04,116.11 55.69,115.76 55.69,115.02 55.51,114.84 v2(54.71,114.84)
  L3-SIGNAL1 w0.089: v2(62.96,114.33) 62.45,114.84 v2(54.71,114.84)
CDCI1_REFSEL: length 1.4
  TOP w0.127: U40.4 58.05,119.97 v2(57.82,120.2)
  BOTTOM w0.127: R920.1 v2(57.82,120.2)
CDCI1_XIN: length 7.6
  TOP w0.127: U40.1 59.55,119.41 59.55,120.33 59.93,120.71 60.49,120.71 61.32,121.54 C163.2 61.32,124.36 61.58,124.62 Y4.2
CDCI1_XOUT: length 7.1
  TOP w0.127: U40.2 59.05,119.41 59.05,120.54 59.67,121.17 60.08,121.17 60.33,121.42 C162.2 60.33,124.31 60.03,124.62 Y4.1
CDCI1_Y0: length 2
  TOP w0.127: TP49.1 55.12,118.88 55.41,118.88 55.67,118.61 56.25,118.61 U40.7
CDCI1_Y1N: length 2.1
  TOP w0.094: U40.21 60.85,117.11 60.96,117.22 61.16,117.22 61.4,116.99 61.75,116.99 R219.1
CDCI1_Y1P: length 2.1
  TOP w0.094: R214.1 61.75,117.27 61.51,117.27 61.28,117.5 60.96,117.5 60.85,117.61 60.35,117.61 U40.22
CDCI1_Y2N: length 6.6
  TOP w0.094: U40.17 59.05,114.81 59.16,114.7 59.16,114.45 59.42,114.19 60.51,114.19 60.71,113.99 60.71,111.67 60.98,111.41 61.76,111.41 R246.1
CDCI1_Y2P: length 6.2
  TOP w0.094: U40.18 59.55,114.81 59.44,114.7 59.44,114.57 59.53,114.47 60.62,114.47 60.99,114.1 60.99,111.79 61.1,111.69 61.76,111.69 R242.1
CDCI1_Y3N: length 4.2
  TOP w0.094: R233.1 55.07,113.33 55.46,113.33 55.81,113.69 55.81,114.1 56.18,114.47 57.07,114.47 57.16,114.57 57.16,114.76 57.05,114.87 U40.13
CDCI1_Y3P: length 4.6
  TOP w0.094: R238.1 55.07,113.05 55.57,113.05 56.09,113.57 56.09,113.99 56.3,114.19 57.18,114.19 57.44,114.45 57.44,114.79 57.55,114.9 U40.14
CDCI1_Y4N: length 1.7
  TOP w0.094: R212.1 55.09,117.5 55.64,117.5 55.75,117.61 56.25,117.61 U40.9
CDCI1_Y4P: length 1.7
  TOP w0.094: R217.1 55.06,117.22 55.64,117.22 55.75,117.11 U40.10
CDCI2_EEPROMSEL: length 7.4
  TOP w0.127: U22.23 110.65,155.26 111.11,154.8 111.11,154.57 111.72,153.96 111.72,151.61 R135.2 R141.1
CDCI2_OE1: length 3.3
  TOP w0.127: TP24.1 107.55,154.95 107.76,155.15 108.67,155.15 109.15,155.63 U22.20
CDCI2_OE4: length 7
  TOP w0.127: R65.2 R66.1 107.62,165.27 108.39,164.5 TP17.1 109.15,161.35 U22.11
CDCI2_REFSEL: length 5.8
  TOP w0.127: R76.1 112.78,162.81 112.78,158.91 112.55,158.68 U22.4
CDCI2_RSTZ: length 54.6
  TOP w0.127: U22.8 v2(110.65,162.61)
  L5-SIGNAL2 w0.102: v2(110.65,162.61) 111.42,163.38 139.02,163.38 141.31,161.09 154.31,161.09 157.24,164.02 157.98,164.02 v2(158.41,163.59)
  BOTTOM w0.127: v2(158.41,163.59) 157.91,164.09 U173.12
CDCI2_XIN: length 7.5
  TOP w0.127: U22.1 112.61,157.18 113.19,156.6 113.19,156.32 114.1,155.41 C99.2 116.94,155.41 117.15,155.2 Y3.2
CDCI2_XOUT: length 6.9
  TOP w0.127: U22.2 112.67,157.68 113.95,156.39 C90.2 116.92,156.39 117.15,156.62 Y3.1
CDCI2_Y0: length 1.9
  TOP w0.127: TP18.1 111.15,161.44 U22.7
CDCI2_Y2N: length 5.1
  TOP w0.094: R122.1 105.17,154.5 105.27,154.6 105.27,155.24 106.66,156.64 106.66,157.23 107,157.57 107.3,157.57 107.41,157.68 U22.17
CDCI2_Y2P: length 4.6
  TOP w0.094: R123.1 105.64,154.5 105.55,154.6 105.55,155.13 106.94,156.52 106.94,157.12 107.11,157.29 107.32,157.29 107.43,157.18 U22.18
CLKGEN_PCIE0_4L_REFCLK_N: length 119.2
  TOP w0.094: R246.2 63.34,111.41 63.75,111.41 R248.1 64.66,111.41 65.17,111.41 65.52,111.06 65.52,109.19 65.35,109.03 63.44,109.03 v2(63.2,109.27)
  L5-SIGNAL2 w0.089: v2(63.2,109.27) 62.92,108.99 62.54,108.99 61,110.53 53.2,110.53 51.29,112.45 51.29,115.89 50.43,116.74 50.43,125.91 45.24,131.11 19.19,131.11 16.21,134.09 16.21,142.65 19.1,145.53 19.1,158.33 19.54,158.77 19.54,161.84 20.32,162.72 29.79,162.72 30.19,162.32 34.46,162.32 34.76,162.03 34.76,160.45 v2(34.82,160.39)
CLKGEN_PCIE0_4L_REFCLK_P: length 119.7
  TOP w0.094: v2(63.2,108.51) 63.44,108.75 65.47,108.75 65.79,109.08 65.79,111.18 65.29,111.69 64.66,111.69 R240.1 63.75,111.69 63.34,111.69 R242.2
  L5-SIGNAL2 w0.089: v2(63.2,108.51) 62.94,108.77 62.46,108.77 60.91,110.32 53.11,110.32 51.07,112.36 51.07,115.8 50.22,116.65 50.22,125.82 45.15,130.89 19.1,130.89 16,134 16,142.74 18.88,145.62 18.88,158.42 19.32,158.86 19.32,161.92 20.23,162.94 29.88,162.94 30.28,162.54 34.45,162.54 34.82,162.9 v2(34.82,163.35)
CLKGEN_PCIE1_2L_REFCLK_N: length 56.6
  TOP w0.094: R212.2 53.5,117.52 52.73,117.52 52.64,117.61 v2(52.64,117.95)
  L5-SIGNAL2 w0.089: v2(52.64,117.95) 53.03,117.56 53.89,117.56 57.53,121.2 57.53,136.9 54.44,139.99 30.9,139.99 30.15,140.75 30.15,142.3 30.59,142.75 31.33,142.75 v2(31.79,143.21)
CLKGEN_PCIE1_2L_REFCLK_P: length 56.6
  TOP w0.094: v2(52.64,116.81) 52.64,117.15 52.73,117.24 53.5,117.24 R217.2
  L5-SIGNAL2 w0.089: v2(31.79,142.07) 31.33,142.53 30.68,142.53 30.36,142.21 30.36,140.84 30.99,140.21 54.53,140.21 57.74,136.99 57.74,121.11 53.98,117.34 53.17,117.34 v2(52.64,116.81)
CLKGEN_SERDES0_REFCLK_N: length 83.4
  TOP w0.094: R219.2 63.33,116.99 63.82,116.99 v2(64.19,116.62) ; R170.2 132.5,134.42 131.83,134.42 v2(131.56,134.15)
  L5-SIGNAL2 w0.089: v2(131.56,134.15) 131.31,134.4 130.41,134.4 129.18,135.63 101.53,135.63 101.25,135.34 100,134.09 76.29,134.09 67.89,125.69 67.89,118.11 67.33,117.55 65.71,117.55 65.2,117.03 64.36,117.03 64.19,116.87 v2(64.19,116.62)
CLKGEN_SERDES0_REFCLK_P: length 83.5
  TOP w0.094: v2(64.19,117.63) 63.82,117.27 63.33,117.27 R214.2 ; R171.2 132.34,134.7 131.71,134.7 v2(131.56,134.86)
  L5-SIGNAL2 w0.089: v2(131.56,134.86) 131.31,134.61 130.5,134.61 129.27,135.84 101.62,135.84 101.44,135.84 101.16,135.56 100.8,135.2 99.91,134.31 76.21,134.31 75.86,133.97 67.98,126.08 67.67,125.78 67.67,118.2 67.24,117.76 65.63,117.76 65.11,117.25 64.28,117.25 64.19,117.34 v2(64.19,117.63)
CLKGEN_SERDES1_REFCLK_N: length 98.5
  TOP w0.094: R166.2 132.35,132.43 131.49,132.43 v2(131.27,132.65) ; R233.2 53.5,113.33 52.73,113.33 52.64,113.42 v2(52.64,113.76)
  L5-SIGNAL2 w0.089: v2(52.64,113.76) 52.51,113.76 52.36,113.61 52.36,113.38 52.45,113.29 55.03,113.29 56.13,114.39 60.28,114.39 61.91,112.76 64.69,112.76 68.52,116.6 68.52,123.72 76.64,131.83 99.36,131.83 101.51,133.99 101.78,133.99 115.52,133.99 116.2,134.66 116.46,134.66 128.19,134.66 130.47,132.38 131,132.38 v2(131.27,132.65)
CLKGEN_SERDES1_REFCLK_P: length 98
  TOP w0.094: v2(52.64,112.62) 52.64,112.96 52.73,113.05 53.5,113.05 R238.2 ; v2(131.27,131.94) 131.48,132.15 132.36,132.15 R176.2
  L5-SIGNAL2 w0.089: v2(52.64,112.62) 52.64,112.99 52.72,113.07 55.12,113.07 56.22,114.18 60.19,114.18 61.82,112.55 64.78,112.55 68.74,116.51 68.74,123.63 76.73,131.62 99.45,131.62 101.6,133.77 101.69,133.77 115.61,133.77 116.29,134.44 116.38,134.44 128.1,134.44 130.38,132.17 131.04,132.17 v2(131.27,131.94)
CODEC_I2C_ADR0: length 5.8
  TOP w0.127: R694.1 R693.2 56.64,13.51 56.45,13.32 53.53,13.32 53.36,13.49 U154.45
CODEC_I2C_ADR1: length 5.7
  TOP w0.127: R699.1 R698.2 56.64,12.8 56.45,12.99 U154.44
CODEC_MODE: length 4
  TOP w0.127: R688.2 R687.1 53.73,15.98 53.5,15.76 53.5,15.17 53.32,14.99 U154.48
CODEC_OVF: length 5.3
  TOP w0.127: TP245.1 36.12,12.43 39.11,12.43 39.67,12.99 U154.5
CODEC_RSTZ: length 28.7
  TOP w0.127: U154.4 39.29,13.49 v2(38.79,12.99) ; TP231.1 53.09,22.97 v2(53.73,23.6) 54.34,24.22 U132.2
  L3-SIGNAL1 w0.089: v2(53.73,23.6) 53.04,22.92 53.04,19.87 53.65,19.26 53.65,17.38 51.01,14.74 42.43,14.74 40.68,12.99 v2(38.79,12.99)
CODEC_SPARE1: length 2.1
  TOP w0.127: TP230.1 54.84,24.17 U132.3
CODEC_VREFAD1: length 2.7
  TOP w0.254: U154.59 45.51,17.95 v2(45.7,18.14)
  BOTTOM w0.381: C1227.1 45.01,19.16 45.7,18.47 v2(45.7,18.14)
CODEC_VREFAD2: length 2.4
  TOP w0.254: C484.1 U154.60
CODEC_ZERO: length 4.9
  TOP w0.127: TP247.1 38.01,9.58 38.34,9.25 39.61,9.25 39.87,8.99 U154.13
COMP1_LM5140: length 3.7
  TOP w0.254: U46.29 214.31,108.46 R253.2 213.48,109.67 212.96,110.2 C195.1
COMP1_LM5143: length 12.8
  TOP w0.127: v2(207.58,154.94) C95.1 206.25,154.94 205.47,154.16 U25.2
  L3-SIGNAL1 w0.089: v2(207.58,154.94) 206.44,154.94 205.5,154.01 205.5,152.89 206.05,152.35 206.05,147.93 v3(205.47,147.35)
COMP2_LM5140: length 4.8
  TOP w0.127: C239.1 213.72,99.04 212.94,99.82 R279.1 213.51,99.83 214.31,100.63 U46.2
COMP_LM5141: length 3.3
  TOP w0.127: R473.1 202.93,59.38 C306.1 203.67,58.15 203.96,58.44 U81.20
CON_DP0_AUX_N: length 10.2
  TOP w0.094: J9.17 123.46,175.68 arc(123.44,175.61) 123.37,175.58 123.2,175.58 arc(123.13,175.55) 123.1,175.49 123.1,175.29 arc(123.22,175.01) 123.49,174.9 123.86,174.9 arc(124.08,174.86) 124.26,174.73 124.89,174.1 arc(125.09,173.81) 125.15,173.47 125.15,172.64 arc(125.17,172.54) 125.23,172.46 125.43,172.26 arc(125.49,172.17) D28.1 arc(125.49,171.95) 125.43,171.86 125.23,171.66 arc(125.17,171.58) 125.15,171.48 125.15,171.07 arc(125.19,170.88) 125.3,170.71 R45.1 125.3,170.1 arc(125.19,169.93) 125.15,169.73 125.15,169.55 arc(125.18,169.43) 125.25,169.32 arc(125.39,169.11) L18.2
CON_DP0_AUX_P: length 10.2
  TOP w0.094: L18.3 124.59,168.88 arc(124.64,169.12) 124.77,169.32 arc(124.85,169.44) 124.87,169.57 124.87,169.73 arc(124.83,169.93) 124.72,170.1 R44.2 124.72,170.71 arc(124.83,170.88) 124.87,171.07 124.87,171.46 arc(124.85,171.56) 124.8,171.65 124.61,171.84 arc(124.54,171.94) D27.1 arc(124.54,172.18) 124.61,172.28 124.8,172.47 arc(124.85,172.56) 124.87,172.66 124.87,173.07 124.87,173.47 arc(124.83,173.7) 124.7,173.9 124.06,174.54 arc(123.97,174.6) 123.86,174.62 123.49,174.62 arc(123.02,174.81) 122.82,175.29 122.82,175.49 arc(122.8,175.55) 122.73,175.58 122.56,175.58 arc(122.49,175.61) 122.46,175.68 J9.15
CON_DP0_TX0_N: length 8.7
  TOP w0.094: J9.3 116.46,175.69 arc(116.43,175.61) 116.36,175.58 116.2,175.58 arc(116.13,175.55) 116.1,175.49 116.1,175.4 arc(115.97,175.07) 115.64,174.94 114.75,174.94 arc(114.48,174.88) 114.25,174.73 113.65,174.13 arc(113.34,173.67) 113.24,173.12 113.24,172.9 arc(113.25,172.8) 113.31,172.71 113.51,172.51 arc(113.57,172.42) D20.1 arc(113.57,172.21) 113.51,172.11 113.31,171.91 arc(113.25,171.83) 113.24,171.73 113.24,171.44 arc(113.26,171.31) 113.33,171.21 arc(113.47,171) L14.2
CON_DP0_TX0_P: length 8.6
  TOP w0.094: L14.3 112.67,170.77 arc(112.72,171.01) 112.85,171.21 arc(112.93,171.32) 112.96,171.46 112.96,171.71 arc(112.94,171.82) 112.88,171.9 112.69,172.09 arc(112.62,172.19) D19.1 arc(112.62,172.43) 112.69,172.54 112.88,172.72 arc(112.94,172.81) 112.96,172.91 112.96,173.12 arc(113.09,173.78) 113.46,174.33 114.05,174.93 arc(114.37,175.14) 114.75,175.22 115.64,175.22 arc(115.77,175.27) 115.82,175.4 115.82,175.49 arc(115.8,175.55) 115.73,175.58 115.57,175.58 arc(115.49,175.61) 115.46,175.69 J9.1
CON_DP0_TX1_N: length 6.5
  TOP w0.094: J9.6 117.96,175.68 arc(117.94,175.61) 117.87,175.58 117.7,175.58 arc(117.63,175.55) 117.6,175.49 117.6,174.99 arc(117.44,174.59) 117.04,174.43 116.29,174.43 arc(116.2,174.39) 116.16,174.29 arc(116.18,174.19) 116.23,174.11 116.43,173.91 arc(116.49,173.82) D14.1 arc(116.49,173.6) 116.43,173.51 116.23,173.31 arc(116.18,173.23) 116.16,173.13 116.16,172.84 arc(116.18,172.71) 116.25,172.61 arc(116.39,172.4) L11.2
CON_DP0_TX1_P: length 6.5
  TOP w0.094: L11.3 115.59,172.17 arc(115.64,172.4) 115.77,172.61 arc(115.85,172.72) 115.88,172.85 115.88,173.11 arc(115.86,173.21) 115.8,173.3 115.61,173.49 arc(115.54,173.59) D13.1 arc(115.54,173.83) 115.61,173.93 115.8,174.12 arc(115.86,174.21) 115.88,174.31 arc(115.99,174.59) 116.28,174.71 117.04,174.71 arc(117.24,174.79) 117.32,174.99 117.32,175.49 arc(117.3,175.55) 117.23,175.58 117.06,175.58 arc(116.99,175.61) 116.96,175.68 J9.4
CON_DP0_TX2_N: length 7
  TOP w0.094: J9.9 119.46,175.68 arc(119.44,175.61) 119.37,175.58 119.2,175.58 arc(119.13,175.55) 119.1,175.49 119.1,172.64 arc(119.12,172.54) 119.18,172.46 119.38,172.26 arc(119.44,172.17) D26.1 arc(119.44,171.95) 119.38,171.86 119.18,171.66 arc(119.12,171.58) 119.1,171.48 119.1,171.19 arc(119.13,171.06) 119.2,170.95 arc(119.34,170.74) L16.2
CON_DP0_TX2_P: length 7
  TOP w0.094: L16.3 118.54,170.52 arc(118.59,170.75) 118.72,170.96 arc(118.8,171.07) 118.82,171.2 118.82,171.46 arc(118.8,171.56) 118.75,171.65 118.56,171.84 arc(118.49,171.94) D25.1 arc(118.49,172.18) 118.56,172.28 118.75,172.47 arc(118.8,172.56) 118.82,172.66 118.82,175.49 arc(118.8,175.55) 118.73,175.58 118.56,175.58 arc(118.49,175.61) 118.46,175.68 J9.7
CON_DP0_TX3_N: length 6.5
  TOP w0.094: J9.12 120.96,175.68 arc(120.94,175.61) 120.87,175.58 120.7,175.58 arc(120.63,175.55) 120.6,175.49 120.6,175.32 arc(120.66,175.18) 120.8,175.12 121.47,175.12 arc(121.92,174.93) 122.1,174.49 122.1,174.29 arc(122.12,174.19) 122.18,174.11 122.38,173.91 arc(122.44,173.82) D16.1 arc(122.44,173.6) 122.38,173.51 122.18,173.31 arc(122.12,173.23) 122.1,173.13 122.1,172.84 arc(122.13,172.71) 122.2,172.61 arc(122.34,172.4) L12.2
CON_DP0_TX3_P: length 6.5
  TOP w0.094: L12.3 121.54,172.17 arc(121.59,172.4) 121.72,172.61 arc(121.8,172.72) 121.83,172.85 121.83,173.11 arc(121.81,173.21) 121.75,173.3 121.56,173.49 arc(121.49,173.59) D15.1 arc(121.49,173.83) 121.56,173.93 121.75,174.12 arc(121.81,174.21) 121.83,174.31 121.83,174.49 arc(121.72,174.74) 121.47,174.84 120.8,174.84 arc(120.46,174.98) 120.32,175.32 120.32,175.49 arc(120.3,175.55) 120.23,175.58 120.06,175.58 arc(119.99,175.61) 119.96,175.68 J9.10
CON_DP1_AUX_N: length 10.2
  TOP w0.094: J8.17 97.59,175.68 arc(97.56,175.61) 97.5,175.58 97.32,175.58 arc(97.26,175.55) 97.23,175.49 97.23,175.29 arc(97.34,175.01) 97.62,174.9 97.99,174.9 arc(98.19,174.86) 98.37,174.74 99.03,174.08 arc(99.21,173.8) 99.28,173.47 99.28,172.64 arc(99.3,172.54) 99.36,172.46 99.56,172.26 arc(99.62,172.17) D24.1 arc(99.62,171.95) 99.56,171.86 99.36,171.66 arc(99.3,171.58) 99.28,171.48 99.28,171.07 arc(99.32,170.88) 99.43,170.71 R43.1 99.43,170.1 arc(99.32,169.93) 99.28,169.73 99.28,169.55 arc(99.31,169.43) 99.38,169.32 arc(99.52,169.11) L17.2
CON_DP1_AUX_P: length 10.2
  TOP w0.094: L17.3 98.72,168.88 arc(98.76,169.12) 98.9,169.32 arc(98.97,169.44) 99,169.57 99,169.73 arc(98.96,169.93) 98.85,170.1 R42.2 98.85,170.71 arc(98.96,170.88) 99,171.07 99,171.46 arc(98.98,171.56) 98.92,171.65 98.73,171.84 arc(98.67,171.94) D23.1 arc(98.67,172.18) 98.73,172.28 98.92,172.47 arc(98.98,172.56) 99,172.66 99,173.47 arc(98.96,173.7) 98.83,173.88 98.17,174.54 arc(98.09,174.6) 97.99,174.62 97.62,174.62 arc(97.15,174.81) 96.95,175.29 96.95,175.49 arc(96.92,175.55) 96.86,175.58 96.68,175.58 arc(96.62,175.61) 96.59,175.68 J8.15
CON_DP1_TX0_N: length 8.6
  TOP w0.094: J8.3 90.59,175.69 arc(90.56,175.61) 90.49,175.58 90.32,175.58 arc(90.26,175.55) 90.23,175.49 90.23,175.4 arc(90.09,175.07) 89.76,174.94 88.88,174.94 arc(88.62,174.89) 88.4,174.74 87.77,174.11 arc(87.47,173.66) 87.36,173.12 87.36,172.9 arc(87.38,172.8) 87.44,172.71 87.64,172.51 arc(87.7,172.42) D18.1 arc(87.7,172.21) 87.64,172.11 87.44,171.91 arc(87.38,171.83) 87.36,171.73 87.36,171.44 arc(87.39,171.31) 87.46,171.21 arc(87.6,171) L13.2
CON_DP1_TX0_P: length 8.6
  TOP w0.094: L13.3 86.8,170.77 arc(86.85,171.01) 86.98,171.21 arc(87.06,171.32) 87.08,171.46 87.08,171.71 arc(87.06,171.82) 87.01,171.9 86.82,172.09 arc(86.75,172.19) D17.1 arc(86.75,172.43) 86.82,172.54 87.01,172.72 arc(87.06,172.81) 87.08,172.91 87.08,173.12 arc(87.21,173.76) 87.57,174.31 88.21,174.94 arc(88.51,175.14) 88.88,175.22 89.76,175.22 arc(89.9,175.27) 89.95,175.4 89.95,175.49 arc(89.92,175.55) 89.86,175.58 89.69,175.58 arc(89.62,175.61) 89.59,175.69 J8.1
CON_DP1_TX1_N: length 6.5
  TOP w0.094: J8.6 92.09,175.68 arc(92.06,175.61) 92,175.58 91.82,175.58 arc(91.76,175.55) 91.73,175.49 91.73,174.99 arc(91.56,174.59) 91.17,174.43 90.42,174.43 arc(90.32,174.39) 90.28,174.29 arc(90.3,174.19) 90.36,174.11 90.56,173.91 arc(90.62,173.82) D10.1 arc(90.62,173.6) 90.56,173.51 90.36,173.31 arc(90.3,173.23) 90.28,173.13 90.28,172.84 arc(90.31,172.71) 90.38,172.61 arc(90.52,172.4) L9.2
CON_DP1_TX1_P: length 6.5
  TOP w0.094: L9.3 89.72,172.17 arc(89.77,172.4) 89.9,172.61 arc(89.98,172.72) 90,172.85 90,173.11 arc(89.98,173.21) 89.93,173.3 89.74,173.49 arc(89.67,173.59) D9.1 arc(89.67,173.83) 89.74,173.93 89.93,174.12 arc(89.98,174.21) 90,174.31 arc(90.12,174.59) 90.4,174.71 91.17,174.71 arc(91.37,174.79) 91.45,174.99 91.45,175.49 arc(91.42,175.55) 91.36,175.58 91.18,175.58 arc(91.12,175.61) 91.09,175.68 J8.4
CON_DP1_TX2_N: length 7.1
  TOP w0.094: J8.9 93.59,175.68 arc(93.56,175.61) 93.5,175.58 93.32,175.58 arc(93.26,175.55) 93.23,175.49 93.23,172.64 arc(93.25,172.54) 93.31,172.46 93.51,172.26 arc(93.57,172.17) D22.1 arc(93.57,171.95) 93.51,171.86 93.31,171.66 arc(93.25,171.58) 93.23,171.48 93.23,171.19 arc(93.25,171.06) 93.33,170.95 arc(93.47,170.74) L15.2
CON_DP1_TX2_P: length 7
  TOP w0.094: J8.7 92.59,175.68 arc(92.62,175.61) 92.68,175.58 92.86,175.58 arc(92.92,175.55) 92.95,175.49 92.95,172.66 arc(92.93,172.56) 92.87,172.47 92.68,172.28 arc(92.62,172.18) D21.1 arc(92.62,171.94) 92.68,171.84 92.87,171.65 arc(92.93,171.56) 92.95,171.46 92.95,171.2 arc(92.92,171.07) 92.85,170.96 arc(92.71,170.75) 92.67,170.52 L15.3
CON_DP1_TX3_N: length 6.5
  TOP w0.094: J8.12 95.09,175.68 arc(95.06,175.61) 95,175.58 94.82,175.58 arc(94.76,175.55) 94.73,175.49 94.73,175.32 arc(94.79,175.18) 94.93,175.12 95.6,175.12 arc(96.05,174.93) 96.23,174.49 96.23,174.29 arc(96.25,174.19) 96.31,174.11 96.51,173.91 arc(96.57,173.82) D12.1 arc(96.57,173.6) 96.51,173.51 96.31,173.31 arc(96.25,173.23) 96.23,173.13 96.23,172.84 arc(96.26,172.71) 96.33,172.61 arc(96.47,172.4) L10.2
CON_DP1_TX3_P: length 6.5
  TOP w0.094: L10.3 95.67,172.17 arc(95.71,172.4) 95.85,172.61 arc(95.93,172.72) 95.95,172.85 95.95,173.11 arc(95.93,173.21) 95.88,173.3 95.69,173.49 arc(95.62,173.59) D11.1 arc(95.62,173.83) 95.69,173.93 95.88,174.12 arc(95.93,174.21) 95.95,174.31 95.95,174.49 arc(95.85,174.74) 95.6,174.84 94.93,174.84 arc(94.59,174.98) 94.45,175.32 94.45,175.49 arc(94.42,175.55) 94.36,175.58 94.18,175.58 arc(94.12,175.61) 94.09,175.68 J8.10
CON_HYP0_RXFLCLK: length 107.3
  TOP w0.127: v2(56.27,94.08) R311.2 55.85,94.03 55.74,94.14 R309.2 ; J10.27 67.08,187.73 v2(66.88,187.94)
  L12-SIGNAL5 w0.102: v2(56.27,94.08) 56.27,94.44 58.83,97 58.83,114.88 59.85,115.9 59.85,129.3 65.14,134.6 65.14,153.1 58.2,160.05 58.2,165.59 58.76,166.15 58.76,167.52 58.4,167.88 58.4,168.84 58.73,169.17 58.73,170.47 58.49,170.71 58.49,174.62 59.42,175.54 59.42,177.85 66.88,185.31 v2(66.88,187.94)
CON_HYP0_RXFLDAT: length 107.2
  TOP w0.127: R298.2 55.67,95.96 55.79,95.84 R302.2 v2(56.27,95.89) ; J10.25 67.58,187.73 v2(67.79,187.94)
  L12-SIGNAL5 w0.102: v2(67.79,187.94) 67.38,188.35 66.71,188.35 66.18,187.82 66.18,184.97 58.61,177.39 58.61,176.79 58.6,176.79 58.6,175.54 57.24,174.18 57.24,167.53 57.97,166.8 57.97,159.95 64.92,153 64.92,134.69 58.93,128.7 58.93,115.96 58.61,115.64 58.61,98.23 v2(56.27,95.89)
CON_HYP0_RXPMCLK: length 93.3
  TOP w0.127: v2(62.38,188.81) 62.58,188.6 J10.39 ; v2(56.27,104.97) R263.2 55.93,104.92 55.81,105.04 R261.2
  L12-SIGNAL5 w0.102: v2(56.27,104.97) 56.81,105.52 56.81,106.31 57.45,106.96 57.45,114.11 56.25,115.31 56.25,122.55 56.77,123.06 56.77,131.9 58.03,133.15 58.03,157.93 55.28,160.68 55.28,181.71 v2(62.38,188.81)
CON_HYP0_RXPMDAT: length 93.1
  TOP w0.127: v2(63.29,188.81) 63.08,188.6 J10.37 ; v2(56.27,106.79) R258.2 55.93,106.74 55.81,106.85 R257.2
  L12-SIGNAL5 w0.102: v2(63.29,188.81) 62.88,189.21 62.21,189.21 55.06,182.06 55.06,160.56 57.81,157.81 57.81,133.25 56.55,131.99 56.55,123.35 56.03,122.83 56.03,115.18 57.23,113.97 57.23,107.75 v2(56.27,106.79)
CON_HYP0_TXFLCLK: length 102.7
  TOP w0.127: J10.29 66.08,188.6 v2(66.29,188.81) ; R273.2 55.81,101.4 55.93,101.29 R275.2 v2(56.27,101.34)
  L12-SIGNAL5 w0.102: v2(56.27,101.34) 58.12,103.2 58.12,114.66 57.7,115.08 57.7,118.86 58.23,119.39 58.23,128.78 64.47,135.03 64.47,152.76 57.49,159.75 57.49,166.52 56.79,167.22 56.79,176.28 64.31,183.79 64.31,188.03 64.65,188.37 65.86,188.37 v2(66.29,188.81)
CON_HYP0_TXFLDAT: length 96.5
  TOP w0.127: v2(65.38,188.81) 65.58,188.6 J10.31 ; v2(56.27,103.16) R268.2 55.93,103.11 55.81,103.22 R267.2
  L12-SIGNAL5 w0.102: v2(56.27,103.16) 57.04,103.92 57.04,106.22 57.68,106.86 57.68,114.29 56.48,115.49 56.48,122.45 57.46,123.44 57.46,132.27 58.25,133.06 58.25,158.06 56.35,159.97 56.35,180.01 63.31,186.97 63.31,188.16 63.95,188.81 v2(65.38,188.81)
CON_HYP0_TXPMCLK: length 102.7
  TOP w0.127: v2(56.27,97.75) 55.37,97.75 R287.2 ; v2(64.79,187.94) 64.58,187.73 J10.33
  L12-SIGNAL5 w0.102: v2(56.27,97.75) 58.35,99.83 58.35,115.69 58.71,116.05 58.71,128.89 64.7,134.88 64.7,152.91 57.72,159.89 57.72,166.65 57.02,167.35 57.02,176.18 64.79,183.96 v2(64.79,187.94)
CON_HYP0_TXPMDAT: length 102.2
  TOP w0.127: v2(56.27,99.52) R282.2 55.93,99.47 55.81,99.59 R281.2 ; v2(63.88,187.94) 64.08,187.73 J10.35
  L12-SIGNAL5 w0.102: v2(63.88,187.94) 63.88,187.16 56.57,179.85 56.57,167.12 57.27,166.43 57.27,159.65 64.25,152.67 64.25,135.12 57.68,128.55 57.68,120.68 56.7,119.69 56.7,115.62 57.9,114.42 57.9,106.77 57.26,106.13 57.26,102.77 56.37,101.88 56.12,101.88 55.86,101.63 55.86,99.93 v2(56.27,99.52)
CON_PCIE0_4L_REFCLK_N: length 8.2
  TOP w0.094: J14.A14 35.02,158.16 34.82,157.96 34.37,157.96 34.16,158.18 34.16,159.5 32.77,160.89 32.77,161.4 33.05,161.68 33.55,161.68 R83.2 34.03,161.69 34.51,161.69 34.85,161.36 C66.2
CON_PCIE0_4L_REFCLK_P: length 8.2
  TOP w0.094: C63.2 34.85,162.38 34.44,161.97 34.1,161.97 R83.1 33.45,161.96 32.93,161.96 32.5,161.52 32.5,160.77 33.88,159.39 33.88,157.11 J14.A13
CON_PCIE1_2L_REFCLK_N: length 9.6
  TOP w0.094: C125.2 32.63,143.19 33.05,142.78 33.58,142.78 R153.2 34.14,142.78 35.02,142.78 35.39,142.4 35.39,140.99 34.16,139.76 34.16,138.26 34.56,137.86 34.74,137.86 35.02,138.14 J17.A14
CON_PCIE1_2L_REFCLK_P: length 9.6
  TOP w0.094: J17.A13 34.57,137.21 34.57,137.45 33.88,138.14 33.88,139.87 35.11,141.1 35.11,142.29 34.9,142.5 34.14,142.5 R153.1 33.58,142.5 33.05,142.5 32.63,142.08 R155.1
CON_PM1_SCL: length 13.9
  L14-SIGNAL6 w0.089: J30.1 238.64,20.53 v11(238.64,18.33)
  BOTTOM w0.127: v11(238.64,18.33) 238.64,18.83 238.31,19.16 234.35,19.16 233.6,19.91 U269.3
CON_PM1_SDA: length 12.2
  L14-SIGNAL6 w0.089: v11(238.64,17.83) 239.04,18.23 239.04,19.61 239.78,20.35 J30.2
  BOTTOM w0.127: U269.6 235.55,20.32 235.9,19.97 238.74,19.97 239.15,19.56 239.15,17.99 239,17.83 v11(238.64,17.83)
CON_PM2_SCL: length 11.8
  L14-SIGNAL6 w0.089: J30.5 237.62,16.12 237.62,17.41 v11(238.04,17.83)
  BOTTOM w0.127: v11(238.04,17.83) 237.46,17.83 237.16,18.14 234.98,18.14 234.25,17.41 U269.11
CON_PM2_SDA: length 7.3
  L14-SIGNAL6 w0.089: J30.4 239.18,15.27 238.04,16.41 v11(238.04,17.33)
  BOTTOM w0.127: U269.8 236.2,17.41 236.38,17.58 237.22,17.58 237.47,17.33 v11(238.04,17.33)
CONN_MMC1_SDCD: length 80
  L14-SIGNAL6 w0.089: v2(28.05,122.79) 28.35,123.1 36.32,123.1 40.84,118.57 52.89,118.57 58.48,112.98 58.48,108.85 59.94,107.39 60.43,106.91 65.73,106.91 66.57,106.07 67.19,106.07 69.48,103.78 69.48,102.56 74.87,97.16 86.22,97.16 v2(86.31,97.24)
  BOTTOM w0.127: J53.9 23.62,121.15 23.91,121.44 23.91,122.38 24.13,122.6 U191.5 24.54,122.11 24.7,121.95 26.36,121.95 R903.2 27.88,122.63 v2(28.05,122.79)
CORE_0V8_IN+: length 4.8
  BOTTOM w0.127: R904.1 63.66,122.79 63.55,122.9 C707.2 62.51,122.9 62.3,123.11 U189.10 60.34,123.11 U188.D3
CORE_0V8_IN-: length 6.3
  BOTTOM w0.127: U188.D2 59.94,124.31 ; 59.94,124.31 60.15,124.31 60.35,124.11 U189.8 62.22,124.11 62.51,123.82 ; 59.94,124.31 U188.D1 ; 62.51,123.82 C707.1 63.59,123.82 63.7,123.94 R898.1 ; 62.51,123.82 62.3,123.61 U189.9
CORE_RAM_0V85_IN+: length 4.8
  BOTTOM w0.127: R969.1 196.56,95.55 196.67,95.66 C797.2 196.67,96.7 196.88,96.91 U208.10 196.88,98.87 U207.D3
CORE_RAM_0V85_IN-: length 6.3
  BOTTOM w0.127: R968.1 197.71,95.51 197.59,95.62 C797.1 197.59,96.7 ; 198.08,99.27 U207.D1 ; 198.08,99.27 U207.D2 ; 198.08,99.27 198.08,99.06 197.88,98.86 U208.8 197.88,96.99 197.59,96.7 ; 197.59,96.7 197.38,96.91 U208.9
CPU_AVS_IN+: length 4.8
  BOTTOM w0.127: U194.D3 153.38,120.14 U195.10 155.35,120.14 155.56,119.93 C714.2 156.59,119.93 156.7,119.82 R919.1
CPU_AVS_IN-: length 6.3
  BOTTOM w0.127: 155.56,120.85 155.27,121.14 U195.8 153.4,121.14 153.2,121.34 152.98,121.34 ; 155.56,120.85 C714.1 156.63,120.85 156.74,120.96 R911.1 ; 155.56,120.85 155.35,120.64 U195.9 ; U194.D1 152.98,121.34 ; 152.98,121.34 U194.D2
CS1_LM5140: length 3.2
  TOP w0.127: R244.2 C202.2 214.76,109.37 215.31,108.82 U46.27
CS1_LM5143: length 3.2
  TOP w0.127: R151.2 205.06,145.02 204.95,145.13 C121.2 204.78,145.85 204.78,146.06 204.47,146.37 U25.27
