# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C3_SCL: length 92.3
  TOP w0.127: v2(45.77,88.98) 45.52,88.73 U58.33 ; U154.42 54.24,11.99 v2(54.74,12.49) ; v2(53.12,28.86) 53.5,28.86 53.84,28.52 U132.12
  L12-SIGNAL5 w0.102: v2(45.77,88.98) 44.6,87.81 44.6,86.88 42.43,84.71 42.43,80.62 42.62,80.43 42.62,75.88 43.32,75.18 43.32,72.32 40.7,69.7 40.7,55.42 47.79,48.34 50.37,48.34 51.34,47.37 51.34,36.48 52.53,35.29 52.53,29.46 53.12,28.87 v2(53.12,28.86) 53.12,26.02 55.21,23.93 55.21,12.96 v2(54.74,12.49)
I2C3_SCL_MUX: length 67.8
  TOP w0.127: U58.23 54.14,88.23 v2(54.77,88.86)
  L3-SIGNAL1 w0.089: v5(87.42,87.22) 87.72,87.22 88.4,86.54 90.36,86.54 92.26,84.63 93.95,84.63 95.72,82.87 95.72,81.89 100,77.61 102.77,77.61 102.84,77.69 105.46,77.69 106.01,78.23 v3(107.92,78.23)
  L4-GND2 w0.102: v6(87.18,87.46) v5(87.42,87.22)
  L5-SIGNAL2 w0.102: v6(87.18,87.46) 86.94,87.7 86.94,89.98 84.57,92.35 71.74,92.35 71.47,92.08 55.31,92.08 54.36,91.13 54.36,89.26 v2(54.77,88.86)
  vias: v1(107.92,78.23)
I2C3_SDA: length 107.6
  TOP w0.127: U50.33 45.52,106.08 v2(45.77,106.33) ; v2(52.48,27.97) 52.48,27.4 52.61,27.28 U132.13 ; U154.43 v2(53.72,12.49)
  L12-SIGNAL5 w0.102: v2(53.72,12.49) 53.27,12.94 53.27,16.72 54.14,17.58 54.14,24.4 52.48,26.05 v2(52.48,27.97) 52.48,29.19 44.75,36.93 44.75,49.67 42.07,52.35 42.07,52.37 39.57,54.87 39.57,70.3 39.7,70.43 42.2,72.93 42.2,74.56 41.5,75.26 41.5,79.96 41.31,80.15 41.31,96.75 44.45,99.89 44.45,105.01 v2(45.77,106.33)
I2C3_SDA_MUX: length 5.7
  TOP w0.127: U50.23 53.5,105.58 53.89,105.96 R259.2 54.59,105.68 54.75,105.53 56.61,105.53 R260.1
I2C4_SCL: length 170.6
  TOP w0.127: v2(128.47,161.51) U20.6 128.47,163.37 128.98,163.88 133.38,163.88 133.6,163.66 U18.12
  L3-SIGNAL1 w0.089: v2(128.47,161.51) 99.61,161.51 85.46,147.36 85.46,145.17 75.7,135.41 70.13,135.41 v2(63.04,128.31) ; v5(91.37,87.2) 93.43,87.2 97.1,83.54 97.1,82.39 100.57,78.92 102.16,78.92 102.24,79 104.94,79 105.55,79.6 105.73,79.6 107.27,79.6 107.5,79.83 v3(107.92,79.83)
  L4-GND2 w0.102: v5(91.37,87.2) v6(91.04,87.2)
  L5-SIGNAL2 w0.102: v6(91.04,87.2) 90.23,88.01 90.23,91.42 86.12,95.53 76.21,95.53 69.71,102.03 69.71,111.61 70.85,112.75 70.85,118.79 69.54,120.1 69.54,121.08 v2(69.96,121.5)
  L14-SIGNAL6 w0.089: v2(63.04,128.31) 64.94,128.31 69.96,123.3 v2(69.96,121.5)
  vias: v1(107.92,79.83)
I2C4_SDA: length 172
  TOP w0.127: v2(129.69,161.08) 129.12,161.65 U20.5 129.12,163.28 129.35,163.51 131.91,163.51 132.23,163.19 132.23,162.73 132.58,162.38 U18.13
  L3-SIGNAL1 w0.089: v3(108.72,80.63) 108.22,80.14 107.54,80.14 107.42,80.02 107.22,79.82 105.82,79.82 105.46,79.82 104.85,79.21 102.15,79.21 102.07,79.13 100.74,79.13 97.31,82.56 97.31,83.62 93.18,87.76 v5(91.09,87.76) ; v2(62.39,127.67) 62.99,127.67 70.51,135.18 75.78,135.18 85.68,145.08 85.68,147.27 99.49,161.08 v2(129.69,161.08)
  L4-GND2 w0.102: v5(91.09,87.76) v6(91.09,88.09)
  L5-SIGNAL2 w0.102: v2(69.95,120.41) 69.95,120.06 71.1,118.9 71.1,112.65 69.96,111.51 69.96,102.1 75.44,96.62 85.35,96.62 90.46,91.52 90.46,88.72 v6(91.09,88.09)
  L14-SIGNAL6 w0.089: v2(62.39,127.67) 65.03,127.67 69.48,123.22 69.48,120.88 v2(69.95,120.41)
  vias: v1(108.72,80.63)
I2C5_SCL: length 255.7
  TOP w0.127: v2(206.89,50.42) 206.76,50.55 U88.6 ; v2(190.56,65.03) 190.9,65.37 U76.12
  L3-SIGNAL1 w0.089: v2(190.56,65.03) 190.56,63.08 191.65,61.98 194.39,61.98 194.68,61.7 197.84,61.7 199.53,60.01 203.52,60.01 204.68,58.85 204.68,57.15 203.84,56.31 203.84,53.47 v2(206.89,50.42) ; v3(111.12,79.83) v5(110.8,79.65)
  L4-GND2 w0.102: v5(110.8,79.65) v7(110.42,79.5)
  L5-SIGNAL2 w0.102: v2(190.56,65.03) 190.56,60.7 184.81,54.95 184.55,54.95 180.8,51.2 180.8,49.7 173.42,42.32 157.87,42.32 156.5,40.94 131.5,40.94 131.17,40.62 130.13,40.62 129.27,41.48 115.39,41.48 114.91,41.96 87.16,41.96 v7(85.43,43.7)
  L12-SIGNAL5 w0.102: v7(85.43,43.7) 83.96,45.16 82.15,45.16 74.51,52.81 74.51,65.76 73.26,67.01 73.26,70.51 70.16,73.61 70.16,87.34 73.38,90.56 84.02,90.56 85.61,88.97 85.61,87.47 84.45,86.3 83.81,86.3 83.57,86.07 83.57,85.38 84.13,84.81 84.13,84.18 85.29,83.02 85.29,82.45 87.07,80.67 89.04,80.67 89.24,80.88 91.42,80.88 91.46,80.92 102.5,80.92 102.9,81.33 107.17,81.33 107.76,80.75 107.76,80.17 108.8,79.13 110.05,79.13 v7(110.42,79.5)
  BOTTOM w0.127: R1147.2 v2(206.89,50.42)
  vias: v1(111.12,79.83)
I2C5_SDA: length 252.1
  TOP w0.127: U88.5 206.66,51.2 v2(206.89,51.43) ; U76.13 192.1,63.72 191.8,63.43 v2(191.8,63.41)
  L3-SIGNAL1 w0.089: v2(206.89,51.43) 206.42,51.43 204.1,53.75 204.1,56.18 204.96,57.05 204.96,58.9 203.64,60.23 200.04,60.23 197.36,62.9 192.31,62.9 v2(191.8,63.41) ; v3(110.32,79.83) v5(109.96,79.83)
  L4-GND2 w0.102: v5(109.96,79.83) v7(109.69,79.55)
  L5-SIGNAL2 w0.102: v2(191.8,63.41) 191.8,61.62 184.83,54.64 184.57,54.64 181.03,51.11 181.03,49.61 173.51,42.09 157.97,42.09 156.6,40.72 132.16,40.72 131.33,39.88 116.67,39.88 114.82,41.73 86.17,41.73 85.02,42.88 85.02,43.59 83.94,44.67 v2(83.19,44.67)
  L12-SIGNAL5 w0.102: v2(83.19,44.67) 82.08,44.67 74.1,52.65 74.1,65.35 72.88,66.57 72.88,70.38 69.71,73.56 69.71,87.2 73.32,90.81 84.18,90.81 85.83,89.15 85.83,87.38 84.41,85.95 84.41,84.46 85.51,83.36 85.51,82.55 87.13,80.93 88.81,80.93 88.99,81.1 91.32,81.1 91.37,81.15 102.17,81.15 102.85,81.84 107.17,81.84 108.09,80.92 108.09,80.24 108.77,79.55 v7(109.69,79.55)
  BOTTOM w0.127: R1143.2 v2(206.89,51.43)
  vias: v1(110.32,79.83)
IFORCE: length 21.3
  TOP w0.127: TP161.1 98.8,61.37 98.86,61.43 v2(98.92,61.43)
  L3-SIGNAL1 w0.089: v3(110.32,76.63) v5(110.09,76.35)
  L4-GND2 w0.102: v5(110.09,76.35) v7(109.78,76.05)
  L7-SIGNAL3 w0.109: v2(98.92,61.43) 103.28,65.8 103.28,69.55 v7(109.78,76.05)
  vias: v1(110.32,76.63)
IOEXP1_A0: length 2.5
  TOP w0.127: R251.1 R250.2 46.88,110.82 46.88,111.41 U43.18
IOEXP2_A0: length 2.6
  BOTTOM w0.127: U173.26 156.41,171.02 156.1,171.33 R773.1 R771.1
IOEXP3_ADDR: length 4.4
  TOP w0.127: R628.2 49.78,25.83 50.44,25.17 R638.1 52.41,25.78 U132.16
IOEXP3_INT#: length 1.4
  TOP w0.127: U132.11 R616.1
IOEXP4_ADDR: length 3.4
  TOP w0.127: R97.2 R98.1 132.24,159.04 132.9,159.7 U18.16
IOEXP4_INT#: length 1.4
  TOP w0.127: U18.11 R72.1
IOEXP5_ADDR: length 2.7
  TOP w0.127: U76.16 193.6,63.94 R453.1 R459.2
IOEXP5_INT#: length 260.4
  TOP w0.127: U76.11 R443.1 189.1,65.87 188.79,65.56 188.79,61.85 v2(188.75,61.81) ; R345.1 v2(41.99,88.21)
  L7-SIGNAL3 w0.109: v2(41.99,88.21) 36.45,82.67 36.45,73.98 40.22,70.21 40.22,41.35 42.15,39.41 45.79,39.41 46.37,39.99 49.72,39.99 53.7,43.97 60.66,43.97 68.65,35.98 77.17,35.98 80.53,32.62 108.8,32.62 109.22,33.05 110.42,33.05 110.9,32.56 116.54,32.56 119.34,29.77 123.88,29.77 124.72,28.93 136.57,28.93 140.29,25.2 142.07,25.2 147.94,19.34 171.51,19.34 173.72,21.55 173.72,26.98 179.64,32.9 184.13,32.9 184.67,32.37 186.55,32.37 187.28,33.1 187.28,39.04 186.32,40.01 186.32,45.44 184.77,46.99 184.77,57.13 185.82,58.17 188.35,58.17 188.75,58.57 v2(188.75,61.81)
JTAG_MUX1_OE#: length 4.3
  BOTTOM w0.127: C772.2 R951.1 26.44,102.1 26.57,102.23 U206.15
JTAG_MUX2_OE#: length 4.3
  TOP w0.127: U47.15 26.87,105.48 26.59,105.76 R256.1 C204.2
JTAG_MUX_SEL: length 28.6
  TOP w0.127: v2(24.58,105.48) 23.93,106.13 U47.1
  L3-SIGNAL1 w0.089: v2(24.58,105.48) 22,102.89 v2(22,100.3) 20.31,98.61 8.14,98.61 v2(6.95,97.42)
  BOTTOM w0.127: U206.1 21.16,101.58 20.93,101.35 R953.1 v2(22,100.3)
JTAG_RESETZ: length 197.8
  L3-SIGNAL1 w0.089: v2(166.26,34.92) 165.41,34.07 165.41,31.85 164.17,30.61 162.9,30.61 162.55,30.96 155.33,30.96 154.54,30.18 135.47,30.18 133.05,32.59 113.93,32.59 111.13,35.39 99.5,35.39 94.81,40.08 86.37,40.08 86.15,39.85 81.09,39.85 80.2,38.96 78.9,38.96 78.01,39.85 58.57,39.85 56.84,41.58 52.86,41.58 52.32,42.12 47.56,42.12 46.81,42.87 45.2,42.87 43.14,44.93 32.51,44.93 30.42,47.02 29.7,47.02 v2(28.6,48.11)
  L5-SIGNAL2 w0.102: v2(6.95,82.49) 9.52,79.92 9.52,67.57 9.52,67.19 11.77,64.95 19.08,57.64 19.08,51.44 21.9,48.62 28.1,48.62 v2(28.6,48.11)
  BOTTOM w0.127: R1157.1 v2(28.6,48.11)
LEOA_OSC32KCAP: length 1.5
  TOP w0.127: v2(180.91,76.52) 180.72,76.32 U68.40
  BOTTOM w0.127: C977.1 v2(180.91,76.52)
LEOA_OSC32KIN: length 9.2
  TOP w0.127: U68.38 181.03,75.32 181.14,75.22 v2(181.54,75.22)
  BOTTOM w0.127: v2(181.54,75.22) 181.76,75.43 181.76,76.89 184.17,79.3 Y10.2 185.83,79.3 186.06,79.07 C941.2
LEOA_OSC32KOUT: length 10.9
  TOP w0.127: U68.39 181.13,75.82 v2(181.16,75.85)
  BOTTOM w0.127: C917.2 186.15,82.15 185.79,81.8 Y10.1 183.37,80.58 183.37,79.37 183.06,79.06 182.68,79.06 182.42,78.8 182.42,77.94 181.52,77.04 181.52,76.59 181.37,76.45 181.37,76.06 v2(181.16,75.85)
LIN1_DATA: length 25.9
  TOP w0.127: U109.13 C377.1 25.01,39.64 25.18,39.81 25.18,41.36 24.85,41.69 17.51,41.69 17.3,41.48 SW13.3 17.3,40.34 16.83,39.87 16.83,37.25 15.64,36.06 9.41,36.06 J28.2
LIN1_RXD: length 3.3
  TOP w0.127: R602.2 R596.1 23.75,34.14 U109.1
LIN1_TXD: length 3
  TOP w0.127: U109.3 R597.2 R603.2
LIN2_DATA: length 28.6
  TOP w0.127: J28.3 9.41,36.39 15.51,36.39 16.5,37.39 16.5,39.88 16.03,40.35 SW13.4 16.03,41.66 16.47,42.1 26.07,42.1 26.65,41.51 26.65,39.86 26.87,39.64 C379.1 27.32,39.31 27,38.99 U109.9
LIN2_RXD: length 3.3
  TOP w0.127: R604.2 R598.1 25.7,34.14 U109.4
LIN2_TXD: length 3.3
  TOP w0.127: U109.7 27.65,34.14 R599.2 R605.2
LIN_UART6_RXD: length 52.2
  TOP w0.127: v2(38.01,79.03) 38.3,78.73 U58.53
  L12-SIGNAL5 w0.102: v2(38.01,79.03) 37.86,78.88 37.86,42.99 37.73,42.86 32.75,37.88 31.19,37.88 v2(30.76,37.45)
LIN_UART6_TXD: length 53.1
  TOP w0.127: U58.51 43.69,79.73 43.5,79.54 36.99,79.54 v2(36.89,79.43)
  L12-SIGNAL5 w0.102: v2(36.89,79.43) 37.64,78.68 37.64,43.09 34.77,40.22 32.14,40.22 v2(30.74,38.82)
LIN_UART9_RXD: length 22.8
  TOP w0.127: U58.44 43.56,83.23 v2(43.31,82.98)
  L12-SIGNAL5 w0.102: v2(43.31,82.98) 42.88,82.55 42.88,80.8 43.13,80.55 43.35,80.55 43.96,79.94 43.96,63.01 v2(43.41,62.46)
LIN_UART9_TXD: length 22.7
  TOP w0.127: U58.42 43.56,84.23 v2(43.31,83.98)
  L12-SIGNAL5 w0.102: v2(43.31,83.98) 42.65,83.32 42.65,80.71 42.84,80.52 42.84,79.22 43.74,78.32 43.74,65.2 v2(43.14,64.6)
  BOTTOM w0.127: v2(43.14,64.6) 43.41,64.33 R1108.1
LINE_OUT2_L: length 7.5
  BOTTOM w0.381: J29.5B 13.5,18.16 14.21,18.88 R1263.1 C1229.2
LINE_OUT2_R: length 7.5
  BOTTOM w0.381: C1215.2 R1252.1 14.21,22.56 13.5,23.28 J29.2B
LJCB_ATEST0: length 44.8
  L3-SIGNAL1 w0.089: v3(128.72,90.23) v5(128.94,90.51)
  L4-GND2 w0.102: v5(128.94,90.51) v7(129.25,90.82)
  L10-SIGNAL4 w0.109: v7(129.25,90.82) 129.53,90.82 130.62,91.9 130.89,91.9 133.54,94.54 136.36,94.54 137.42,95.6 137.42,99.09 139.61,101.27 139.61,118.5 144.08,122.97 v2(144.08,126.75)
  vias: v1(128.72,90.23)
LJCB_ATEST1: length 45.9
  L3-SIGNAL1 w0.089: v3(127.92,90.23) v5(128.14,90.51)
  L4-GND2 w0.102: v5(128.14,90.51) v7(128.45,90.82)
  L10-SIGNAL4 w0.109: v7(128.45,90.82) 128.87,91.24 129.4,91.24 130.47,92.3 130.47,92.57 130.74,92.84 131.01,92.84 131.23,93.06 131.23,93.33 131.54,93.64 131.81,93.64 132.03,93.86 132.03,94.13 132.29,94.4 132.63,94.4 132.87,94.64 132.87,94.97 133.15,95.25 134.29,95.25 134.73,94.82 136.25,94.82 137.14,95.71 137.14,99.19 139.38,101.42 139.38,118.59 142.76,121.97 v2(142.76,126.75)
  vias: v1(127.92,90.23)
LM5060_EN: length 107.8
  L3-SIGNAL1 w0.089: J6.2 204.69,177.99 204.69,162.22 210.41,156.5 210.41,146.04 v2(209.86,145.49) 208.02,143.64 208.02,140.39 v2(207.62,139.99)
  L5-SIGNAL2 w0.102: J6.2 213.15,169.53 234.75,169.53 236.72,171.5 236.72,172.1 SW1.2
  BOTTOM w0.127: U182.5 209.12,139.66 208.79,139.99 v2(207.62,139.99)
LM5060_EN_HIGH: length 51.9
  L5-SIGNAL2 w0.102: SW1.3 238.62,169.3 213.05,169.3 199.16,183.19 J6.1
  BOTTOM w0.127: SW1.3 239.94,170.62 R780.2
LM5060_EN_LOW: length 59.1
  L5-SIGNAL2 w0.102: SW1.1 236.36,176.44 236.36,171.62 234.49,169.76 213.24,169.76 198.79,184.21 198.79,186.43 J6.3
LM5060_GATE: length 8.6
  TOP w0.127: U28.1 v2(213.8,142.83)
  BOTTOM w0.127: U182.10 211.12,143.7 211.34,143.92 212.2,143.92 212.4,144.13 C643.2 213.34,144.61 213.79,144.15 213.79,142.84 v2(213.8,142.83)
LM5060_NPGD: length 3.2
  BOTTOM w0.127: R831.1 R830.1 209.86,144.13 210.12,143.87 U182.8
LM5060_OUT: length 2
  BOTTOM w0.127: R829.2 211.13,144.58 210.62,144.06 U182.9
LM5060_OVP: length 3.7
  BOTTOM w0.127: U182.3 210.12,137.32 209.48,136.68 R850.2 R851.1
LM5060_SENSE: length 2.8
  BOTTOM w0.127: R846.2 211.35,139.77 211.12,139.54 U182.1
LM5060_TIMER: length 3.4
  BOTTOM w0.127: C650.1 209.42,141.45 209.62,141.65 U182.7
LM5060_ULVO: length 4.2
  BOTTOM w0.127: R847.2 R849.1 209.49,137.45 209.62,137.57 U182.4
LM5140/LM5143/LM5141_PG: length 4.8
  BOTTOM w0.127: U255.3 R1193.2 R1192.2 R1191.2 R1190.2
LM5140_LO1: length 6.9
  L3-SIGNAL1 w0.089: v2(221.32,108.28) 221.91,107.68 v3(228.01,107.68)
LM5140_LO2: length 4.9
  L3-SIGNAL1 w0.089: v3(226.06,101.59) 225.86,101.39 v2(221.27,101.39)
LM5140_PG1: length 285.7
  TOP w0.127: U46.24 216.81,108.7 217.01,108.91 v2(217.03,108.91)
  L3-SIGNAL1 w0.089: v2(217.03,108.91) 216.3,108.91 214,106.61 214,95.8 215.26,94.54 217.93,94.54 218.87,93.6 218.87,89.09 219.36,88.61 219.36,75.84 215.94,72.42 215.94,68.2 212.03,64.29 212.03,53.63 207.6,49.2 206.63,49.2 206.38,49.45 198.22,49.45 197.04,48.27 197.04,45.14 195.92,44.02 193.58,44.02 192.87,44.73 175.01,44.73 174.52,44.24 169.32,39.05 168.6,39.05 164.82,35.27 161.88,35.27 v2(161.24,35.91) 160.05,35.91 157.96,33.83 114.59,33.83 109.3,39.12 98.94,39.12 93.74,44.32 87.55,44.32 86.22,42.99 83.23,42.99 81.36,44.86 78.24,44.86 75.22,47.88 69.66,47.88 68.9,48.63 68.9,50.01 68.33,50.57 66.36,50.57 64.92,49.12 56.4,49.12 50.98,43.71 46.17,43.71 43.92,45.96 43.92,46.85 42.14,48.63 32.97,48.63 32.53,49.07 25.56,49.07 24.87,48.39 20.78,48.39 20.19,48.97 v2(19.77,49.4)
  BOTTOM w0.127: R939.1 217.15,109.65 217.03,109.52 v2(217.03,108.91) ; R1193.1 v2(161.24,35.91)
LM5140_PG1/LM5140_PG2: length 2.6
  BOTTOM w0.127: R1153.2 R1155.2 U247.1
LM5140_PG2: length 300
  TOP w0.127: U46.7 216.81,100.75 216.47,100.41 216.47,99.18 v2(216.88,98.77)
  L3-SIGNAL1 w0.089: v2(216.88,98.77) 216.76,98.65 215.34,98.65 214.42,97.73 214.42,95.69 215.23,94.88 218.01,94.88 219.08,93.8 219.08,89.18 219.57,88.7 219.57,75.72 216.28,72.42 216.28,68.16 214.11,65.99 214.11,56.41 222.68,47.85 222.68,43.29 221.33,41.94 207.28,41.94 205.76,40.43 204.92,40.43 203.31,38.81 203.31,37.97 195.15,29.81 195.02,29.69 182.34,29.69 181.77,29.12 176.09,29.12 175.2,28.23 164.92,28.23 164.16,29 163.11,29 162.16,29.95 156.93,29.95 154.76,27.77 142.69,27.77 137.3,27.77 128.29,27.77 127.72,27.2 110.17,27.2 103.31,34.06 93,34.06 91.58,32.64 78.77,32.64 77.58,33.83 66.64,33.83 63.84,36.63 51.33,36.63 49.98,37.99 22.54,37.99 16.17,44.35 16.17,46.42 18.01,48.26 v2(19.77,48.26)
LM5140_SW1: length 2.3
  TOP w0.254: C201.1 219.45,109.16 218.31,108.02 U46.21
LM5140_SW2: length 3
  TOP w0.254: C232.2 218.31,100.93 U46.10
  TOP w0.381: C232.2 219.07,99.11
LM5141_PG: length 56.2
  TOP w0.127: v2(203.79,57.67) 204.07,57.94 U81.21
  L3-SIGNAL1 w0.089: v2(203.79,57.67) 203.48,57.67 199.33,53.52 194.86,53.52 194.42,53.08 190.09,53.08 182.86,45.85 171.26,45.85 161.7,36.3 161.7,35.79 162.01,35.49 163.1,35.49 v2(163.52,35.91)
  BOTTOM w0.127: v2(203.79,57.67) 203.95,57.82 R1131.1 ; R1191.1 v2(163.52,35.91)
LM5143_FB: length 6
  TOP w0.127: U25.28 v2(204.97,146.52)
  BOTTOM w0.127: R834.2 R833.2 206.28,144.93 R832.2 206.31,144.95 206.31,145.96 205.74,146.52 v2(204.97,146.52)
LM5143_HB1: length 6.7
  TOP w0.381: U25.20 200.46,148.1 199.7,147.34 C122.2 198.31,145.65 197.58,146.38 196.36,146.38 D32.1
LM5143_HB2: length 6.5
  TOP w0.381: D31.1 197.53,154.32 198,154.8 C100.1 200.08,152.98 200.46,152.6 U25.11
LM5143_HO1: length 1.8
  TOP w0.127: R149.2 201.77,146.09 201.97,146.29 U25.22
LM5143_HO2: length 2
  TOP w0.127: R118.1 202.05,154.81 201.97,154.72 U25.9
LM5143_HOL1: length 19.7
  TOP w0.127: v2(202,144.83) 202.38,144.83 202.61,145.07 R149.1 202.61,146.12 202.47,146.27 U25.23
  L3-SIGNAL1 w0.089: v2(202,144.83) 201.63,144.46 v2(186.58,144.46)
  BOTTOM w0.127: U180.4 v2(186.58,144.46)
LM5143_HOL2: length 25
  TOP w0.127: U25.8 202.47,154.43 202.89,154.86 R118.2 202.89,155.81 202.29,156.41 v2(202.29,156.96)
  L3-SIGNAL1 w0.089: v2(194.93,152.24) 195.77,152.24 196.71,151.29 198.91,151.29 199.31,151.69 199.95,151.69 201.15,152.89 201.15,156.57 201.54,156.96 v2(202.29,156.96)
  BOTTOM w0.127: v2(194.93,152.24) 194.49,151.8 187.95,151.8 187.57,151.42 U178.4
LM5143_LO1: length 11.1
  TOP w0.127: U25.18 200.05,149.1 199.89,148.94 v3(199.89,148.6) U25.19
  L3-SIGNAL1 w0.089: v3(199.89,148.6) 198.75,147.46 194.26,147.46 193.25,148.47 v3(191.75,148.47)
LM5143_LO2: length 9.1
  TOP w0.127: U25.12 v3(199.89,152.1) 199.89,151.76 200.05,151.6 U25.13
  L3-SIGNAL1 w0.089: v3(193.85,152.22) 194.96,153.33 198.66,153.33 v3(199.89,152.1)
LM5143_PG1: length 169.2
  TOP w0.127: U25.24 v2(202.97,146.52)
  L3-SIGNAL1 w0.089: v2(162.38,35.91) 171.63,45.16 195.95,45.16 196.45,45.66 196.45,48.67 197.67,49.89 206.56,49.89 206.71,49.73 207.5,49.73 211.6,53.83 211.6,64.55 215.26,68.21 215.26,72.57 218.92,76.24 218.92,88.43 218.44,88.92 218.44,93.34 217.95,93.83 215.05,93.83 213.1,95.79 213.1,98.68 210.01,101.77 210.01,127.23 211.5,128.72 211.5,133.75 210.77,134.48 206.44,134.48 205.09,135.83 205.09,141.66 205.72,142.3 205.72,143.65 203.88,145.5 203.88,146.11 203.46,146.52 v2(202.97,146.52)
  BOTTOM w0.127: R828.1 v2(202.97,146.52) ; R1192.1 v2(162.38,35.91)
LM5143_PG2: length 175.6
  TOP w0.127: v2(202.97,154.24) U25.7
  L3-SIGNAL1 w0.089: v2(202.97,154.24) 203.74,153.47 203.74,147.9 204.42,147.22 204.42,145.32 205.98,143.77 205.98,141.94 205.37,141.33 205.37,136.08 206.65,134.79 210.9,134.79 211.74,133.95 211.74,128.56 210.22,127.05 210.22,101.9 213.53,98.59 213.53,95.91 215.27,94.17 217.95,94.17 218.65,93.47 218.65,89.01 219.14,88.52 219.14,76.15 215.57,72.58 215.57,68.15 211.81,64.39 211.81,53.72 207.55,49.45 206.68,49.45 206.47,49.67 197.96,49.67 196.73,48.44 196.73,45.54 196.13,44.95 172.28,44.95 164.67,37.33 v2(164.67,35.91)
  BOTTOM w0.127: R817.1 v2(202.97,154.24) ; R1190.1 v2(164.67,35.91)
LM5143_SW1: length 2
  TOP w0.254: U25.21 201.47,147.08 200.62,146.24 C122.1
  vias: v2(188.64,147.29) v2(188.64,146.27) v2(188.64,145.26) v2(189.66,147.29) v2(189.66,146.27) v2(189.66,145.26) v2(190.67,147.29) v2(190.67,146.27) v2(190.67,145.26) v2(191.69,147.29) v2(191.69,146.27) v2(191.69,145.26) v2(192.71,147.29) v2(192.71,146.27) v2(192.71,145.26) v2(193.72,147.29) v2(193.72,146.27) v2(193.72,145.26)
LM5143_SW2:
  vias: v2(188.81,155.43) v2(188.81,154.41) v2(188.81,153.4) v2(189.82,155.43) v2(189.82,154.41) v2(189.82,153.4) v2(190.84,155.43) v2(190.84,154.41) v2(190.84,153.4) v2(191.85,155.43) v2(191.85,154.41) v2(191.85,153.4) v2(192.87,155.43) v2(192.87,154.41) v2(192.87,153.4) v2(193.89,155.43) v2(193.89,154.41) v2(193.89,153.4)
LO1: length 2.8
  TOP w0.127: R254.2 220.11,106.23 219.97,106.23 219.78,106.04 U46.18
LO2: length 3.2
  TOP w0.127: R272.1 220.8,102.23 220.56,102.47 220.56,103.21 220.28,103.49 219.11,103.49 U46.13
LO_LM5141: length 2.8
  TOP w0.127: R482.1 209.76,55.77 209.76,56.4 209.22,56.94 U81.8
LOL1: length 2.8
  TOP w0.127: U46.19 219.82,106.54 219.97,106.69 v2(219.97,106.95)
  BOTTOM w0.127: R940.2 220.46,107.44 v2(219.97,106.95)
LOL2: length 2.5
  TOP w0.127: v2(219.89,103.04) U46.12
  BOTTOM w0.127: R950.1 220.7,102.23 v2(219.89,103.04)
LOL_LM5141: length 3.3
  TOP w0.127: R488.1 209.79,54.6 209.79,55.17 209.48,55.47 209.48,56.09 209.13,56.44 U81.7
LSM6DSRX_CS: length 2.7
  BOTTOM w0.127: R1047.2 R1043.2 17.67,75.78 17.79,75.66 U228.12
LSM6DSRX_INT: length 2.6
  BOTTOM w0.127: U228.4 R1029.2 R1028.2
LSM6DSRX_INT2: length 1.1
  BOTTOM w0.127: U228.9 19.79,74.23 v2(19.53,73.97)
LSM6DSRX_SA0: length 1.3
  BOTTOM w0.127: U228.1 R1030.2
MAIN_ATEST: length 26.1
  TOP w0.127: v2(98.28,60.69) 98.26,60.71 97.21,60.71 96.71,61.21 96.71,61.66 TP160.1
  L3-SIGNAL1 w0.089: v3(111.92,76.63) v5(111.69,76.35)
  L4-GND2 w0.102: v5(111.69,76.35) v7(111.38,76.05)
  L7-SIGNAL3 w0.109: v2(98.28,60.69) 99.25,60.69 103.52,64.96 103.52,69.33 108.79,74.6 110.68,74.6 111.11,75.03 111.11,75.77 v7(111.38,76.05)
  vias: v1(111.92,76.63)
MAIN_PWRGRP_IRQN: length 409.3
  TOP w0.127: R1300.1 163.21,49 v2(162.96,48.75) ; R206.2 167.35,120.62 U35.4 ; U48.4 74.48,100.36 74.16,100.03 73.81,100.03 v2(73.38,99.6) ; v2(73.38,110.78) 73.81,111.21 74.17,111.21 74.48,111.52 U42.4 ; U37.4 190.2,120.62 189.81,121.01 189.81,121.61 v2(189.38,122.03) ; v2(178.2,122.03) 178.63,121.61 178.63,121.01 179.02,120.62 U36.4 ; R1298.1 v2(110.1,119.4)
  L3-SIGNAL1 w0.089: v2(73.38,110.78) 72.55,111.6 72.55,113.67 73.93,115.05 77.44,115.05 79.1,116.71 79.1,118.74 81.57,121.21 81.57,122.75 86.04,127.23 95.05,127.23 98.1,130.28 120.73,130.28 130,139.55 144.51,139.55 148.24,135.81 152.97,135.81 154.03,134.75 164.19,134.75 166.26,134.75 v2(166.94,134.07) ; v2(180.87,55.39) 180.87,59.74 188.89,67.75 197.21,67.75 199.72,65.24 199.72,62.89 v2(199.68,62.85)
  L7-SIGNAL3 w0.109: v2(110.1,119.4) 101.69,119.4 95.66,125.43 83.35,125.43 82.13,124.21 82.13,121.79 80.75,120.42 73.92,120.42 72.02,118.52 72.02,115.93 72.73,115.21 72.73,113.79 72.53,113.59 72.53,111.05 72.8,110.78 v2(73.38,110.78) ; v2(84.01,80.22) 84.01,84 84.51,84.51 84.51,88.47 83.83,89.15 81.82,89.15 73.38,97.6 v2(73.38,99.6)
  L10-SIGNAL4 w0.109: v2(162.96,48.75) 164.72,48.75 165.18,48.29 176.79,48.29 178.06,49.56 178.06,51.46 180.87,54.27 v2(180.87,55.39)
  L14-SIGNAL6 w0.089: v2(73.38,99.6) 72.42,100.55 72.42,102.24 74.59,104.4 74.59,106.37 73.38,107.58 v2(73.38,110.78) ; v2(166.7,121.25) 167.88,122.43 167.88,131.63 166.94,132.57 v2(166.94,134.07) 167.14,134.27 174.24,134.27 178.2,130.31 v2(178.2,122.03) 178.6,121.64 179.34,121.64 179.78,122.08 181.01,122.08 182.33,123.4 187,123.4 188.36,122.03 v2(189.38,122.03) 189.38,121.58 188.53,120.73 183.63,120.73 179.15,116.26 179.15,113.79 184.84,108.1 184.84,95.64 v11(180.93,91.73) 180.5,91.3 180.5,86.82 179.64,85.96 179.64,82.81 180.16,82.28 180.16,78.73 178.86,77.42 178.86,77.41 178.86,72.71 179.06,72.5 180.19,72.5 180.95,71.73 180.97,71.73 180.98,71.72 181.05,71.72 181.29,71.49 181.29,71.4 181.49,71.2 181.49,70.12 182.84,68.77 182.84,57.36 v2(180.87,55.39)
  BOTTOM w0.127: R1294.1 85.18,79.14 84.98,79.35 84.36,79.35 84.01,79.71 v2(84.01,80.22) ; U216.3 v11(180.93,91.73) ; U234.2 199.6,62.92 v2(199.68,62.85)
MAIN_PWRGRP_IRQN_BUF: length 1.6
  BOTTOM w0.127: R1089.1 199.08,68.02 198.65,67.59 U234.4
MAIN_RET_WAKE: length 129.3
  TOP w0.127: SW3.2 SW3.3 D33.1 R202.2 C160.1 v2(20.96,122.84)
  L3-SIGNAL1 w0.089: v2(92.46,85.27) 93.64,85.27 96,82.91 96,81.94 100.11,77.83 102.68,77.83 102.76,77.9 105.37,77.9 106.01,78.54 108.22,78.54 v3(108.72,79.03)
  L14-SIGNAL6 w0.089: v2(20.96,122.84) 21.99,123.87 35.84,123.87 40.63,119.08 45.51,119.08 45.87,119.43 52.36,119.43 58.68,113.1 58.68,109.28 60.83,107.14 68.74,107.14 70.98,104.9 70.98,102.56 71.68,101.85 71.68,100.73 75.02,97.4 84.9,97.4 85.15,97.64 87.35,97.64 87.68,97.32 87.68,92.26 88.22,91.72 88.22,89.51 v2(92.46,85.27)
  vias: v1(108.72,79.03)
MAIN_SVS_SLEEPN: length 2
  TOP w0.127: U87.7 179.71,48.36 R546.1
MAX6818_CH#: length 2.1
  TOP w0.127: U98.11 R539.2
MAX6818_EN#: length 3.6
  TOP w0.127: U98.1 228.71,42.37 228.32,41.98 R568.2
MCAN3_EN: length 1.7
  TOP w0.127: U148.6 116.52,15.93 116.65,16.06 v2(117.13,16.06)
MCAN3_FAULT#: length 2.9
  TOP w0.127: U148.8 115.25,8.51 114.9,8.16 TP250.1
MCAN3_H: length 9.1
  TOP w0.132: J41.1 123.5,4.38 123.2,4.68 121.4,4.68 121.13,4.95 121.13,7.1 R712.1 121.13,8.04 121.13,8.58 121.6,9.05 U148.13
MCAN3_L: length 9.1
  TOP w0.132: J41.3 118.42,4.38 118.73,4.68 120.53,4.68 120.8,4.95 120.8,7.1 R711.2 120.8,8.04 120.8,8.58 120.33,9.05 U148.12
MCAN3_PWR_ON_HV: length 4.9
  TOP w0.127: TP239.1 114.02,18.23 R684.1 R676.2 U148.7
MCAN3_RX: length 84.7
  TOP w0.127: U108.3 59.5,33.82 v2(59.83,33.5) ; R677.1 v2(119.06,18.16) 119.06,18.75 119.28,18.97 124.76,18.97 125.28,18.45 J32.2
  L3-SIGNAL1 w0.089: v2(59.83,33.5) 59.83,32.11 57.08,29.36 57.08,27.66 66.48,18.26 113.1,18.26 113.78,17.58 118.48,17.58 v2(119.06,18.16)
MCAN3_RX_MUX: length 71
  TOP w0.127: v2(53.27,85.98) 53.02,85.73 U58.18
  L3-SIGNAL1 w0.089: v5(89.43,82.32) 89.81,82.32 91.11,81.02 91.11,80.55 99.01,72.65 102.23,72.65 104.04,74.46 107.23,74.46 107.51,74.73 108.41,74.73 v3(108.72,75.03)
  L4-GND2 w0.102: v5(89.43,82.32) 89.44,82.32 v6(89.44,82.62)
  L5-SIGNAL2 w0.102: v2(53.27,85.98) 53.59,85.66 60.24,85.66 61.02,86.44 72.3,86.44 74.21,88.35 75.03,88.35 78.01,91.33 84.62,91.33 85.66,90.29 85.66,87.61 86.57,86.69 86.57,85.8 88.06,84.32 88.06,83.52 88.95,82.62 v6(89.44,82.62)
  vias: v1(108.72,75.03)
MCAN3_STB#: length 257.7
  TOP w0.127: v2(127.36,14.6) 127.36,13.21 125.76,11.62 U155.2
  L12-SIGNAL5 w0.102: v2(127.36,14.6) 127.81,15.05 155.08,15.05 157.15,12.99 162.65,12.99 163.44,13.78 163.44,14.31 164.06,14.93 169.74,14.93 175.05,20.24 177.16,20.24 181.6,24.68 191,24.68 198.99,32.67 198.99,37.54 197.37,39.16 197.37,52.81 200.24,55.68 200.24,60.96 201.71,62.43 201.71,79.81 200.29,81.23 200.29,86.84 193.08,94.05 186.82,94.05 184.39,96.48 184.39,102.27 176.82,109.84 163.21,109.84 160.79,112.26 160.79,121.76 157.28,125.27 157.28,135.87 161.31,139.9 161.31,149.44 163.38,151.51 163.38,155.59 163.38,161.76 165.36,163.74 165.36,166.37 164.93,166.8 163.24,166.8 v2(162.89,167.15)
MCAN3_STBN: length 4.4
  TOP w0.127: U155.4 125.26,8.69 125.02,8.44 123.05,8.44 122.87,8.62 U148.14
MCAN3_T: length 4.1
  TOP w0.127: v2(122.44,7.57) C530.1
  L14-SIGNAL6 w0.089: v2(119.49,7.57) v2(122.44,7.57)
MCAN3_TX: length 88.1
  TOP w0.127: J32.1 124.18,13.88 123.89,14.17 123.89,16.11 123.6,16.4 123.13,16.4 v2(122.87,16.14) U148.1 ; v2(52.96,33.62) 53.29,33.95 U112.3
  L3-SIGNAL1 w0.089: v2(122.87,16.14) 122.28,15.55 115.4,15.55 112.91,18.05 66.26,18.05 61.41,22.89 58.46,22.89 55.91,25.45 55.91,27.66 55.85,27.72 55.85,27.75 53.18,30.42 53.18,33.41 v2(52.96,33.62)
MCAN3_TX_MUX: length 83.4
  TOP w0.127: v2(50.81,83.98) 51.06,84.23 U58.15
  L3-SIGNAL1 w0.089: v5(89.27,80.85) 88.73,80.31 88.73,76.99 88.6,76.86 88.6,72.37 89.04,71.93 93.03,71.93 95.37,69.59 97.3,69.59 98.06,68.82 102.99,68.82 105.55,71.37 108.17,71.37 108.36,71.56 108.36,71.91 108.64,72.19 109.07,72.19 v3(109.52,72.63)
  L4-GND2 w0.102: v5(89.27,80.85) 89.27,81.18 v6(89.26,81.18)
  L5-SIGNAL2 w0.102: v6(89.26,81.18) 89.26,81.83 87.73,83.36 87.73,84.18 86.32,85.6 86.32,86.54 85.43,87.43 85.43,90.2 84.52,91.1 78.1,91.1 74.52,87.52 74.52,87.04 73.21,85.73 69.35,85.73 68.16,84.53 51.36,84.53 v2(50.81,83.98)
  vias: v1(109.52,72.63)
MCAN3_WAKE: length 6.5
  TOP w0.127: R726.2 114.69,6.55 114.96,6.82 R723.1 ; J41.4 115.88,4.86 115.5,5.24 R723.1 ; R723.1 R724.2
MCAN4_H: length 8.9
  TOP w0.132: J45.1 162.57,4.19 162.26,4.5 160.46,4.5 160.2,4.76 160.2,6.92 R720.1 160.2,7.85 160.2,8.4 160.66,8.86 U152.7
MCAN4_L: length 8.9
  TOP w0.132: U152.6 159.39,8.86 159.86,8.4 159.86,7.85 R719.2 159.86,6.92 159.86,4.76 159.6,4.5 157.79,4.5 157.49,4.19 J45.3
MCAN4_RX: length 243
  TOP w0.127: v2(158.12,17.34) 158.59,17.82 163.1,17.82 J36.2
  L5-SIGNAL2 w0.102: v2(158.12,17.34) 161.15,17.34 162.37,16.13 162.37,15.77 157.71,11.12 127,11.12 126.49,10.61 126.11,10.61 120.47,10.61 120.33,10.74 113.6,17.48 111.95,17.48 106.12,23.3 106.12,24.96 104.77,26.31 92.86,26.31 92.33,25.79 84.23,25.79 82.88,27.13 79.79,27.13 79.49,27.44 71.32,27.44 70.15,26.27 63.1,26.27 59.54,29.83 46.91,29.83 46.72,29.83 43.06,33.49 41.66,33.49 41.39,33.76 37.6,37.55 35.37,39.78 35.37,43.5 34.66,44.21 29.85,49.02 29.04,49.83 23.4,49.83 23.26,49.97 21.5,51.73 21.5,55.54 21.14,55.9 9.75,67.29 9.75,67.48 9.75,76.56 11.68,78.49 11.68,90.2 20.57,99.09 27.97,99.09 v2(28.33,99.45)
  BOTTOM w0.127: R955.2 v2(28.33,99.45)
MCAN4_RX_MUX: length 87.4
  TOP w0.127: v2(50.81,102.83) 51.06,103.08 U50.18
  L3-SIGNAL1 w0.089: v5(75.36,90.99) 75.36,86.88 77.22,85.01 78.24,85.01 79.86,83.39 87.06,83.39 88.33,84.67 88.74,84.67 89.09,84.32 89.09,83.46 89.9,82.65 91.09,82.65 99.58,74.17 100.39,74.17 100.79,73.77 102.12,73.77 103.68,75.32 106.9,75.32 107.41,75.83 v3(107.92,75.83)
  L4-GND2 w0.102: v5(75.36,90.99) 75.37,90.99 v6(75.37,91.29)
  L5-SIGNAL2 w0.102: v2(50.81,102.83) 51.65,101.99 51.65,88.85 52.76,87.73 54.11,87.73 54.87,86.97 72.05,86.97 74.3,89.22 74.3,90.23 v6(75.37,91.29)
  vias: v1(107.92,75.83)
MCAN4_T: length 4.2
  TOP w0.127: C541.1 v2(161.5,7.38)
  L14-SIGNAL6 w0.089: v2(158.55,7.38) v2(161.5,7.38)
MCAN4_TX: length 235.8
  TOP w0.127: J36.1 163.19,13.88 162.95,14.11 162.95,15.73 162.73,15.95 v2(161.93,15.95) U152.1
  L5-SIGNAL2 w0.102: v2(29.21,97.92) 28.38,97.92 27.52,98.79 20.59,98.79 11.91,90.11 11.91,78.31 9.98,76.38 9.98,67.38 21.83,55.54 21.83,51.72 23.49,50.06 29.13,50.06 30,49.2 35.62,43.57 35.62,39.85 37.83,37.64 41.62,33.85 41.76,33.72 43.16,33.72 46.08,30.79 46.82,30.06 61.72,30.06 65.25,26.53 70.04,26.53 71.19,27.67 79.58,27.67 79.89,27.36 82.98,27.36 83.71,26.63 95.12,26.63 96.16,27.67 103.96,27.67 106.56,25.07 106.56,23.29 111.97,17.88 113.52,17.88 120.56,10.84 126.21,10.84 126.4,10.84 126.91,11.35 157.33,11.35 v2(161.93,15.95)
  BOTTOM w0.127: R959.2 v2(29.21,97.92)
MCAN4_TX_MUX: length 75.2
  TOP w0.127: v2(53.22,101.83) 52.97,101.58 U50.15
  L3-SIGNAL1 w0.089: v5(83.8,81.15) 83.8,81.79 83.19,82.4 79.36,82.4 78.55,83.21 76.11,83.21 70.52,88.8 66.63,88.8 64.08,91.35 57.6,91.35 53.22,95.73 v2(53.22,101.83) ; v3(110.32,74.23) v5(110.09,73.95)
  L4-GND2 w0.102: v6(84.04,80.93) 84.04,80.92 v5(83.8,81.15) ; v5(110.09,73.95) v6(109.78,73.65)
  L5-SIGNAL2 w0.102: v6(84.04,80.93) 85.76,80.93 86.29,80.39 86.29,79.68 87.69,78.28 87.69,77.65 88.22,77.11 90.94,77.11 92.18,75.87 99.07,75.87 101.51,73.43 109,73.43 109.22,73.65 v6(109.78,73.65)
  vias: v1(110.32,74.23)
MCAN5_H: length 8.9
  TOP w0.132: U151.7 150.86,8.86 150.39,8.4 150.39,7.85 R718.1 150.39,6.92 150.39,4.76 150.66,4.5 152.46,4.5 152.76,4.19 J44.1
MCAN5_L: length 8.9
  TOP w0.132: J44.3 147.68,4.19 147.99,4.5 149.79,4.5 150.06,4.76 150.06,6.92 R717.2 150.06,7.85 150.06,8.4 149.59,8.86 U151.6
MCAN5_RX: length 119.3
  TOP w0.127: v2(50.09,34.92) 49.77,34.6 U112.13 ; J35.2 153.29,17.82 148.79,17.82 v2(148.32,17.34)
  L3-SIGNAL1 w0.089: v2(148.32,17.34) 146.94,18.72 144.11,18.72 143.57,18.17 125.51,18.17 122.67,15.34 115.31,15.34 112.82,17.83 66.17,17.83 61.32,22.68 58.37,22.68 58.35,22.7 58.3,22.7 55.63,25.37 55.63,27.66 52.96,30.33 52.96,31.68 50.09,34.55 v2(50.09,34.92)
MCAN5_RX_MUX: length 3
  TOP w0.127: R304.2 53.58,96.08 U50.4
MCAN5_STB: length 233.6
  TOP w0.127: v2(152.24,13.36) 153.64,11.96 R708.1 152.44,10.7 152.13,10.39 U151.8
  L12-SIGNAL5 w0.102: v2(152.24,13.36) 152.84,12.76 171,12.76 177.2,18.96 177.2,19.96 181.69,24.45 191.11,24.45 199.3,32.64 199.3,37.58 197.6,39.28 197.6,52.72 201.11,56.23 201.11,61.37 202.04,62.31 202.04,80.01 200.69,81.36 200.69,87.05 193.42,94.32 186.94,94.32 184.67,96.59 184.67,102.3 176.88,110.09 163.28,110.09 161.02,112.35 161.02,122.01 157.5,125.53 157.5,135.66 161.6,139.75 161.6,149.32 163.64,151.36 163.64,155.47 163.64,160.3 166.12,162.79 166.12,166.13 v2(164.93,167.32)
MCAN5_T: length 4.2
  TOP w0.127: C540.1 v2(151.7,7.38)
  L14-SIGNAL6 w0.089: v2(148.75,7.38) v2(151.7,7.38)
MCAN5_TX: length 126.6
  TOP w0.127: v2(50.09,36.87) 49.77,36.55 U112.10 ; U151.1 v2(152.13,15.95) 152.92,15.95 153.14,15.73 153.14,14.11 153.38,13.88 J35.1
  L3-SIGNAL1 w0.089: v2(152.13,15.95) 149.13,18.96 144.04,18.96 143.48,18.39 122.83,18.39 122.07,19.15 113.71,19.15 113.04,18.48 66.67,18.48 57.3,27.85 57.3,29.18 60.36,32.24 60.36,33.68 59.77,34.27 52.7,34.27 v2(50.09,36.87)
MCAN5_TX_MUX: length 4
  TOP w0.127: U50.2 53.4,95.08 53.65,94.83 53.65,93.68 54.09,93.25 R315.2
MCAN16_H: length 8.9
  TOP w0.132: J46.1 172.37,4.19 172.07,4.5 170.26,4.5 170,4.76 170,6.92 R722.1 170,7.85 170,8.4 170.47,8.86 U153.7
MCAN16_L: length 8.9
  TOP w0.132: J46.3 167.29,4.19 167.6,4.5 169.4,4.5 169.67,4.76 169.67,6.92 R721.2 169.67,7.85 169.67,8.4 169.2,8.86 U153.6
MCAN16_RX: length 192.1
  L3-SIGNAL1 w0.089: v2(93.38,86.46) 93.76,86.46 96.88,83.34 96.88,82.3 100.5,78.69 102.32,78.69 102.4,78.77 102.91,78.77 105.01,78.77 105.03,78.78 105.03,78.78 105.64,79.39 107.32,79.39 107.47,79.53 108.04,79.53 108.22,79.71 108.22,79.86 108.68,80.33 108.84,80.33 109.02,80.51 109.02,80.66 109.49,81.13 110.01,81.13 v3(110.32,81.43)
  L14-SIGNAL6 w0.089: v2(93.38,86.46) 93.38,85.34 89.8,81.76 89.8,79.96 89.34,79.5 82.1,79.5 81.14,78.54 81.14,75.28 80.67,74.81 80.67,73.63 80.03,72.99 78.75,71.7 77.46,71.7 74.39,68.64 74.39,44.11 78.29,40.21 78.29,38.78 81.12,35.94 81.12,35.18 82.27,34.03 82.27,26.8 86.87,22.2 105.01,22.2 105.39,22.58 106.13,22.58 108.16,24.61 108.16,25.46 108.99,26.29 109.6,26.29 114.38,21.5 114.55,21.5 131.02,21.5 131.66,20.86 137.8,20.86 138.79,21.85 163.42,21.85 v2(167.93,17.34)
  vias: v1(110.32,81.43)
MCAN16_STB: length 2.7
  TOP w0.127: U153.8 171.74,10.39 172.05,10.7 R710.2
MCAN16_T: length 4.2
  TOP w0.127: C542.1 v2(171.31,7.38)
  L14-SIGNAL6 w0.089: v2(168.36,7.38) v2(171.31,7.38)
MCAN16_TX: length 190.4
  TOP w0.127: U153.1 v2(171.74,15.95)
  L3-SIGNAL1 w0.089: v3(110.32,73.43) v5(110.09,73.15)
  L4-GND2 w0.102: v5(110.09,73.15) v6(109.78,72.85)
  L5-SIGNAL2 w0.102: v6(109.78,72.85) 109.33,72.85 109.18,72.7 99.91,72.7 99.52,73.08 98.05,73.08 95.79,75.34 91.83,75.34 90.84,76.33 87.38,76.33 v7(86.84,76.87)
  L13-GND5 w0.102: v7(86.84,76.87) v9(86.37,76.87)
  L14-SIGNAL6 w0.089: v9(86.37,76.87) 85.73,77.51 85.73,78.16 84.97,78.92 81.97,78.92 81.39,78.34 81.39,75.24 80.88,74.73 80.88,73.55 78.81,71.48 77.51,71.48 74.6,68.56 74.6,44.29 78.95,39.93 79.82,39.93 82.53,37.22 82.53,26.83 86.96,22.4 102.52,22.4 103.39,23.27 105.28,23.27 105.97,23.95 106.84,23.95 107.73,24.84 107.73,25.39 108.96,26.62 109.55,26.62 114.47,21.71 132.52,21.71 132.89,22.08 165.61,22.08 v2(171.74,15.95)
  vias: v1(110.32,73.43)
MCASP0_ACLKX: length 52.1
  TOP w0.127: v2(46.19,36.15) 46.44,35.9 U112.11 ; U154.36 53.67,8.99 v2(55,10.32) ; U154.7 v2(39.81,11.99)
  L14-SIGNAL6 w0.089: v2(55,10.32) 53.99,9.31 40.77,9.31 39.81,10.27 v2(39.81,11.99) 39.81,14.15 40.81,15.15 40.81,24.98 40.78,25 40.78,28.43 45.92,33.57 46.24,33.57 46.61,33.94 46.61,35.73 v2(46.19,36.15)
MCASP0_ACLKX/MCAN5_TX: length 72.7
  TOP w0.127: U112.9 47.69,37.2 v2(47.36,36.87) ; U50.53 45.52,96.08 v2(45.77,96.33)
  L12-SIGNAL5 w0.102: v2(45.77,96.33) 44.89,95.45 44.89,88.57 42.2,85.88 42.2,80.52 42.39,80.33 42.39,75.73 43.09,75.03 43.09,72.41 40.46,69.78 40.46,55.24 47.59,48.11 50.28,48.11 51,47.39 51,40.51 v2(47.36,36.87)
MCASP0_AFSX: length 50.7
  TOP w0.127: U112.14 47.33,33.95 47.16,34.12 v2(46.19,34.12) ; U154.6 39.7,12.49 39.05,11.84 v2(38.79,11.84) ; U154.35 53.4,8.49 53.53,8.62 54.01,8.62 v2(54.34,8.95)
  L14-SIGNAL6 w0.089: v2(46.19,34.12) 40.58,28.51 40.58,24.92 40.61,24.89 40.61,15.37 39.36,14.12 39.36,12.55 38.79,11.99 v2(38.79,11.84) 38.79,9.46 39.23,9.02 54.27,9.02 v2(54.34,8.95)
MCASP0_AFSX/MCAN5_RX: length 76
  TOP w0.127: U50.51 45.52,97.08 v2(45.77,97.33) ; v2(47.36,34.92) 47.69,35.25 U112.12
  L12-SIGNAL5 w0.102: v2(45.77,97.33) 44.66,96.22 44.66,88.66 41.98,85.97 41.98,80.43 42.17,80.24 42.17,75.53 42.87,74.84 42.87,72.65 40.24,70.03 40.24,55.14 47.49,47.89 50.18,47.89 50.78,47.29 50.78,40.9 46.93,37.05 46.93,35.36 v2(47.36,34.92)
MCASP0_AXR3: length 28.8
  TOP w0.127: v2(55.69,33.62) 55.37,33.3 U112.2 ; U154.37 53.48,9.49 v2(53.73,9.74)
  L14-SIGNAL6 w0.089: v2(53.73,9.74) 53.73,9.96 54.57,10.8 55.91,10.8 56.27,11.16 56.27,32.28 55.69,32.85 v2(55.69,33.62)
MCASP0_AXR3/MCAN3_TX: length 58.2
  TOP w0.127: v2(55.69,34.92) 55.37,34.6 U112.4 ; U58.40 45.3,85.23 45.58,85.5 46.13,85.5 v2(46.59,85.05)
  L12-SIGNAL5 w0.102: v2(46.59,85.05) 47.3,84.34 47.3,53.16 52.66,47.79 52.66,37.14 54.67,35.14 55.48,35.14 v2(55.69,34.92)
MCASP0_AXR4: length 53.2
  TOP w0.127: v2(58.53,33.5) 58.85,33.82 U108.2
  L14-SIGNAL6 w0.089: v2(37.23,11.21) 35.76,12.68 35.76,32.2 41.56,38.01 50.17,38.01 51.12,37.06 58.4,37.06 59.6,35.86 59.6,34.33 58.77,33.5 v2(58.53,33.5)
MCASP0_AXR4/MCAN3_RX: length 62
  TOP w0.127: U58.37 45.66,86.73 45.86,86.54 v2(45.88,86.54) ; U108.4 60.15,35.9 v2(59.83,36.23)
  L12-SIGNAL5 w0.102: v2(59.83,36.23) 59.14,36.91 54.03,36.91 52.89,38.06 52.89,47.88 47.52,53.25 47.52,84.73 45.88,86.37 v2(45.88,86.54)
MCASP0_AXR4_R: length 3.1
  TOP w0.127: R705.1 39.75,11.21 40.03,11.49 U154.8
MCASP4_AXR1/TRC_DATA16_MUX: length 82.7
  TOP w0.127: v2(53.27,106.83) 53.02,106.58 U50.25
  L3-SIGNAL1 w0.089: v5(86,79.37) 86.25,79.62 86.25,80.4 86,80.65 85.68,80.65 83.45,82.88 79.51,82.88 78.62,83.77 76.21,83.77 70.67,89.31 66.78,89.31 64.09,92 60.21,92 59.55,92.66 v2(59.55,98.92) ; v3(111.12,73.43) v5(110.89,73.15)
  L4-GND2 w0.102: v6(86.24,79.15) 86.23,79.14 v5(86,79.37) ; v5(110.89,73.15) v6(110.58,72.85)
  L5-SIGNAL2 w0.102: v2(53.27,106.83) 54,107.56 56.31,107.56 56.93,106.94 56.93,105.69 59.55,103.07 v2(59.55,98.92) ; v6(86.24,79.15) 86.72,78.66 86.72,77.57 87.46,76.84 90.86,76.84 92.11,75.59 95.94,75.59 97.34,74.19 99.68,74.19 100.87,73 109.03,73 109.25,73.23 110.2,73.23 v6(110.58,72.85)
  vias: v1(111.12,73.43)
MCASP4_AXR3/TRC_DATA5_MUX: length 87.5
  TOP w0.127: U50.27 53.02,107.58 v2(53.27,107.83)
  L3-SIGNAL1 w0.089: v3(109.52,74.23) 109.02,73.73 107.73,73.73 107.55,73.56 104.48,73.56 101.87,70.95 98.24,70.95 90.94,78.25 90.94,79.35 v5(90.56,79.73)
  L4-GND2 w0.102: v5(90.56,79.73) v6(90.33,79.97)
  L5-SIGNAL2 w0.102: v6(90.33,79.97) 90.33,80.54 91.04,81.26 91.04,83.87 88.91,86 88.6,86 87.64,86.97 87.64,87.55 87.28,87.91 87.28,89.96 84.66,92.58 71.65,92.58 71.42,92.35 56.33,92.35 54.16,94.52 54.16,103.66 52.86,104.95 52.86,107.42 v2(53.27,107.83)
  vias: v1(109.52,74.23)
MCU_0V85_IN+: length 4.8
  TOP w0.127: R393.1 191.54,78.08 191.65,78.19 C263.2 192.44,78.4 U60.10 194.86,78.4 U61.D3
MCU_0V85_IN-: length 6.3
  TOP w0.127: U60.9 192.9,78.9 192.69,79.11 ; 192.69,79.11 C263.1 191.61,79.11 191.5,79.22 R388.1 ; 192.69,79.11 192.98,79.4 U60.8 194.82,79.4 195.02,79.6 195.26,79.6 ; 195.26,79.6 U61.D2 ; 195.26,79.6 U61.D1
MCU_1V8+: length 4.8
  TOP w0.127: U119.D3 173.9,34.98 U118.10 173.9,37.02 173.69,37.23 C389.2 173.69,38.18 173.58,38.3 R572.1
MCU_1V8-: length 6.3
  TOP w0.127: 174.61,37.15 174.9,36.86 U118.8 174.9,34.98 175.1,34.78 175.1,34.58 ; 174.61,37.15 C389.1 174.61,38.22 174.72,38.34 R573.1 ; 174.61,37.15 174.4,36.94 U118.9 ; 175.1,34.58 U119.D2 ; 175.1,34.58 U119.D1
MCU_ADC0_AIN0: length 137.9
  L3-SIGNAL1 w0.089: v2(21.18,50.99) 30.68,50.99 32.97,53.29 32.97,53.87 46.44,67.34 46.44,69.51 50.65,73.72 69.31,73.72 71.1,71.93 71.66,71.93 73.21,70.38 76.24,70.38 77.52,69.1 77.52,66.26 78.53,65.24 78.53,64.56 80.4,62.69 88.45,62.69 91.56,59.58 107.94,59.58 109.64,61.28 110.67,61.28 111.99,62.59 111.99,65.32 112.85,66.18 112.85,67.39 113.52,68.06 113.64,68.06 114.16,68.58 114.16,69.77 113.52,70.41 113.52,71.83 v3(113.52,71.83)
  BOTTOM w0.127: J27.4 9.04,53.69 9.04,51.69 10.04,50.68 20.97,50.68 21.18,50.89 v2(21.18,50.99)
  vias: v1(113.52,71.83)
MCU_ADC0_AIN1: length 132.4
  L3-SIGNAL1 w0.089: v5(109.84,64.09) 109.81,64.09 109.81,63.01 108.51,61.71 106.3,61.71 105.51,62.5 90.29,62.5 88.11,64.68 82.64,64.68 80.59,66.73 78.85,66.73 78.59,66.99 78.59,70.63 77.73,71.48 73.63,71.48 72.5,72.61 72.5,72.87 71.59,73.79 70.93,73.79 69.81,74.91 45.86,74.91 38.75,67.8 38.75,63.86 36.96,62.07 36.09,62.07 32.96,58.95 30.67,58.95 29.7,57.98 13.32,57.98 11.7,56.36 11.7,53.37 J27.5 ; v3(114.32,72.63) v5(114.09,72.35)
  L4-GND2 w0.102: v5(114.09,72.35) v6(113.78,72.05) ; v6(110.07,64.31) 109.85,64.09 v5(109.84,64.09)
  L5-SIGNAL2 w0.102: v6(113.78,72.05) 113.52,71.79 113.52,69.29 112.3,68.07 112.3,66.54 v6(110.07,64.31)
  vias: v1(114.32,72.63)
MCU_ADC0_AIN2: length 122.7
  L3-SIGNAL1 w0.089: v2(22.54,57.36) 29.69,57.36 30.85,58.52 33.14,58.52 36.27,61.65 37.14,61.65 39.18,63.69 39.18,66.07 41.97,68.85 43.31,68.85 44.66,70.21 45.17,70.21 49.39,74.42 69.51,74.42 71.37,72.57 71.94,72.57 73.46,71.05 77.55,71.05 78.16,70.44 78.16,66.81 78.67,66.3 79.91,66.3 80.83,65.38 80.83,64.9 82.38,63.35 88.83,63.35 90.11,62.07 105.1,62.07 105.88,61.28 108.68,61.28 111.04,63.64 v5(111.04,63.91) ; v3(115.92,72.63) v5(115.69,72.35)
  L4-GND2 w0.102: v5(115.69,72.35) v6(115.38,72.05) ; v6(111.27,64.15) 111.28,64.15 v5(111.04,63.91)
  L5-SIGNAL2 w0.102: v6(111.27,64.15) 112.76,65.64 112.76,67.85 115.02,70.11 115.02,71.69 v6(115.38,72.05)
  BOTTOM w0.127: v2(22.54,57.36) 21.62,56.44 21.62,53.57 J27.11
  vias: v1(115.92,72.63)
MCU_ADC0_AIN3: length 128.8
  TOP w0.127: U59.A28 111.91,68.63 v2(111.52,68.23)
  L3-SIGNAL1 w0.089: v2(14.89,58.43) 15.57,59.11 24.75,59.11 24.99,58.87 27.25,58.87 28.1,59.72 31.73,59.72 31.93,59.52 33.23,59.52 36,62.29 36.88,62.29 38.54,63.95 38.54,67.88 45.89,75.24 55.33,75.24 56.87,76.78 70.61,76.78 72.94,74.45 72.94,73.68 73.06,73.55 74.92,71.69 77.82,71.69 78.8,70.71 78.8,68.03 79.42,67.41 80.2,67.41 82.68,64.93 88.19,64.93 90.41,62.71 105.73,62.71 106.51,61.92 108.42,61.92 109.5,63.01 109.5,66.21 111.52,68.22 v2(111.52,68.23)
  BOTTOM w0.127: v2(14.89,58.43) 12.26,58.43 11.16,57.33 10.13,57.33 J27.2
MCU_ADC0_AIN4: length 126.3
  L3-SIGNAL1 w0.089: J27.9 19.66,50.49 30.48,50.49 36.15,56.16 36.61,56.16 39.91,59.46 39.91,60.17 46.69,66.95 46.69,69.46 50.74,73.51 69.22,73.51 71.01,71.71 71.57,71.71 73.13,70.16 76.15,70.16 77.3,69.02 77.3,66.17 78.32,65.15 78.32,64.47 80.31,62.47 88.33,62.47 91.45,59.36 108.09,59.36 109.79,61.06 110.76,61.06 113.88,64.18 113.88,67.64 114.36,68.12 114.36,71.08 v3(115.12,71.83)
  vias: v1(115.12,71.83)
MCU_ADC0_AIN5: length 114.3
  L3-SIGNAL1 w0.089: v3(112.72,71.03) 112.72,70.52 113.03,70.21 113.42,70.21 113.95,69.67 113.95,68.64 113.56,68.25 113.06,68.25 112.58,67.76 112.58,66.21 111.64,65.28 111.64,63.58 108.92,60.85 98.93,60.85 98.14,61.64 89.94,61.64 88.65,62.92 80.47,62.92 78.75,64.64 78.75,65.33 77.73,66.35 77.73,69.19 76.33,70.59 73.3,70.59 71.75,72.14 71.19,72.14 69.4,73.94 50.5,73.94 45.45,68.89 45.45,67.54 38.84,60.94 38.84,60.37 37.1,58.62 36.05,58.62 30.98,53.55 26.67,53.55 J27.15
  vias: v1(112.72,71.03)
MCU_ADC0_AIN6: length 122.3
  L3-SIGNAL1 w0.089: J27.6 13.95,56.06 32.51,56.06 40.42,63.97 40.42,65.71 41.97,67.26 43.47,67.26 50.4,74.19 69.44,74.19 71.28,72.35 71.84,72.35 73.36,70.84 76.49,70.84 77.95,69.38 77.95,66.73 78.59,66.09 79.11,66.09 79.89,65.31 79.89,64.83 81.58,63.14 88.74,63.14 90.02,61.86 105.01,61.86 105.8,61.07 108.83,61.07 111.39,63.63 111.39,65.38 112.36,66.36 112.36,68.16 112.84,68.63 v3(113.52,68.63)
  vias: v1(113.52,68.63)
MCU_ADC0_AIN7: length 128.5
  L3-SIGNAL1 w0.089: v2(12.37,56.46) 13.67,57.76 29.79,57.76 30.76,58.73 33.05,58.73 36.17,61.86 37.05,61.86 38.97,63.77 38.97,67.68 45.94,74.65 69.59,74.65 70.69,73.54 71.52,73.54 72.27,72.8 72.27,72.54 73.55,71.27 77.64,71.27 78.37,70.53 78.37,66.9 78.76,66.51 80.5,66.51 82.55,64.46 88.02,64.46 90.2,62.28 105.32,62.28 106.1,61.5 108.6,61.5 110.17,63.07 110.17,64.52 112.15,66.5 112.15,68.87 v3(112.72,69.43)
  BOTTOM w0.127: v2(12.37,56.46) 11.57,55.66 11.57,53.68 J27.3
  vias: v1(112.72,69.43)
MCU_ADC1_AIN0: length 112.7
  L3-SIGNAL1 w0.089: v3(108.72,70.23) 108.72,69.62 108.14,69.04 108.14,65.55 106.58,63.99 99.07,63.99 97.56,65.51 89.55,65.51 83.62,71.44 81.89,71.44 79.69,73.64 78.54,73.64 76.03,76.15 76.03,76.94 75.12,77.85 75.12,78.13 72.87,80.38 70.96,80.38 69.7,79.11 55.5,79.11 52.59,76.2 45.65,76.2 37.57,68.13 37.57,67.48 33.1,63.01 31.51,63.01 31.22,62.72 31.22,62.27 31.99,61.5 v2(32.39,61.5)
  L14-SIGNAL6 w0.089: v2(32.39,61.5) 32.31,61.58 32.19,61.58 32.07,61.46 32.07,61.45 31.82,61.21 31.81,61.21 29.45,58.84 29.45,53.79 J27.17
  BOTTOM w0.127: v2(32.39,61.5) 34.11,61.5 J56.83
  vias: v1(108.72,70.23)
MCU_ADC1_AIN1: length 109.5
  L3-SIGNAL1 w0.089: v3(107.92,69.43) 107.92,65.63 106.49,64.2 100.14,64.2 98.59,65.76 89.6,65.76 83.4,71.96 83.4,72.09 82.96,72.53 81.17,72.53 79.81,73.89 78.59,73.89 76.31,76.17 76.31,77.84 73.56,80.59 70.82,80.59 69.61,79.38 55.41,79.38 52.46,76.43 45.58,76.43 37.21,68.06 37.02,68.06 33.31,64.34 33.31,63.71 32.82,63.22 31.42,63.22 31.01,62.81 31.01,61.87 v2(31.38,61.5)
  L14-SIGNAL6 w0.089: J27.18 29.25,56.12 29.25,59.37 v2(31.38,61.5)
  BOTTOM w0.127: J56.85 32.92,62.13 32,62.13 v2(31.38,61.5)
  vias: v1(107.92,69.43)
MCU_ADC1_AIN2: length 98.6
  L3-SIGNAL1 w0.089: v2(32.64,62.55) 33.02,62.55 37.79,67.32 37.79,68.04 45.72,75.97 52.76,75.97 55.02,78.23 74.4,78.23 74.66,77.97 74.66,77.57 75.52,76.71 75.52,74.4 76.26,73.66 76.26,73.04 76.75,72.55 78.8,72.55 82.36,68.99 82.36,68.82 83.48,67.69 86.76,67.69 90.89,63.56 108.19,63.56 108.83,64.21 108.83,67.19 109.52,67.88 v3(109.52,69.43)
  BOTTOM w0.127: v2(32.64,62.55) 34.16,62.55 J56.87
  vias: v1(109.52,69.43)
MCU_ADC1_AIN3: length 101
  TOP w0.127: U59.B29 111.11,69.43 v2(110.72,69.03)
  L3-SIGNAL1 w0.089: v2(31.62,62.55) 32.02,62.15 33,62.15 38.01,67.16 38.01,67.95 45.74,75.69 54.92,75.69 56.44,77.2 70.78,77.2 73.36,74.62 73.36,73.86 75.1,72.12 78,72.12 81.04,69.07 81.04,68.14 82.71,66.47 87.38,66.47 90.72,63.14 108.36,63.14 109.29,64.06 109.29,66.29 111.08,68.08 111.08,68.67 v2(110.72,69.03)
  BOTTOM w0.127: J56.89 32.92,63.13 32.2,63.13 v2(31.62,62.55)
MCU_ADC1_AIN4: length 98.6
  L3-SIGNAL1 w0.089: v3(109.52,71.03) 109.09,71.03 107.61,69.56 107.61,65.63 106.4,64.42 100.29,64.42 98.71,65.99 89.67,65.99 83.61,72.05 83.61,72.18 83.02,72.77 81.23,72.77 79.86,74.14 78.64,74.14 76.54,76.24 76.54,77.92 73.65,80.81 70.73,80.81 70.48,80.56 67.61,80.56 66.65,79.59 55.24,79.59 52.31,76.66 45.5,76.66 37.12,68.27 36.94,68.27 33.07,64.41 33.07,64.04 33.06,64.03 v2(32.66,63.63)
  BOTTOM w0.127: J56.91 v2(32.66,63.63)
  vias: v1(109.52,71.03)
MCU_ADC1_AIN5: length 51.7
  TOP w0.127: v3(70.84,82.38) 71.27,81.94 R385.2
  L3-SIGNAL1 w0.089: v2(31.65,63.63) 32.24,64.22 32.24,64.87 36.1,68.73 36.97,68.73 45.36,77.11 52.03,77.11 54.44,79.53 54.57,79.53 55.07,80.02 65.09,80.02 67.22,82.14 70.6,82.14 v3(70.84,82.38)
  BOTTOM w0.127: J56.93 32.15,64.13 v2(31.65,63.63)
MCU_ADC1_AIN6: length 51.6
  TOP w0.127: R392.2 73.71,80.96 72.98,81.69 72.4,81.69 v3(71.8,82.29)
  L3-SIGNAL1 w0.089: v3(71.8,82.29) 71.33,81.81 67.22,81.81 65.21,79.81 55.16,79.81 52.23,76.89 45.43,76.89 37.03,68.49 36.52,68.49 v2(32.66,64.63)
  BOTTOM w0.127: J56.95 v2(32.66,64.63)
MCU_ADC1_AIN7: length 48.5
  TOP w0.127: R379.2 69.23,82.7 v3(69.22,82.71)
  L3-SIGNAL1 w0.089: v2(31.65,64.63) 35.97,68.96 36.88,68.96 45.26,77.34 51.95,77.34 55.56,80.95 65.64,80.95 67.4,82.71 v3(69.22,82.71)
  BOTTOM w0.127: J56.97 32.15,65.13 v2(31.65,64.63)
MCU_ADC_EXT_TRIGGER0: length 14.4
  L14-SIGNAL6 w0.089: J27.16 25.45,58.91 28.74,62.21 28.74,63.76 29.92,64.94 29.92,66.21 v2(30.26,66.54)
  BOTTOM w0.127: R1099.2 v2(30.26,66.54)
MCU_ADC_EXT_TRIGGER1: length 2.2
  BOTTOM w0.127: R1098.2 32.69,66.54 32.77,66.63 J56.103
MCU_BOOTMODE00: length 3.5
  TOP w0.127: TP142.1 R419.1 R420.2 R414.2
MCU_BOOTMODE01: length 3.7
  TOP w0.127: R422.1 R423.2 TP146.1 R428.2
MCU_BOOTMODE02: length 21.7
  TOP w0.127: v2(58.42,59.29) SW7.1
  L5-SIGNAL2 w0.102: v2(58.42,59.29) 58.86,59.72 58.86,60.79 55.68,63.96 v2(54.24,63.96)
  L14-SIGNAL6 w0.089: v2(54.24,63.96) 54.67,63.54 54.67,54.34 v2(54.37,54.05)
  BOTTOM w0.127: U233.3 v2(54.24,63.96) ; U243.1 v2(54.37,54.05)
MCU_BOOTMODE03: length 21.8
  TOP w0.127: v2(58.42,60.56) SW7.2
  L5-SIGNAL2 w0.102: v2(58.42,60.56) 56.04,62.95 v2(54.24,62.95)
  L14-SIGNAL6 w0.089: v2(54.37,53.03) 53.94,53.46 53.94,54.88 54.42,55.35 54.42,62.77 v2(54.24,62.95)
  BOTTOM w0.127: U233.4 53.74,63.45 v2(54.24,62.95) ; v2(54.37,53.03) 53.87,53.53 U243.2
MCU_BOOTMODE04: length 22.5
  TOP w0.127: v2(58.42,61.83) SW7.3
  L5-SIGNAL2 w0.102: v2(53.24,63.96) 53.24,64.47 53.44,64.68 56.45,64.68 57.59,63.53 58.6,63.53 58.86,63.28 58.86,62.26 v2(58.42,61.83)
  L14-SIGNAL6 w0.089: v2(53.24,63.96) 53.67,63.54 53.67,61.19 53.48,61.01 53.48,55.82 53.37,55.71 v2(53.37,54.05)
  BOTTOM w0.127: U243.3 v2(53.37,54.05) ; U233.5 v2(53.24,63.96)
MCU_BOOTMODE05: length 23.3
  TOP w0.127: v2(58.42,63.1) SW7.4
  L5-SIGNAL2 w0.102: v2(53.24,62.95) 53.67,63.38 53.67,64.21 53.85,64.39 55.9,64.39 57.19,63.1 v2(58.42,63.1)
  L14-SIGNAL6 w0.089: v2(53.37,53.03) 52.94,53.46 52.94,55.61 53.24,55.9 v2(53.24,62.95)
  BOTTOM w0.127: U233.6 52.74,63.45 v2(53.24,62.95) ; U243.4 52.87,53.53 v2(53.37,53.03)
MCU_BOOTMODE06: length 21.1
  TOP w0.127: v2(58.42,64.37) SW7.5
  L5-SIGNAL2 w0.102: v2(58.42,64.37) 57.08,64.37 56.55,64.9 53.18,64.9 v2(52.24,63.96)
  L14-SIGNAL6 w0.089: v2(52.37,54.05) 52.09,54.32 52.09,58.98 52.67,59.55 52.67,63.54 v2(52.24,63.96)
  BOTTOM w0.127: U243.5 v2(52.37,54.05) ; U233.7 v2(52.24,63.96)
MCU_BOOTMODE07: length 25.2
  TOP w0.127: v2(58.42,65.64) SW7.6
  L5-SIGNAL2 w0.102: v2(52.24,62.95) 51.81,63.38 51.81,64.14 52.06,64.39 52.8,65.13 56.95,65.13 57.48,65.65 58.41,65.65 v2(58.42,65.64)
  L14-SIGNAL6 w0.089: v2(52.37,53.03) 51.79,53.61 51.79,59.62 52.24,60.07 v2(52.24,62.95)
  BOTTOM w0.127: v2(52.37,53.03) 51.87,53.53 U243.6 ; U233.8 51.74,63.45 v2(52.24,62.95)
MCU_BOOTMODE08: length 22.9
  TOP w0.127: v2(58.42,66.91) SW7.7
  L5-SIGNAL2 w0.102: v2(58.42,66.91) 57.68,66.91 56.13,65.36 52.64,65.36 v2(51.24,63.96)
  L14-SIGNAL6 w0.089: v2(51.24,63.96) 51.67,63.54 51.67,60.46 50.78,59.57 50.78,54.63 v2(51.37,54.05)
  BOTTOM w0.127: U243.7 v2(51.37,54.05) ; U233.9 v2(51.24,63.96)
MCU_BOOTMODE09: length 27.9
  TOP w0.127: v2(58.42,68.18) SW7.8
  L5-SIGNAL2 w0.102: v2(51.24,62.95) 50.81,63.38 50.81,64.14 51.98,65.31 51.98,66.02 52.32,66.36 55.92,66.36 57.74,68.18 v2(58.42,68.18)
  L14-SIGNAL6 w0.089: v2(51.37,53.03) 50.5,53.9 50.5,62.21 v2(51.24,62.95)
  BOTTOM w0.127: U243.8 50.87,53.53 v2(51.37,53.03) ; v2(51.24,62.95) 50.74,63.45 U233.10
MCU_CAN0_STB: length 266.6
  TOP w0.127: U149.8 132.52,10.39 132.83,10.7 R706.1 134.03,11.44 134.85,12.26 135.8,12.26 136.41,12.87 v2(136.41,17.55)
  L3-SIGNAL1 w0.089: v3(123.12,71.83) v5(123.39,71.6) ; v2(57.06,72.04) 56.44,72.66 54.78,72.66 53.81,71.68 50.76,71.68 50.55,71.48 49.85,71.48 49.56,71.19 49.56,70.86 50.24,70.18 52.28,70.18 56.37,66.09 57.26,66.09 58.24,65.11 61.33,65.11 64.69,61.75 69.83,61.75 75.55,56.03 103.58,56.03 105.41,54.2 108.14,54.2 v5(109.08,53.26)
  L4-GND2 w0.102: v5(109.08,53.26) v6(109.41,53.26) ; v5(123.39,71.6) v6(123.09,71.3)
  L5-SIGNAL2 w0.102: v6(123.09,71.3) 122.64,70.85 122.64,70.36 122.08,69.8 122.08,59.37 115.63,52.92 109.75,52.92 v6(109.41,53.26) ; v2(57.06,72.04) 55.79,73.3 49.64,73.3 47.73,71.39 47.73,60.16 47.73,59.97 46.32,58.57 46.32,49.32 46.34,49.31 46.34,47.22 44.67,45.55 44.67,38.31 44.8,38.18 49.91,33.07 65.09,33.07 66.21,31.95 67.37,30.79 70.98,30.79 72.14,31.95 83.25,31.95 84.64,30.56 92.41,30.56 92.82,30.15 99.75,30.15 100.41,29.49 104,29.49 104.66,28.83 107.68,28.83 110.42,26.09 119.16,26.09 127.85,17.4 127.85,16.89 129.73,15.01 133.18,15.01 133.74,15.57 133.74,16.99 134.3,17.55 v2(136.41,17.55)
  BOTTOM w0.127: R1074.1 57.88,71.21 v2(57.06,72.04)
  vias: v1(123.12,71.83)
