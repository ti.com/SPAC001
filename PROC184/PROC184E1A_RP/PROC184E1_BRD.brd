# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCU_CAN1_STB: length 257.4
  TOP w0.127: v2(145.64,18.07) 146.62,17.09 146.62,12.97 145.52,11.86 143.96,11.86 143.84,11.73 R707.1 142.64,10.7 142.32,10.39 U150.8
  L3-SIGNAL1 w0.089: v3(119.92,71.03) v5(119.69,70.75) ; v2(53.52,72.14) 54.24,72.87 65.72,72.87 67.42,71.17 67.42,65.93 76.15,57.2 105.11,57.2 106.05,56.26 v5(109.81,56.26)
  L4-GND2 w0.102: v5(119.69,70.75) v6(119.38,70.45) ; v5(109.81,56.26) v6(110.14,56.26)
  L5-SIGNAL2 w0.102: v2(53.52,72.14) 52.71,72.95 49.72,72.95 48.61,71.84 48.61,69.04 47.95,68.39 47.95,60.25 47.95,59.87 46.57,58.48 46.57,47.12 44.9,45.46 44.9,38.41 49.09,34.21 64.32,34.21 66.36,32.17 83.39,32.17 84.78,30.79 92.59,30.79 92.89,30.48 99.78,30.48 100.24,30.02 104,30.02 104.8,29.22 107.61,29.22 110.52,26.31 119.26,26.31 128.15,17.42 128.15,17.17 129.88,15.44 132.95,15.44 133.38,15.88 133.38,17.27 134.19,18.07 v2(145.64,18.07) ; v6(119.38,70.45) 119.38,59.58 115.02,55.22 112.86,55.22 111.82,56.26 v6(110.14,56.26)
  BOTTOM w0.127: v2(53.52,72.14) 52.87,72.14 52.63,71.9 R1067.1
  vias: v1(119.92,71.03)
MCU_ENET_RSTZ: length 21.9
  TOP w0.127: U111.4 v2(91.44,33.92)
  L12-SIGNAL5 w0.102: v2(104.8,25.14) 104.8,26.78 103.87,27.71 97.65,27.71 95.9,29.46 94.14,29.46 91.44,32.16 v2(91.44,33.92)
  BOTTOM w0.127: U261.43 102.86,24.77 103.49,24.77 103.64,24.62 104.29,24.62 v2(104.8,25.14)
MCU_I2C0_SCL: length 254.8
  TOP w0.127: U68.32 180.68,72.32 v2(181.03,72.68) ; U55.1 101.94,86.03 101.94,85.07 101.2,84.34 96.68,84.34 v2(95.18,82.84) ; U82.1 194.59,101.72 v2(194.78,101.9)
  L3-SIGNAL1 w0.089: v2(109.61,58.24) 112.1,58.24 114.31,60.45 114.31,61.73 114.94,62.36 114.94,69.57 116.41,71.03 v3(116.72,71.03)
  L7-SIGNAL3 w0.109: v2(97.37,74.86) 97.37,65.59 96.6,64.83 96.6,60.66 101.59,55.68 111.95,55.68 116.11,59.84 133.41,59.84 136.69,63.12 152.08,63.12 152.41,62.79 155.38,62.79 160.64,68.05 160.64,73.08 163.94,76.38 163.94,77.14 164.91,78.11 167.57,78.11 168.18,77.5 172.6,77.5 172.93,77.83 178.04,77.83 179.84,76.02 179.84,73.87 v2(181.03,72.68)
  L14-SIGNAL6 w0.089: v2(95.18,82.84) 97.37,80.65 v2(97.37,74.86) 94.53,74.86 92.36,72.7 92.36,69.27 93.1,68.53 93.1,67.64 97.63,63.11 104.75,63.11 v2(109.61,58.24) ; v2(191.17,49.41) 190.13,50.44 188.65,50.44 183.27,55.83 183.27,69.05 182.24,70.08 182.24,71.47 v2(181.03,72.68) 182.77,72.68 183.78,73.69 183.78,78.89 187.08,82.19 187.08,92.63 190.79,96.35 190.79,100.74 191.96,101.9 v2(194.78,101.9)
  BOTTOM w0.127: v2(191.17,49.41) 191.17,49.06 192.11,48.11 U250.6
  vias: v1(116.72,71.03)
MCU_I2C0_SDA: length 261.6
  TOP w0.127: U68.33 179.4,72.82 v2(179.31,72.91) ; U82.6 v2(195.97,101) ; U55.6 99.32,85.07 98.96,84.71 96.04,84.71 v2(94.19,82.86)
  L3-SIGNAL1 w0.089: v2(106.15,51.54) 106.56,51.94 111.74,51.94 117.52,57.72 v3(117.52,68.63)
  L7-SIGNAL3 w0.109: v2(179.31,72.91) 179.31,75.59 178.14,76.76 169.63,76.76 169.38,77.01 168.16,77.01 167.42,77.75 165.06,77.75 164.32,77.01 164.32,76.25 160.94,72.87 160.94,65.15 156.55,60.76 134.78,60.76 133.6,59.58 116.31,59.58 111.97,55.25 101.51,55.25 90.48,66.27 v2(90.48,69.27)
  L14-SIGNAL6 w0.089: v2(106.15,51.54) 105.16,52.53 104.05,52.53 90.48,66.09 v2(90.48,69.27) 90.93,69.72 90.93,71.97 94.19,75.24 v2(94.19,82.86) ; v2(195.97,101) 195.97,101.63 195.26,102.34 191.78,102.34 190.56,101.12 190.56,96.52 186.85,92.81 186.85,82.52 182.81,78.49 182.81,73.74 182.46,73.38 179.56,73.38 179.31,73.13 v2(179.31,72.91) 180.19,72.91 181.89,71.21 181.89,70.09 183.04,68.94 183.04,55.52 188.66,49.9 189.66,49.9 v2(190.15,49.41)
  BOTTOM w0.127: U250.5 191.46,47.97 191.02,48.42 190.48,48.42 190.15,48.75 v2(190.15,49.41)
  vias: v1(117.52,68.63)
MCU_I3C0_SCL: length 146.2
  L3-SIGNAL1 w0.089: v2(17.17,76.92) 16.74,77.34 16.74,78.24 17.18,78.68 25.85,78.68 26.88,77.64 33.83,77.64 35.21,76.26 40.77,76.26 41.61,75.42 41.61,74.68 v2(41.37,74.44) ; v3(119.12,69.43) 118.81,69.13 118.81,68.44 119.03,68.22 119.03,57.59 111.56,50.11 109.25,50.11 108.9,49.77 106.24,49.77 v5(101.66,54.35)
  L4-GND2 w0.102: v5(101.66,54.35) v6(101.3,54.35)
  L5-SIGNAL2 w0.102: J25.3 13.4,67.09 14.69,68.38 14.69,75.18 16.42,76.92 v2(17.17,76.92) ; v6(101.3,54.35) 85.96,69.7 81.31,69.7 80.84,70.17 78.58,70.17 77.83,70.92 72.98,70.92 70.44,73.46 65,73.46 64.02,74.44 v2(41.37,74.44)
  BOTTOM w0.127: U228.13 17.93,76.16 v2(17.17,76.92)
  vias: v1(119.12,69.43)
MCU_I3C0_SDA: length 150.7
  L3-SIGNAL1 w0.089: v2(17.17,78.06) 17.8,77.43 33.74,77.43 35.49,75.67 39.63,75.67 v2(40.14,75.17) ; v3(122.32,68.63) 122.3,68.62 122.3,57.2 110.83,45.73 107.21,45.73 v5(99.22,53.72)
  L4-GND2 w0.102: v5(99.22,53.72) v6(98.87,53.72)
  L5-SIGNAL2 w0.102: v2(17.17,78.06) 14.29,75.18 14.29,71 13.01,69.73 J25.2 ; v2(40.14,75.17) 40.14,75.09 41.2,74.03 63.58,74.03 64.51,73.1 70.34,73.1 73.58,69.86 80.64,69.86 81.11,69.39 85.08,69.39 88.17,66.3 88.17,64.41 v6(98.87,53.72)
  BOTTOM w0.127: J25.2 13.39,70.01 R1080.1 ; v2(17.17,78.06) 17.83,77.4 17.83,76.84 18.02,76.66 U228.14
  vias: v1(122.32,68.63)
MCU_I3C0_SDAPULLEN: length 146.7
  TOP w0.127: TP148.1 v2(15.17,69.17)
  L3-SIGNAL1 w0.089: v3(117.52,69.43) 117.2,69.12 117.2,57.96 116.9,57.66 113.04,57.66 112.56,57.18 105.84,57.18 105.32,57.71 77.35,57.71 69.81,65.25 69.81,70.67 67.4,73.08 51.58,73.08 50.25,71.76 49.83,71.76 47.46,69.39 47.46,61.5 43.69,57.73 39.71,57.73 37.75,55.78 36.45,55.78 v2(35.75,55.07)
  L5-SIGNAL2 w0.102: v2(15.17,69.17) 15.17,66.72 25.17,56.72 30.65,56.72 33.95,53.42 35.98,53.42 36.23,53.68 36.23,54.59 v2(35.75,55.07)
  vias: v1(117.52,69.43)
MCU_MCAN0_H: length 8.9
  TOP w0.132: J42.1 133.16,4.19 132.85,4.5 131.05,4.5 130.78,4.76 130.78,6.92 R714.1 130.78,7.85 130.78,8.4 131.25,8.86 U149.7
MCU_MCAN0_L: length 8.9
  TOP w0.132: U149.6 129.98,8.86 130.45,8.4 130.45,7.85 R713.2 130.45,6.92 130.45,4.76 130.18,4.5 128.38,4.5 128.08,4.19 J42.3
MCU_MCAN0_RX: length 82.8
  TOP w0.127: v2(128.71,17.34) 129.18,17.82 133.69,17.82 J33.2
  L3-SIGNAL1 w0.089: v2(107.27,48.44) 111.24,48.44 120.13,57.32 120.13,68.1 120.22,68.19 120.22,69.93 v3(119.92,70.23)
  L5-SIGNAL2 w0.102: v2(128.71,17.34) 128.71,18.32 120.29,26.75 113.9,26.75 111.82,28.83 v2(109.28,28.83)
  L14-SIGNAL6 w0.089: v2(107.27,48.44) 106.26,47.42 106.26,35.33 107.68,33.91 107.68,32.28 109.28,30.68 v2(109.28,28.83)
  vias: v1(119.92,70.23)
MCU_MCAN0_T: length 4.2
  TOP w0.127: C538.1 v2(132.09,7.38)
  L14-SIGNAL6 w0.089: v2(129.14,7.38) v2(132.09,7.38)
MCU_MCAN0_TX: length 81.9
  TOP w0.127: J33.1 133.77,13.88 133.53,14.11 133.53,15.73 133.31,15.95 v2(132.52,15.95) U149.1
  L3-SIGNAL1 w0.089: v3(116.72,71.83) v5(116.49,71.55)
  L4-GND2 w0.102: v5(116.49,71.55) v6(116.18,71.25)
  L5-SIGNAL2 w0.102: v2(132.52,15.95) 132.37,15.95 123.35,24.97 123.35,25.81 122.83,26.33 121.99,26.33 121.01,27.31 116.95,27.31 112.71,31.55 v2(109.53,31.55) ; v2(107.41,58.48) 107.76,58.83 108.66,58.83 115.71,65.87 115.71,70.77 v6(116.18,71.25)
  L14-SIGNAL6 w0.089: v2(109.53,31.55) 108.14,32.94 108.14,33.91 106.64,35.41 106.64,47.17 107.68,48.21 107.68,58.22 v2(107.41,58.48)
  vias: v1(116.72,71.83)
MCU_MCAN1_H: length 8.9
  TOP w0.132: J43.1 142.96,4.19 142.65,4.5 140.85,4.5 140.59,4.76 140.59,6.92 R716.1 140.59,7.85 140.59,8.4 141.05,8.86 U150.7
MCU_MCAN1_L: length 8.9
  TOP w0.132: J43.3 137.88,4.19 138.18,4.5 139.99,4.5 140.25,4.76 140.25,6.92 R715.2 140.25,7.85 140.25,8.4 139.78,8.86 U150.6
MCU_MCAN1_RX: length 124.8
  TOP w0.127: J34.2 143.49,17.82 138.99,17.82 R680.1 137.91,17.34 137.25,16.68 v2(137.25,13.24)
  L3-SIGNAL1 w0.089: v3(118.32,71.03) v5(118.09,70.75)
  L4-GND2 w0.102: v5(118.09,70.75) v6(117.78,70.45)
  L5-SIGNAL2 w0.102: v2(137.25,13.24) 142.28,13.24 144.1,15.06 145.88,15.06 147.28,16.46 147.28,21.41 135.64,33.05 111.76,33.05 111.15,33.66 110.14,33.66 110.02,33.53 v2(106.99,33.53) ; v2(104.91,56.34) 105.4,56.83 114.81,56.83 115.11,56.53 115.57,56.53 115.77,56.73 115.77,62.72 117.78,64.74 v6(117.78,70.45)
  L14-SIGNAL6 w0.089: v2(104.91,56.34) 106.64,54.61 106.64,48.84 105.77,47.98 105.77,34.75 v2(106.99,33.53)
  vias: v1(118.32,71.03)
MCU_MCAN1_T: length 4.2
  TOP w0.127: C539.1 v2(141.89,7.38)
  L14-SIGNAL6 w0.089: v2(138.94,7.38) v2(141.89,7.38)
MCU_MCAN1_TX: length 100.8
  TOP w0.127: U150.1 v2(142.32,16.1) 142.33,16.11 143.03,16.11 143.32,15.82 143.32,14.34 143.78,13.88 J34.1
  L3-SIGNAL1 w0.089: v3(121.52,71.83) v5(121.79,71.6)
  L4-GND2 w0.102: v5(121.79,71.6) v6(121.49,71.3)
  L5-SIGNAL2 w0.102: v2(142.32,16.1) 143.75,17.53 145.83,17.53 146.16,17.86 146.16,22.17 135.54,32.79 111.44,32.79 v2(110.98,33.25) ; v6(121.49,71.3) 121.09,70.9 121.09,59.67 115.49,54.08 111.77,54.08 111.59,54.25 v2(110.88,54.25)
  L14-SIGNAL6 w0.089: v2(110.98,33.25) 110.98,35.08 110.63,35.43 110.63,54 v2(110.88,54.25)
  vias: v1(121.52,71.83)
MCU_MDIO0_MDC: length 73.4
  L3-SIGNAL1 w0.089: v3(124.72,71.83) v5(124.99,71.6)
  L4-GND2 w0.102: v5(124.99,71.6) v7(125.3,71.3)
  L12-SIGNAL5 w0.102: v8(105.93,49.51) 105.93,50.34 106.17,50.58 106.6,50.58 107.58,51.56 108.47,51.56 109.03,51 109.81,51 110.57,51.77 117.67,51.77 127.03,61.13 127.03,71.02 126.35,71.7 125.7,71.7 v7(125.3,71.3)
  L13-GND5 w0.102: v8(105.93,49.51) v9(105.93,49.12)
  L14-SIGNAL6 w0.089: v2(95,23.77) 97.62,26.39 101.97,26.39 104.47,28.89 104.47,30.52 105.22,31.27 105.22,48.24 105.93,48.95 v9(105.93,49.12)
  BOTTOM w0.127: U261.16 95.86,23.77 v2(95,23.77)
  vias: v1(124.72,71.83)
MCU_MDIO0_MDIO: length 81.1
  L3-SIGNAL1 w0.089: v3(123.92,72.63) v5(124.19,72.4)
  L4-GND2 w0.102: v5(124.19,72.4) v7(124.5,72.1)
  L12-SIGNAL5 w0.102: v8(106.28,50.2) 106.57,49.91 107.6,49.91 108.39,50.7 109.91,50.7 110.63,51.41 117.81,51.41 127.39,60.99 127.39,72.24 127.11,72.52 125.61,72.52 125.19,72.1 v7(124.5,72.1)
  L13-GND5 w0.102: v8(106.28,50.2) v9(106.28,50.58)
  L14-SIGNAL6 w0.089: v9(106.28,50.58) 106.28,50.78 105.01,52.05 100.26,52.05 97.54,49.33 97.54,48.39 93.66,44.5 93.66,34.77 92.97,34.09 92.97,25.63 93.27,25.32 93.27,25.21 v2(94.22,24.27)
  BOTTOM w0.127: v2(94.22,24.27) 95.86,24.27 U261.17
  vias: v1(123.92,72.63)
MCU_ONAND_CLK: length 19.2
  TOP w0.127: U245.B2 v2(121.85,36.4) ; v2(130.51,46.16) 130.01,46.66 U241.42
  L3-SIGNAL1 w0.089: v2(121.85,36.4) 122.14,36.12 123.58,36.12 124.37,36.91 126.78,36.91 129.12,39.24 129.12,45.39 129.4,45.67 129.73,45.67 130.02,45.67 v2(130.51,46.16)
MCU_ONAND_CS0#: length 19
  TOP w0.127: U241.37 v3(127.79,43.35) ; v2(121.85,37.4) 121.35,37.9 U245.C2
  L3-SIGNAL1 w0.089: v2(121.85,37.4) 122.3,36.96 123.25,36.96 123.78,37.49 123.78,38.13 124.06,38.4 124.29,38.4 124.42,38.53 124.42,38.97 124.51,39.06 124.72,39.06 124.81,38.97 124.81,38.7 124.9,38.61 125.41,38.61 125.72,38.92 126.02,38.92 126.14,39.05 126.14,39.75 126.27,39.88 126.88,39.88 127.06,39.7 127.06,39.04 127.18,38.92 127.85,38.92 128.08,39.15 128.08,41.23 128.16,41.32 128.63,41.32 128.72,41.41 128.72,41.62 128.63,41.71 127.71,41.71 127.62,41.8 127.62,41.99 127.73,42.1 128.63,42.1 128.72,42.19 128.72,42.41 128.63,42.5 128.16,42.5 128.08,42.59 128.08,43.07 v3(127.79,43.35)
MCU_ONAND_D0: length 19
  TOP w0.127: U245.D3 v2(120.85,38.4) ; U241.33 v3(125.79,43.35)
  L3-SIGNAL1 w0.089: v2(120.85,38.4) 121.26,38.81 122.87,38.81 123.42,39.37 123.42,40.21 123.85,40.64 124.01,40.64 124.16,40.49 124.32,40.49 124.44,40.61 124.44,40.77 124.29,40.92 124.29,41.08 124.65,41.43 125.59,41.43 126.37,42.22 126.37,46.83 126.12,47.08 125.79,47.08 125.51,46.79 125.51,43.64 v3(125.79,43.35)
MCU_ONAND_D1: length 19.4
  TOP w0.127: U241.35 v3(126.79,43.35) ; U245.D2 v2(121.85,38.4)
  L3-SIGNAL1 w0.089: v2(121.85,38.4) 122.31,37.95 123.17,37.95 123.38,38.15 123.38,38.8 125.56,40.99 126.29,40.99 127.29,41.99 127.29,43.51 128.33,44.55 128.33,46.67 127.96,47.04 127.31,47.04 126.79,46.52 v3(126.79,43.35)
MCU_ONAND_D2/WP: length 19.1
  TOP w0.127: U241.26 122.29,42.94 v3(121.79,42.44) ; U245.C4 v2(118.85,37.4)
  L3-SIGNAL1 w0.089: v3(121.79,42.44) 121.79,41.6 121.28,41.09 121.28,40.17 120.86,39.75 120.48,39.75 120.02,39.29 118.73,39.29 118.35,38.91 118.35,35.93 118.44,35.85 119.06,35.85 119.36,35.54 119.36,35.27 119.86,34.77 120.35,34.77 120.53,34.95 120.53,35.17 120.39,35.3 120.03,35.3 119.9,35.44 119.9,35.64 120.03,35.77 120.39,35.77 120.53,35.91 120.53,36.61 120.26,36.88 119.38,36.88 v2(118.85,37.4)
MCU_ONAND_D3: length 19.1
  TOP w0.127: U245.D4 v2(119.85,38.4) ; U241.31 v3(124.79,43.35)
  L3-SIGNAL1 w0.089: v3(124.79,43.35) 123.76,44.39 123.76,47 124.09,47.33 124.81,47.33 125.22,46.93 125.22,42.11 124.95,41.84 124.57,41.84 121.82,39.09 120.91,39.09 120.23,38.4 v2(119.85,38.4)
MCU_ONAND_D4: length 19.6
  TOP w0.127: v3(120.79,42.44) 121.29,42.94 U241.24 ; U245.D5 v2(117.85,38.4)
  L3-SIGNAL1 w0.089: v2(117.85,38.4) 117.85,35.47 117.6,35.22 117.2,35.22 116.75,35.68 116.75,36.85 116.84,36.95 117.23,36.95 117.32,37.04 117.32,37.17 117.23,37.26 116.84,37.26 116.75,37.36 116.75,37.49 116.84,37.58 117.23,37.58 117.32,37.67 117.32,37.81 117.23,37.9 116.84,37.9 116.75,37.99 116.75,38.12 116.84,38.22 117.23,38.22 117.32,38.31 117.32,38.44 117.23,38.53 116.84,38.53 116.75,38.63 116.75,38.91 117.74,39.9 120,39.9 120.28,40.18 120.28,41.93 v3(120.79,42.44)
MCU_ONAND_D5: length 18.7
  TOP w0.127: U241.22 120.29,42.94 v3(119.79,42.44) ; v2(119.85,40.4) 120.35,39.9 U245.E3
  L3-SIGNAL1 w0.089: v3(119.79,42.44) 119.79,43.13 121.65,44.98 121.65,46.74 121.33,47.07 119.97,47.07 119.13,46.23 119.13,45.21 117.74,43.82 117.74,42.38 118.17,41.94 119.39,41.94 119.85,41.48 v2(119.85,40.4)
MCU_ONAND_D6: length 19
  TOP w0.127: v2(120.85,40.4) 121.35,39.9 U245.E2 ; U241.20 119.12,45.66 118.62,45.16 v3(118.08,45.16)
  L3-SIGNAL1 w0.089: v3(118.08,45.16) 118.5,45.58 118.5,47.68 118.83,48.01 119.43,48.01 119.52,47.92 119.52,47.67 119.61,47.58 119.74,47.58 119.84,47.67 119.84,47.92 119.93,48.01 120.06,48.01 120.15,47.92 120.15,47.67 120.25,47.58 120.38,47.58 120.47,47.67 120.47,47.92 120.56,48.01 120.7,48.01 120.79,47.92 120.79,47.67 120.88,47.58 121.01,47.58 121.11,47.67 121.11,47.92 121.2,48.01 121.83,48.01 122.03,47.81 122.03,44.78 121.22,43.97 121.22,41.79 120.85,41.43 v2(120.85,40.4)
MCU_ONAND_D7: length 18.7
  TOP w0.127: U241.18 119.19,46.66 119.19,46.65 118.85,46.65 118.5,46.31 v3(118,46.31) ; v2(121.85,40.4) 122.35,39.9 U245.E1
  L3-SIGNAL1 w0.089: v2(121.85,40.4) 122.22,40.77 122.22,44.03 123.33,45.14 123.33,47.04 121.39,48.97 120.28,48.97 119.73,48.42 118.07,48.42 117.64,47.98 117.64,46.59 117.92,46.31 v3(118,46.31)
MCU_ONAND_DS: length 13.2
  TOP w0.127: U241.28 123.29,42.94 v3(122.79,42.44)
  L3-SIGNAL1 w0.089: v3(122.79,42.44) 122.54,42.19 122.54,40.26 121.67,39.4 120.68,39.4 120.24,38.95 119.63,38.95 119.4,38.72 119.4,38.06 119.54,37.92 119.95,37.92 120.99,36.88 v2(120.99,35.42)
  BOTTOM w0.127: R532.2 v2(120.99,35.42)
MCU_OSPI0/ONAND_RESET#: length 28.7
  TOP w0.127: U241.3 v2(127.29,48.51)
  L3-SIGNAL1 w0.089: v3(126.32,72.63) v5(126.59,72.4)
  L4-GND2 w0.102: v5(126.59,72.4) v7(126.9,72.1)
  L7-SIGNAL3 w0.109: v7(126.9,72.1) 126.9,64.55 130.84,60.6 v2(131.07,60.6)
  L12-SIGNAL5 w0.102: v2(131.07,60.6) 128.25,57.79 128.25,49.47 v2(127.29,48.51)
  vias: v1(126.32,72.63)
MCU_OSPI0_CLK: length 19
  TOP w0.127: U241.41 v2(129.59,46.16) ; U246.B2 v2(129.6,36.4)
  L12-SIGNAL5 w0.102: v2(129.59,46.16) 128.87,46.16 128.46,45.74 128.46,44.55 128.91,44.09 132.55,44.09 133.1,43.54 133.1,37.7 132.27,36.86 130.06,36.86 v2(129.6,36.4)
MCU_OSPI0_CS0#: length 14
  TOP w0.127: v2(128.71,43.38) 128.7,43.37 128.42,43.37 128.29,43.49 U241.38 ; U246.C2 v2(129.6,37.4)
  L12-SIGNAL5 w0.102: v2(129.6,37.4) 132.08,37.4 132.77,38.1 132.77,42.11 131.51,43.38 v2(128.71,43.38)
MCU_OSPI0_D0: length 19
  TOP w0.127: U241.34 126.29,42.94 v2(125.79,42.44) ; U246.D3 v2(127.6,39.4)
  L12-SIGNAL5 w0.102: v2(127.6,39.4) 127.6,39.09 128.14,38.55 128.14,37.86 128,37.72 127.25,37.72 127.11,37.58 127.11,37.37 127.25,37.23 128,37.23 128.14,37.09 128.14,36.88 128,36.74 127.25,36.74 127.11,36.6 127.11,36.39 127.25,36.25 128,36.25 128.14,36.11 128.14,35.98 128.28,35.84 129.04,35.84 129.17,35.97 129.17,38.15 128.17,39.15 128.17,39.56 127.76,39.97 127.38,39.97 127.17,40.18 127.17,40.48 125.79,41.86 v2(125.79,42.44)
MCU_OSPI0_D1: length 19
  TOP w0.127: U246.D2 v2(128.6,39.4) ; U241.36 127.29,42.94 v2(126.79,42.44)
  L12-SIGNAL5 w0.102: v2(126.79,42.44) 128.08,41.16 128.08,40.32 128.46,39.94 129.5,39.94 129.6,39.83 129.6,38.9 129.7,38.79 129.94,38.79 130.04,38.9 130.04,40.09 130.39,40.44 132.04,40.44 132.42,40.06 132.42,38.21 132.03,37.82 130.01,37.82 128.6,39.23 v2(128.6,39.4)
MCU_OSPI0_D2: length 19.3
  TOP w0.127: U246.C4 v2(126.6,38.4) ; U241.27 v2(122.79,43.35)
  L12-SIGNAL5 w0.102: v2(126.6,38.4) 125.92,38.4 124.37,36.86 124.37,36.18 123.12,34.93 122.13,34.93 120.38,36.68 120.38,41.28 121.36,42.26 121.36,43.54 121.6,43.79 122.36,43.79 v2(122.79,43.35)
MCU_OSPI0_D3: length 19
  TOP w0.127: v2(124.79,42.44) 125.29,42.94 U241.32 ; U246.D4 v2(126.6,39.4)
  L12-SIGNAL5 w0.102: v2(124.79,42.44) 124.79,42.1 124.68,41.99 123.05,41.99 122.36,41.3 122.36,40.59 122.5,40.45 123.28,40.45 123.43,40.3 123.43,40.1 123.28,39.96 122.5,39.96 122.36,39.81 122.36,36.75 122.59,36.53 122.94,36.53 124.47,38.05 124.47,39.68 124.67,39.89 125.76,39.89 126.25,39.4 v2(126.6,39.4)
MCU_OSPI0_D4: length 19
  TOP w0.127: U241.25 v2(121.79,43.35) ; U246.D5 v2(125.6,39.4)
  L12-SIGNAL5 w0.102: v2(125.6,39.4) 125.73,39.4 125.99,39.14 125.99,38.88 125.89,38.78 124.97,38.78 124.81,38.62 124.81,38.46 125.07,38.2 125.07,38.04 122.97,35.94 121.67,35.94 121.34,36.27 121.34,36.99 121.2,37.14 120.85,37.14 120.71,37.28 120.71,37.48 120.85,37.63 121.2,37.63 121.34,37.77 121.34,38.88 121.2,39.03 120.88,39.03 120.73,39.17 120.73,39.37 120.88,39.52 121.2,39.52 121.34,39.66 121.34,41.54 121.45,41.65 122.14,41.65 122.36,41.86 122.36,42.79 v2(121.79,43.35)
MCU_OSPI0_D5: length 19
  TOP w0.127: U246.E3 v2(127.6,40.4) ; U241.23 v2(120.79,43.35)
  L12-SIGNAL5 w0.102: v2(120.79,43.35) 120.79,42.98 120.66,42.85 120.05,42.85 119.9,43 119.9,43.46 119.59,43.76 118.35,43.76 118.22,43.89 118.22,44.21 118.33,44.32 123.62,44.32 123.77,44.18 123.77,43.91 123.91,43.76 124.11,43.76 124.26,43.91 124.26,44.18 124.4,44.32 124.8,44.32 125.2,43.92 125.97,43.92 126.36,43.53 126.36,41.85 126.78,41.43 126.98,41.43 127.06,41.5 127.26,41.5 127.41,41.36 127.41,41.16 127.33,41.08 127.33,40.88 127.6,40.61 v2(127.6,40.4)
MCU_OSPI0_D6: length 19
  TOP w0.127: v2(119.24,43.26) 119.84,43.86 U241.21 ; U246.E2 v2(128.6,40.4)
  L12-SIGNAL5 w0.102: v2(119.24,43.26) 118.22,43.26 117.81,43.66 117.81,44.27 118.25,44.7 124.95,44.7 125.36,44.3 126.7,44.3 127.34,43.66 127.34,42.62 128.6,41.36 v2(128.6,40.4)
MCU_OSPI0_D7: length 19.3
  TOP w0.127: U246.E1 v2(129.6,40.4) ; v2(117.21,45.67) 118.5,45.67 118.98,46.16 U241.19
  L12-SIGNAL5 w0.102: v2(129.6,40.4) 129.6,40.95 127.8,42.76 127.8,44.17 127.16,44.81 125.56,44.81 124.62,45.75 117.29,45.75 v2(117.21,45.67)
MCU_OSPI0_DQS: length 17.8
  TOP w0.127: U241.29 v2(123.79,43.35)
  L12-SIGNAL5 w0.102: v1(127.77,35.31) 127.26,34.8 125.43,34.8 124.87,35.36 124.87,36.55 125.23,36.91 125.84,36.91 127.06,38.13 127.06,39.6 126.71,39.95 126.41,39.95 126.14,40.21 126.14,40.88 125.36,41.66 125.36,43.13 125.13,43.35 v2(123.79,43.35)
  BOTTOM w0.127: R526.2 R552.2 R542.2
MCU_OSPI0_LBCLKO: length 19.2
  L3-SIGNAL1 w0.089: v3(124.48,52.62) 124.48,67.5 125.13,68.15 125.13,69.67 126.32,70.85 v3(126.32,71.03)
  vias: v1(126.32,71.03)
MCU_OSPI0_RESET_OUT0: length 72.6
  TOP w0.127: U241.39 v2(129.59,45.16)
  L7-SIGNAL3 w0.109: v2(129.59,45.16) 130.03,45.59 130.03,46.33 131.61,47.9 131.61,50.01 129.35,52.27 105.16,52.27 98.79,45.9 84.82,45.9 82.86,47.85 71.55,47.85 v2(71.04,48.37)
  BOTTOM w0.127: R1160.1 70.93,48.22 71,48.29 71,48.33 v2(71.04,48.37)
MCU_OSPI0_RESET_OUT0_R: length 2.1
  TOP w0.127: U97.2 71.05,46.26 v2(70.93,46.13)
  BOTTOM w0.127: R1162.1 v2(70.93,46.13) R1160.2
MCU_OSPI1_CLK: length 29.5
  TOP w0.127: U79.B2 140.09,46.23 141.71,46.23 142.02,45.92 v3(143.07,45.92)
  L3-SIGNAL1 w0.089: v3(143.07,45.92) 143.47,46.32 143.47,47.73 140.95,50.24 140.95,53.01 139.56,54.41 134.27,54.41 128.86,59.82 128.86,60.54 129.37,61.05 129.37,61.47 129.51,61.61 v3(129.93,61.61)
MCU_OSPI1_CLK_R: length 7.5
  L3-SIGNAL1 w0.089: v3(129.93,62.45) 129.53,62.85 129.53,67.39 128.72,68.2 v3(128.72,69.43)
  vias: v1(128.72,69.43)
MCU_OSPI1_CS0: length 36.4
  TOP w0.127: v3(143.07,47.19) 140.06,47.19 U79.C2
  L3-SIGNAL1 w0.089: v3(143.07,47.19) 140.36,49.91 140.36,52.62 139.99,52.98 139.35,52.98 138.62,52.25 138.01,52.25 136.49,53.77 132.19,53.77 128.25,57.71 128.25,61.32 128.66,61.73 128.66,67.18 127.92,67.93 v3(127.92,68.63)
  vias: v1(127.92,68.63)
MCU_OSPI1_D0: length 36.9
  TOP w0.127: U79.D3 138.11,48.23 138.11,50.85 138.34,51.08 v3(138.34,52.59)
  L3-SIGNAL1 w0.089: v3(127.92,69.43) 128.41,68.94 128.41,67.97 128.99,67.39 128.99,61.19 128.56,60.76 128.56,58.12 128.78,57.89 128.92,57.89 129.28,58.25 129.41,58.25 129.53,58.14 129.53,58.01 129.17,57.65 129.17,57.51 129.27,57.41 129.41,57.41 129.81,57.81 129.95,57.81 130.06,57.71 130.06,57.57 129.65,57.16 129.65,57.02 129.75,56.92 129.89,56.92 130.3,57.33 130.44,57.33 130.54,57.23 130.54,57.08 130.14,56.68 130.14,56.54 130.24,56.44 130.38,56.44 130.78,56.84 130.92,56.84 131.02,56.74 131.02,56.6 130.62,56.19 130.62,56.05 130.72,55.95 130.86,55.95 131.27,56.36 131.41,56.36 131.51,56.26 131.51,56.11 131.11,55.71 131.11,55.57 131.21,55.47 131.35,55.47 131.75,55.87 131.89,55.87 131.99,55.77 131.99,55.63 131.59,55.22 131.59,55.08 132.57,54.1 136.82,54.1 v3(138.34,52.59)
  vias: v1(127.92,69.43)
MCU_OSPI1_D1: length 36.9
  TOP w0.127: U79.D2 139.15,48.19 139.15,49.53 139.61,49.99 v3(139.61,52.59)
  L3-SIGNAL1 w0.089: v3(125.52,69.43) 125.94,69.01 125.94,64.11 125.78,63.94 125.78,57.04 134.09,48.72 135.95,48.72 139.61,52.38 v3(139.61,52.59)
  vias: v1(125.52,69.43)
MCU_OSPI1_D2: length 36.9
  TOP w0.127: U79.C4 137.12,47.22 135.63,47.22 135.14,46.73 v3(134.49,46.73)
  L3-SIGNAL1 w0.089: v3(134.49,46.73) 134.17,47.05 134.17,48.26 129.05,53.38 128.91,53.38 128.49,52.97 128.35,52.97 128.25,53.07 128.25,53.21 128.66,53.63 128.66,53.77 128.56,53.87 128.42,53.87 128.01,53.45 127.86,53.45 127.76,53.55 127.76,53.69 128.18,54.11 128.18,54.25 128.08,54.35 127.94,54.35 127.52,53.94 127.38,53.94 127.28,54.04 127.28,54.18 127.69,54.59 127.69,54.74 127.59,54.84 127.45,54.84 127.04,54.42 126.89,54.42 126.79,54.52 126.79,54.66 127.21,55.08 127.21,55.22 127.11,55.32 126.97,55.32 126.55,54.91 126.41,54.91 126.31,55.01 126.31,55.15 126.72,55.56 126.72,55.71 126.62,55.81 126.48,55.81 126.17,55.5 126.05,55.5 125.93,55.61 125.93,55.74 126.24,56.05 126.24,56.19 125.51,56.92 125.51,64.05 125.52,64.06 v3(125.52,68.63)
  vias: v1(125.52,68.63)
MCU_OSPI1_D3: length 37.3
  TOP w0.127: v3(137.07,52.59) 137.09,52.56 137.09,48.24 U79.D4
  L3-SIGNAL1 w0.089: v3(137.07,52.59) 137.45,52.21 137.45,51.77 137.35,51.67 135.83,51.67 135.75,51.58 135.75,51.45 135.87,51.32 137.35,51.32 137.45,51.22 137.45,50.85 136.81,50.22 136.03,50.22 135.63,49.82 135.63,49.39 135.36,49.12 134.22,49.12 126.09,57.25 126.09,63.88 126.32,64.1 v3(126.32,68.63)
  vias: v1(126.32,68.63)
MCU_OSPI1_DQS: length 29.6
  L3-SIGNAL1 w0.089: v3(127.5,63.6) 127.5,57.37 131.22,53.65 131.4,53.65 131.55,53.8 131.55,53.98 127.95,57.58 127.95,61.6 128.23,61.87 128.23,65.71 127.54,66.4 127.54,69.01 v3(127.12,69.43)
  vias: v1(127.12,69.43)
MCU_OSPI1_LBCLKO: length 6
  L3-SIGNAL1 w0.089: v3(126.66,63.6) 126.66,63.97 126.7,64.01 126.7,69.04 v3(126.32,69.43)
  vias: v1(126.32,69.43)
MCU_PERIPH_1V8_RSTZ: length 108.3
  TOP w0.127: U103.4 47.27,41.7 47.08,41.9 47.08,42.65 TP193.1 v2(46.73,44.6) ; U79.A4 v3(137.1,44.23)
  L3-SIGNAL1 w0.089: v2(46.73,44.6) 52.42,50.29 59.93,50.29 63.67,54.03 68.53,54.03 70.11,52.45 99.78,52.45 106.93,45.31 111.25,45.31 115.43,49.48 118.25,49.48 119.01,50.24 119.85,50.24 120.4,50.79 121.33,50.79 122.05,50.07 122.05,48.75 122.89,47.9 127.82,47.9 128.74,46.99 130.92,46.99 133.21,44.7 135.09,44.7 135.56,44.23 v3(137.1,44.23)
MCU_PERIPH_RSTZ: length 143.5
  TOP w0.127: R565.2 51.77,41.05 U103.2 ; R565.2 52.87,39.95 53.07,39.95 v2(53.36,39.66) ; R565.2 R559.2
  L3-SIGNAL1 w0.089: v2(136.43,26.98) 135.51,26.06 110.5,26.06 103.06,33.5 93.06,33.5 91.72,32.17 64.2,32.17 v2(61.57,29.53)
  L5-SIGNAL2 w0.102: v2(53.36,39.66) 52.96,39.66 49.39,43.23 49.39,46.98 50.51,48.1 52.4,48.1 55.46,45.04 62.78,45.04 64.24,46.51 64.24,47.12 68.83,51.7 69.44,51.7 v2(73.25,51.7)
  L7-SIGNAL3 w0.109: v2(53.36,39.66) 54.28,39.66 57.22,36.72 57.22,33.88 v2(61.57,29.53)
  BOTTOM w0.127: U257.2 v2(61.57,29.53) ; R1159.1 72.54,47.99 72.54,51 71.97,51.57 R1139.1 73.18,51.63 v2(73.25,51.7)
MCU_PERIPH_RSTZ_R: length 2.7
  TOP w0.127: U97.1 72,46.11 v2(72,46.11)
  BOTTOM w0.127: v2(72,46.11) 72.07,46.17 R1159.2 72.99,46.68 73.08,46.77 R1158.1
MCU_PORZ: length 154.2
  TOP w0.127: v2(86.57,39.68) 86.22,40.04 83.88,40.04 83.41,39.57 U104.3 ; v2(168.76,29.13) 168.76,30.09 168.05,30.8 U124.4
  L3-SIGNAL1 w0.089: v2(86.57,39.68) 94.6,39.68 99.11,35.17 110.91,35.17 113.75,32.33 116.77,32.33 119.29,29.82 154.77,29.82 155.66,30.71 162.5,30.71 162.83,30.38 164.85,30.38 166.1,29.13 v2(168.76,29.13) ; v3(115.12,70.23) 114.73,69.84 114.73,62.45 114.08,61.8 114.08,60.72 112.6,59.23 109.33,59.23 v2(108.44,58.34)
  L5-SIGNAL2 w0.102: v2(86.57,39.68) 87.85,38.41 v2(108.36,38.41)
  L14-SIGNAL6 w0.089: v2(108.36,38.41) 109.84,39.88 109.84,50.47 108.44,51.87 v2(108.44,58.34)
  vias: v1(115.12,70.23)
MCU_PORZ_OE: length 1.4
  TOP w0.127: U104.5 80.59,39.07 R569.2
MCU_PORZ_OUT: length 196.5
  TOP w0.127: v2(87.37,36.78) 87.65,36.51 U111.1 ; U104.4 80.94,39.57 80.68,39.83 80.68,40.13 R566.1 80.22,40.6 80.68,41.05 v2(81.34,41.05)
  L5-SIGNAL2 w0.102: v2(51.78,43) 53.49,43 56.8,39.68 74.62,39.68 75.99,41.05 v2(81.34,41.05)
  L7-SIGNAL3 w0.109: v2(87.37,36.78) 86.85,37.31 83.77,37.31 81.34,39.73 v2(81.34,41.05)
  L12-SIGNAL5 w0.102: v2(87.37,36.78) 88.37,36.78 89.16,36 89.16,33.76 89.45,33.47 89.45,33.46 96.75,26.16 101.62,26.16 104.22,23.57 111.64,23.57 116.04,19.17 133.65,19.17 134.39,18.44 140.06,18.44 140.26,18.23 143.78,18.23 144.8,19.25 169.4,19.25 176.64,26.49 176.64,34.54 179.36,37.26 179.36,38.25 184.95,43.84 184.95,52.27 189.31,56.64 189.31,58.34 191.16,60.19 194.33,60.19 196.25,62.1 v2(196.91,62.1)
  BOTTOM w0.127: v2(81.34,41.05) 81.82,41.05 82.18,40.7 U254.2 ; v2(196.91,62.1) 197.03,61.99 R1123.1
MCU_PWRGRP_IRQN: length 227.4
  TOP w0.127: R504.1 v2(165.86,52.05) 165.88,52.03 R512.1 ; U68.42 180.57,77.32 v2(180.89,77.64) 181.53,77.64 182.9,79.02 183.61,79.02 184.43,79.84 TP127.1 ; v2(73.81,74.58) 73.48,74.91 R1299.1
  L3-SIGNAL1 w0.089: v2(180.89,77.64) 178.63,75.39 178.63,71.92 178.19,71.47 173.69,71.47 172.1,69.88 172.1,65.61 172.47,65.24 172.47,61.91 171.92,61.35 171.92,54.55 169.42,52.05 v2(165.86,52.05)
  L7-SIGNAL3 w0.109: v2(165.86,52.05) 165.86,50.08 166.81,49.12 166.81,48.54 167.65,47.7 168.26,47.7 171.94,44.02 177.22,44.02 179.79,41.45 179.79,38.35 176.51,35.08 172.83,35.08 168.28,30.53 147.48,30.53 144.76,33.25 135.8,33.25 134.76,34.29 118.02,34.29 116.44,35.87 100.21,35.87 92.87,43.21 84.03,43.21 83.85,43.38 83.85,44.65 83.07,45.44 77.48,45.44 74.71,42.67 69.76,42.67 68.94,43.49 68.94,46.79 67.17,48.57 67.17,52.53 65.24,54.46 65.24,64.47 69.44,68.67 69.44,70.21 v2(73.81,74.58)
MCU_RESETSTATZ: length 105.7
  TOP w0.127: R447.1 v2(75.75,65.08) 74.91,65.08 74.38,64.55 TP157.1
  L3-SIGNAL1 w0.089: v2(75.75,65.08) 78.99,61.85 88.31,61.85 91.22,58.94 108.5,58.94 109.68,60.12 111.2,60.12 v5(111.21,60.13) ; v3(117.52,71.83) v5(117.29,71.55)
  L4-GND2 w0.102: v6(111.54,60.14) 111.54,60.13 111.21,60.13 v5(111.21,60.13) ; v5(117.29,71.55) v6(116.98,71.25)
  L5-SIGNAL2 w0.102: v2(51.77,40.22) 49.16,42.83 49.16,47.14 50.35,48.33 52.5,48.33 53.37,47.46 55.52,45.31 58.6,45.31 59.87,46.58 59.87,55.8 68.36,64.29 70.57,64.29 71.36,65.08 v2(75.75,65.08) ; v6(116.98,71.25) 116.98,71.03 116.29,70.33 116.29,65.81 111.54,61.06 v6(111.54,60.14)
  vias: v1(117.52,71.83)
MCU_RESETZ: length 110.7
  TOP w0.127: U101.4 v2(84.36,43.68)
  L3-SIGNAL1 w0.089: v3(118.32,71.83) v5(118.09,71.55) ; v5(113.7,60.81) 109.96,60.81 108.31,59.15 91.34,59.15 88.38,62.11 79.89,62.11 77.18,64.82 77.18,65.86 76.41,66.62 v2(76.41,68.83)
  L4-GND2 w0.102: v5(118.09,71.55) v6(117.78,71.25) ; v6(113.69,61.14) 113.7,61.14 v5(113.7,60.81)
  L5-SIGNAL2 w0.102: v6(117.78,71.25) 117.48,70.95 117.48,70.33 117.48,70.32 117.48,70.05 117.25,69.83 117.25,65.46 115.32,63.53 115.32,62.77 v6(113.69,61.14)
  L7-SIGNAL3 w0.109: v2(84.36,43.68) 84.36,44.68 83.35,45.7 77.4,45.7 74.61,42.91 69.99,42.91 69.3,43.6 69.3,46.91 67.5,48.72 67.5,52.65 65.62,54.53 65.62,62.97 69.01,66.37 71.69,66.37 74.15,68.83 v2(76.41,68.83)
  vias: v1(118.32,71.83)
MCU_RGMII1_100MBPS: length 42.7
  L14-SIGNAL6 w0.089: J40.14 90.2,6.86 90.2,17.25 91.43,18.49 105.85,18.49 107.63,20.26 109.15,21.79 109.15,24.9 109.44,25.19 v2(109.44,25.84)
  BOTTOM w0.127: R1290.1 J40.14
MCU_RGMII1_1000MBPS: length 35.6
  L14-SIGNAL6 w0.089: J40.13 93.75,5.36 90.4,8.71 90.4,17.17 91.46,18.23 107.3,18.23 107.93,17.6 107.93,16.67 v2(107.96,16.64)
  BOTTOM w0.127: U271.3 v2(107.96,16.64) ; R1287.1 J40.13
MCU_RGMII1_ACT_LED: length 22.7
  L14-SIGNAL6 w0.089: J40.12 109.77,5.87 v2(109.77,24.95)
MCU_RGMII1_CLK_OUT: length 1.7
  TOP w0.127: TP228.1 v2(95,24.77)
  BOTTOM w0.127: U261.18 TP228.1 v2(95,24.77)
MCU_RGMII1_D0_N: length 9.7
  BOTTOM w0.094: U261.2 101.61,21.52 101.61,20.95 101.72,20.84 101.72,20.15 103.51,18.36 103.51,15.99 104.32,15.19 105.23,15.19 J40.10
MCU_RGMII1_D0_P: length 9.7
  BOTTOM w0.094: U261.1 102.11,21.52 102.11,21.52 102.11,20.95 102,20.84 102,20.27 103.79,18.47 103.79,16.11 104.43,15.47 105.44,15.47 105.57,15.6 105.57,16.12 J40.9
MCU_RGMII1_D1_N: length 9.4
  BOTTOM w0.094: J40.8 102.69,15.19 101.66,15.19 101.03,15.83 101.03,17.68 100.22,18.48 100.22,20.84 100.11,20.95 100.11,21.52 U261.5
MCU_RGMII1_D1_P: length 9.4
  BOTTOM w0.094: U261.4 100.61,21.52 100.61,21.52 100.61,20.95 100.5,20.84 100.5,18.6 101.31,17.79 101.31,15.94 101.78,15.47 102.9,15.47 103.03,15.6 103.03,16.12 J40.7
MCU_RGMII1_D2_N: length 9.1
  BOTTOM w0.094: J40.6 100.15,15.19 99.24,15.19 98.43,15.99 98.43,17.43 98.72,17.72 98.72,20.84 98.61,20.95 U261.8
MCU_RGMII1_D2_P: length 9.1
  BOTTOM w0.094: J40.5 100.49,16.12 100.49,15.6 100.36,15.47 99.35,15.47 98.71,16.11 98.71,17.31 99,17.6 99,20.84 99.11,20.95 U261.7
MCU_RGMII1_D3_N: length 9.5
  BOTTOM w0.094: U261.11 97.11,20.95 97.22,20.84 97.22,19.63 95.89,18.31 95.89,15.99 96.7,15.19 97.61,15.19 J40.4
MCU_RGMII1_D3_P: length 9.5
  BOTTOM w0.094: J40.3 97.95,16.12 97.95,15.6 97.82,15.47 96.81,15.47 96.17,16.11 96.17,18.19 97.5,19.52 97.5,20.84 97.61,20.95 U261.10
MCU_RGMII1_GPIO0_100: length 7.2
  TOP w0.127: U133.1 107.14,26.39 106.76,26.02 105.06,26.02 104.87,26.21 R630.2 R622.1 104.17,27.77 103.95,27.54 v2(103.95,27.01)
  BOTTOM w0.127: U261.39 103.71,26.77 v2(103.95,27.01)
MCU_RGMII1_GPIO1: length 3.3
  BOTTOM w0.127: U261.40 103.59,26.27 103.79,26.47 104.3,26.47 104.45,26.63 R1234.2 R1231.1
MCU_RGMII1_INT#: length 66
  L3-SIGNAL1 w0.089: v3(119.12,71.03) v5(118.89,70.75)
  L4-GND2 w0.102: v5(118.89,70.75) v7(118.58,70.45)
  L12-SIGNAL5 w0.102: v7(118.58,70.45) 118.58,64.6 111.74,57.76 106.99,57.76 v8(100.31,51.08)
  L13-GND5 w0.102: v8(100.31,51.08) v9(100.31,51.46)
  L14-SIGNAL6 w0.089: v9(100.31,51.46) 105.11,51.46 105.93,50.65 105.93,49.84 106.28,49.48 106.28,48.92 105.55,48.18 105.55,31.09 105.24,30.79 105.24,24.64 v2(104.87,24.27)
  BOTTOM w0.127: U261.44 102.86,24.27 104.87,24.27 v2(104.87,24.27)
  vias: v1(119.12,71.03)
MCU_RGMII1_LED0: length 3.5
  TOP w0.127: v2(103.74,22.77) 103.74,22.36 103.99,22.11 R655.1 R650.2
  BOTTOM w0.127: v2(103.74,22.77) 102.86,22.77 U261.47
MCU_RGMII1_LED1_1000: length 9
  BOTTOM w0.127: U271.1 107.01,19 106.84,18.83 105.09,18.83 104.87,19.05 R1260.2 R1255.1 104.28,21.56 104.28,23.1 104,23.38 103.59,23.38 103.48,23.27 102.86,23.27 U261.46
MCU_RGMII1_LED2_ACT: length 8.4
  BOTTOM w0.127: U263.1 107.47,22.25 106.74,21.52 105.01,21.52 104.87,21.66 R1253.1 R1250.2 104.23,23.77 102.86,23.77 U261.45
MCU_RGMII1_LED2_ANODE: length 2.2
  BOTTOM w0.127: R1286.1 J40.11
MCU_RGMII1_RBIAS: length 1.9
  BOTTOM w0.127: U261.12 96.61,20.61 96.24,20.24 R1258.2
MCU_RGMII1_RD0: length 65.7
  L3-SIGNAL1 w0.089: v3(123.92,71.83) v5(124.19,71.6)
  L4-GND2 w0.102: v5(124.19,71.6) v7(123.89,71.3)
  L12-SIGNAL5 w0.102: v7(123.89,71.3) 124.31,71.3 124.85,70.76 125.71,70.76 126.68,69.8 126.68,61.28 117.52,52.12 107.55,52.12 106.33,50.9 105.85,50.9 105.49,50.55 v8(105.49,50.24)
  L13-GND5 w0.102: v8(105.49,50.24) v9(105.49,50.62)
  L14-SIGNAL6 w0.089: v11(99.47,34.02) 100.12,34.67 100.12,34.85 99.75,35.22 99.75,35.4 99.87,35.53 100.05,35.53 100.43,35.15 100.61,35.15 100.73,35.28 100.73,35.46 100.36,35.83 100.36,36.01 100.48,36.14 100.66,36.14 101.04,35.76 101.22,35.76 101.34,35.89 101.34,36.07 100.97,36.44 100.97,36.62 101.09,36.75 101.27,36.75 101.65,36.37 101.83,36.37 101.96,36.5 101.96,36.68 101.58,37.05 101.58,37.23 101.71,37.36 101.88,37.36 102.26,36.98 102.44,36.98 102.57,37.11 102.57,37.29 102.19,37.66 102.19,37.84 102.32,37.97 102.49,37.97 102.87,37.59 103.05,37.59 104.38,38.92 104.38,47.83 105.49,48.95 v9(105.49,50.62)
  BOTTOM w0.127: R1204.1 v11(99.47,34.02)
  vias: v1(123.92,71.83)
MCU_RGMII1_RD0_R: length 5.5
  BOTTOM w0.127: U261.33 100.61,28.52 R1216.2 100.23,30.35 100.06,30.51 100.06,31.65 R1198.1 99.47,32.2 R1204.2
MCU_RGMII1_RD1: length 69
  L3-SIGNAL1 w0.089: v3(123.12,71.03) v5(123.39,70.8)
  L4-GND2 w0.102: v5(123.39,70.8) v7(123.06,70.47)
  L12-SIGNAL5 w0.102: v8(104.05,49.56) 104.05,49.89 104.22,50.07 104.22,51.05 106.28,53.11 116.89,53.11 125.54,61.75 125.54,68.99 124.42,70.1 123.43,70.1 v7(123.06,70.47)
  L13-GND5 w0.102: v8(104.05,49.56) v9(104.05,49.17)
  L14-SIGNAL6 w0.089: v11(101.66,31.12) 102.24,31.71 102.24,33.35 101.84,33.75 100.17,33.75 99.71,33.29 99.08,33.29 98.43,33.93 98.43,35.41 99.23,36.2 99.23,36.38 99.01,36.59 99.01,36.77 99.14,36.9 99.32,36.9 99.53,36.68 99.71,36.68 99.84,36.81 99.84,36.99 99.62,37.2 99.62,37.38 99.75,37.51 99.93,37.51 100.14,37.29 100.32,37.29 100.45,37.42 100.45,37.6 100.23,37.82 100.23,37.99 100.36,38.12 100.54,38.12 100.75,37.91 100.93,37.91 101.06,38.03 101.06,38.21 100.84,38.43 100.84,38.6 100.97,38.73 101.15,38.73 101.36,38.52 101.54,38.52 101.67,38.64 101.67,38.82 101.45,39.04 101.45,39.22 101.58,39.34 101.76,39.34 101.97,39.13 102.15,39.13 102.28,39.25 102.28,39.43 102.06,39.65 102.06,39.83 102.19,39.95 102.37,39.95 102.58,39.74 102.76,39.74 102.89,39.86 102.89,40.04 102.67,40.26 102.67,40.44 102.8,40.56 102.98,40.56 103.19,40.35 103.37,40.35 103.79,40.77 103.79,48.92 v9(104.05,49.17)
  vias: v1(123.12,71.03)
MCU_RGMII1_RD1_R: length 2.2
  BOTTOM w0.127: U261.34 101.11,28.52 101.11,29.91 R1210.2
MCU_RGMII1_RD2: length 65.3
  L3-SIGNAL1 w0.089: v3(124.72,71.03) v5(124.99,70.8)
  L4-GND2 w0.102: v5(124.99,70.8) v7(125.54,70.26)
  L12-SIGNAL5 w0.102: v7(125.54,70.26) 126.3,69.5 126.3,61.44 117.28,52.43 106.46,52.43 105.04,51 105.04,50.09 104.81,49.86 v8(104.81,49.53)
  L13-GND5 w0.102: v8(104.81,49.53) v9(104.81,49.15)
  L14-SIGNAL6 w0.089: v9(104.81,49.15) 104.38,49.58 103.31,49.58 103.06,49.33 103.06,42.67 101.17,40.79 100.99,40.79 100.84,40.94 100.66,40.94 100.54,40.81 100.54,40.64 100.69,40.48 100.69,40.31 100.56,40.18 100.38,40.18 100.23,40.33 100.05,40.33 99.93,40.2 99.93,40.03 100.08,39.87 100.08,39.69 99.95,39.57 99.77,39.57 99.62,39.72 99.44,39.72 99.32,39.59 99.32,39.41 99.47,39.26 99.47,39.08 99.34,38.96 99.16,38.96 99.01,39.11 98.83,39.11 98.71,38.98 98.71,38.8 98.86,38.65 98.86,38.47 98.73,38.35 98.55,38.35 98.4,38.5 98.22,38.5 98.1,38.37 98.1,38.19 98.25,38.04 98.25,37.86 97.72,37.34 97.72,33.86 98.98,32.6 101.4,32.6 v11(101.66,32.86)
  vias: v1(124.72,71.03)
MCU_RGMII1_RD2_R: length 5.9
  BOTTOM w0.127: U261.35 101.61,28.52 101.61,29.23 R1215.2 102.33,30.35 102.19,30.49 102.19,31.67 102.73,32.2 ; 102.73,32.2 R1197.1 ; 102.73,32.2 R1203.2
MCU_RGMII1_RD3: length 68.2
  L3-SIGNAL1 w0.089: v3(123.92,71.03) v5(124.19,70.8)
  L4-GND2 w0.102: v7(123.92,70.52) 123.92,70.52 v5(124.19,70.8)
  L12-SIGNAL5 w0.102: v8(104.61,50.24) 104.61,51 106.38,52.78 117.1,52.78 125.92,61.6 125.92,69.19 124.61,70.5 123.94,70.5 v7(123.92,70.52)
  L13-GND5 w0.102: v8(104.61,50.24) v9(104.61,50.62)
  L14-SIGNAL6 w0.089: v11(103.79,31.12) 103.79,33.73 103.31,34.21 100.23,34.21 99.58,33.57 99.33,33.57 98.94,33.96 98.94,35.18 102.37,38.6 102.54,38.6 102.98,38.17 103.15,38.17 103.28,38.3 103.28,38.48 102.85,38.91 102.85,39.09 102.98,39.21 103.16,39.21 103.59,38.78 103.76,38.78 103.89,38.91 103.89,39.09 103.46,39.52 103.46,39.7 104.07,40.3 104.07,47.9 105.22,49.05 105.22,50.01 v9(104.61,50.62)
  vias: v1(123.92,71.03)
MCU_RGMII1_RD3_R: length 2.8
  BOTTOM w0.127: U261.36 102.11,28.52 102.11,29.11 102.65,29.65 102.98,29.65 R1209.2
MCU_RGMII1_RX_CTL: length 66.2
  L3-SIGNAL1 w0.089: v3(124.72,70.23) v5(124.49,69.95)
  L4-GND2 w0.102: v7(123.96,69.7) 124.22,69.95 v5(124.49,69.95)
  L12-SIGNAL5 w0.102: v7(123.96,69.7) 124.39,69.7 125.1,68.99 125.1,61.93 116.59,53.42 106.15,53.42 103.79,51.05 v8(103.79,50.24)
  L13-GND5 w0.102: v8(103.79,50.24) v9(103.79,50.62)
  L14-SIGNAL6 w0.089: v9(103.79,50.62) 102.75,49.58 102.75,43.64 97.44,38.33 97.44,33.71 99.07,32.08 99.07,30.81 99.42,30.46 103.79,30.46 104.51,31.18 104.51,31.42 v11(104.87,31.78)
  vias: v1(124.72,70.23)
MCU_RGMII1_RX_CTL_R: length 5
  BOTTOM w0.127: U261.38 103.48,27.27 104.35,28.15 104.35,28.39 R1223.1 R1220.2 R1206.2
MCU_RGMII1_RXC: length 68.7
  L3-SIGNAL1 w0.089: v3(123.12,70.23) v5(122.89,69.95)
  L4-GND2 w0.102: v5(122.89,69.95) v7(123.19,69.65)
  L12-SIGNAL5 w0.102: v8(103.41,49.56) 103.41,51.13 106,53.72 116.35,53.72 124.72,62.09 124.72,68.89 124.34,69.27 123.57,69.27 v7(123.19,69.65)
  L13-GND5 w0.102: v8(103.41,49.56) v9(103.41,49.17)
  L14-SIGNAL6 w0.089: v9(103.41,49.17) 103.41,41.76 102.8,41.15 102.63,41.15 102.41,41.37 102.23,41.37 102.11,41.24 102.11,41.06 102.32,40.85 102.32,40.67 102.19,40.54 102.02,40.54 101.8,40.76 101.62,40.76 101.5,40.63 101.5,40.45 101.71,40.24 101.71,40.06 101.58,39.93 101.4,39.93 101.19,40.14 101.01,40.14 100.88,40.02 100.88,39.84 101.1,39.62 101.1,39.45 100.97,39.32 100.79,39.32 100.58,39.53 100.4,39.53 100.27,39.41 100.27,39.23 100.49,39.01 100.49,38.83 100.36,38.71 100.18,38.71 99.97,38.92 99.79,38.92 99.66,38.8 99.66,38.62 99.88,38.4 99.88,38.22 99.75,38.1 99.57,38.1 99.36,38.31 99.18,38.31 99.05,38.19 99.05,38.01 99.27,37.79 99.27,37.61 99.14,37.49 98.96,37.49 98.75,37.7 98.57,37.7 98.44,37.58 98.44,37.4 98.66,37.18 98.66,37 98.07,36.41 98.07,33.92 99.04,32.95 99.81,32.95 100.31,33.44 101.61,33.44 101.98,33.08 101.98,32.58 101.68,32.29 100.69,32.29 v11(99.53,31.12)
  vias: v1(123.12,70.23)
MCU_RGMII1_RXC_R: length 2.3
  BOTTOM w0.127: R1211.2 100.21,29.78 100.21,29.24 100.11,29.14 100.11,28.52 U261.32
MCU_RGMII1_TD0: length 62.6
  L3-SIGNAL1 w0.089: v3(123.92,69.43) v5(123.69,69.15)
  L4-GND2 w0.102: v5(123.69,69.15) v7(123.38,68.85)
  L12-SIGNAL5 w0.102: v7(123.38,68.85) 122.94,68.41 122.94,62.83 116.94,56.82 107.37,56.82 101.61,51.05 101.61,48.16 v8(100.48,47.03)
  L13-GND5 w0.102: v8(100.48,47.03) v9(100.21,46.76)
  L14-SIGNAL6 w0.089: v11(97.61,30.3) 97.65,30.34 97.65,31.77 96.33,33.1 96.33,37.17 96.45,37.3 96.73,37.3 96.86,37.42 96.86,37.6 96.73,37.73 96.45,37.73 96.33,37.85 96.33,38.03 96.45,38.16 96.73,38.16 96.86,38.29 96.86,38.47 96.73,38.59 96.45,38.59 96.33,38.72 96.33,38.9 96.45,39.02 96.73,39.02 96.86,39.15 96.86,39.33 96.73,39.46 96.45,39.46 96.33,39.58 96.33,39.76 96.45,39.89 96.73,39.89 96.86,40.01 96.86,40.19 96.73,40.32 96.45,40.32 96.33,40.45 96.33,40.62 96.45,40.75 96.73,40.75 96.86,40.88 96.86,41.06 96.73,41.18 96.45,41.18 96.33,41.31 96.33,42.88 v9(100.21,46.76)
  BOTTOM w0.127: U261.28 98.11,29.8 v11(97.61,30.3)
  vias: v1(123.92,69.43)
MCU_RGMII1_TD1: length 62.4
  L3-SIGNAL1 w0.089: v3(123.92,68.63) v5(123.69,68.35)
  L4-GND2 w0.102: v5(123.69,68.35) v7(123.38,68.05)
  L12-SIGNAL5 w0.102: v8(101.91,47.93) 101.91,50.93 106.36,55.37 116.11,55.37 123.38,62.65 v7(123.38,68.05)
  L13-GND5 w0.102: v8(101.91,47.93) v9(101.91,48.31)
  L14-SIGNAL6 w0.089: v9(101.91,48.31) 100.97,49.25 100.47,49.25 99.68,48.46 99.68,47.22 98.87,46.41 98.69,46.41 98.35,46.75 98.17,46.75 98.05,46.63 98.05,46.45 98.39,46.11 98.39,45.93 96.01,43.55 96.01,32.96 97.22,31.75 97.22,29.42 97.31,29.33 97.56,29.33 v11(97.61,29.38)
  BOTTOM w0.127: U261.27 v11(97.61,29.38)
  vias: v1(123.92,68.63)
MCU_RGMII1_TD2: length 62.5
  L3-SIGNAL1 w0.089: v3(124.72,69.43) v5(124.49,69.15)
  L4-GND2 w0.102: v5(124.49,69.15) v7(124.18,68.85)
  L12-SIGNAL5 w0.102: v8(102.32,49.45) 102.32,50.9 106.49,55.07 116.41,55.07 123.81,62.47 123.81,68.47 v7(124.18,68.85)
  L13-GND5 w0.102: v8(102.32,49.45) v9(102.32,49.07)
  L14-SIGNAL6 w0.089: v11(96.61,30.3) 96.61,31.24 96.61,31.9 95.74,32.77 95.74,44.98 98.36,47.6 98.53,47.6 98.93,47.21 99.11,47.21 99.23,47.33 99.23,47.51 98.84,47.9 98.84,48.08 100.31,49.56 101.84,49.56 v9(102.32,49.07)
  BOTTOM w0.127: U261.26 97.11,29.8 v11(96.61,30.3)
  vias: v1(124.72,69.43)
MCU_RGMII1_TD3: length 62.4
  L3-SIGNAL1 w0.089: v3(124.72,68.63) v5(124.49,68.35)
  L4-GND2 w0.102: v5(124.49,68.35) 124.24,68.11 v7(124.24,67.95)
  L12-SIGNAL5 w0.102: v7(124.24,67.95) 124.24,62.29 116.71,54.76 106.61,54.76 102.93,51.08 v8(102.93,50.27)
  L13-GND5 w0.102: v8(102.93,50.27) v9(102.93,50.65)
  L14-SIGNAL6 w0.089: v9(102.93,50.65) 102.93,50.24 102.57,49.89 102.27,49.89 102.15,50.01 102.15,50.72 102.02,50.85 101.84,50.85 101.71,50.72 101.71,50.01 101.59,49.89 100.21,49.89 95.44,45.11 95.44,32.56 96.07,31.93 96.07,29.92 v11(96.61,29.38)
  BOTTOM w0.127: U261.25 v11(96.61,29.38)
  vias: v1(124.72,68.63)
MCU_RGMII1_TX_CTL: length 62.4
  L3-SIGNAL1 w0.089: v3(123.12,69.43) v5(122.89,69.15)
  L4-GND2 w0.102: v5(122.89,69.15) v7(122.49,68.76)
  L12-SIGNAL5 w0.102: v8(100.9,49.2) 100.62,49.48 100.62,50.93 107.15,57.46 114.05,57.46 122.06,65.46 122.06,68.32 v7(122.49,68.76)
  L13-GND5 w0.102: v8(100.9,49.2) v9(100.9,48.82)
  L14-SIGNAL6 w0.089: v11(103.62,28.51) 103.07,27.97 101.48,27.97 100.54,28.91 100.54,29.62 100.03,30.12 99.38,30.12 98.73,30.78 98.73,32 97.18,33.55 97.18,43.07 100.9,46.79 v9(100.9,48.82)
  BOTTOM w0.127: U261.37 103.44,27.77 103.62,27.95 v11(103.62,28.51)
  vias: v1(123.12,69.43)
MCU_RGMII1_TXC: length 62.2
  L3-SIGNAL1 w0.089: v3(123.12,68.63) v5(122.89,68.35)
  L4-GND2 w0.102: v5(122.89,68.35) v7(122.51,67.97)
  L12-SIGNAL5 w0.102: v7(122.51,67.97) 122.51,64.84 114.79,57.13 107.25,57.13 101.2,51.08 v8(101.2,50.27)
  L13-GND5 w0.102: v8(101.2,50.27) v9(101.2,50.65)
  L14-SIGNAL6 w0.089: v9(101.2,50.65) 100.77,50.22 99.86,50.22 95.14,45.5 95.14,30.21 96.38,28.98 97.68,28.98 97.75,29.05 98.48,29.78 v11(98.48,30.28)
  BOTTOM w0.127: U261.29 98.51,28.62 98.51,30.26 v11(98.48,30.28)
  vias: v1(123.12,68.63)
MCU_RGMII1_XIN: length 6.5
  BOTTOM w0.127: U261.15 95.61,23.27 95.61,23.27 93.62,23.27 C1207.2 90.9,23.58 90.72,23.75 Y12.2
MCU_RGMII1_XOUT: length 6.5
  BOTTOM w0.127: Y12.1 90.72,22.22 90.97,22.46 C1218.2 93.62,22.77 95.86,22.77 U261.14
MCU_SAFETY_ERRZ: length 87.8
  L3-SIGNAL1 w0.089: v2(116.72,58.09) 115.68,59.13 115.68,60.86 115.17,61.37 115.17,69.44 115.96,70.23 v3(116.72,70.23)
  L7-SIGNAL3 w0.109: v2(116.72,58.09) 117.53,58.09 117.76,58.32 156.4,58.32 161.5,63.42 161.5,72.3 v2(162.38,73.18) 165.7,76.5 166.79,76.5 169.44,73.85 169.44,70.81 v2(171,69.25)
  BOTTOM w0.127: R1081.1 v2(171,69.25)
  vias: v1(116.72,70.23)
MCU_SVS_SLEEPN: length 2.9
  TOP w0.127: U89.7 172.53,50.14 R531.2 173.91,49.61 R528.1
MCU_UART0_CTS#: length 274
  L3-SIGNAL1 w0.089: v5(109.89,53.65) 109.1,53.65 108.31,54.43 105.51,54.43 103.68,56.26 75.65,56.26 69.91,62 64.99,62 60.8,66.19 58.48,66.19 57.87,66.8 55.96,66.8 v2(51.74,71.03) ; v3(122.32,71.03) v5(122.59,70.8)
  L4-GND2 w0.102: v5(122.59,70.8) v6(122.29,70.5) ; v5(109.89,53.65) v6(110.22,53.65)
  L5-SIGNAL2 w0.102: v2(51.74,71.03) 51.31,71.46 49.78,71.46 49.06,70.74 49.06,68.85 48.41,68.2 48.41,60.44 48.41,59.65 47.05,58.29 47.05,45.75 46.31,45.02 46.31,43.13 47.63,41.81 47.63,40.48 52.58,35.53 63.74,35.53 65.81,33.45 82.77,33.45 83.45,32.76 94.41,32.76 97.08,35.43 111.11,35.43 112.58,33.96 165.18,33.96 166.94,32.21 180.63,32.21 182.91,29.93 183.77,29.93 185.15,29.93 v2(185.94,29.14) ; v6(122.29,70.5) 121.83,70.04 121.83,59.44 115.54,53.15 110.71,53.15 v6(110.22,53.65)
  BOTTOM w0.127: v2(185.94,29.14) 185.52,29.56 U259.5
  vias: v1(122.32,71.03)
MCU_UART0_RTS#: length 280.5
  L3-SIGNAL1 w0.089: v5(101.52,52.29) 107.86,45.95 110.74,45.95 121.95,57.16 121.95,69.79 v3(121.52,70.23)
  L4-GND2 w0.102: v5(101.52,52.29) v6(101.28,52.53)
  L5-SIGNAL2 w0.102: v6(101.28,52.53) 95.26,52.53 81.8,65.99 72.32,65.99 70.54,67.77 62.64,67.77 61.1,69.32 59.27,69.32 57.08,71.5 53.3,71.5 52.66,72.14 v2(51.74,72.14) 52.17,71.71 52.17,70.85 48.87,67.54 48.87,60.63 48.87,59.44 47.54,58.11 47.54,42.66 53.39,36.82 63.19,36.82 66.1,33.91 82.95,33.91 83.64,33.22 94.22,33.22 96.89,35.89 131.52,35.89 132.22,36.58 168.46,36.58 170.96,34.08 184.81,34.08 v2(187.05,31.83)
  BOTTOM w0.127: U259.7 186.82,31.6 v2(187.05,31.83) ; R1069.1 50.85,71.75 51.25,72.14 v2(51.74,72.14)
  vias: v1(121.52,70.23)
MCU_UART0_RXD: length 270.2
  L3-SIGNAL1 w0.089: v3(117.52,71.03) v5(117.29,70.75) ; v2(50.17,72.37) 51.09,73.3 67.49,73.3 70.85,69.93 70.85,67.14 80,57.99 105.37,57.99 105.8,57.56 v5(106.43,57.56)
  L4-GND2 w0.102: v5(106.43,57.56) v6(106.76,57.56) ; v5(117.29,70.75) v6(116.98,70.45)
  L5-SIGNAL2 w0.102: v6(116.98,70.45) 116.67,70.14 116.67,65.83 111.95,61.11 111.95,59.46 110.04,57.56 v6(106.76,57.56) ; v2(184.87,29.14) 184.31,29.7 183.68,29.7 182.65,29.7 180.37,31.98 165.41,31.98 163.66,33.73 112.4,33.73 110.93,35.2 97.17,35.2 94.51,32.53 66.41,32.53 64.48,34.46 49.17,34.46 45.13,38.5 45.13,44.19 46.82,45.88 46.82,58.38 48.18,59.74 48.18,59.78 48.18,68.3 48.83,68.95 48.83,71.04 v2(50.17,72.37)
  BOTTOM w0.127: v2(50.17,72.37) 49.7,72.37 49.07,71.75 R1071.1 ; v2(184.87,29.14) U259.4
  vias: v1(117.52,71.03)
MCU_UART0_TXD: length 270.5
  L3-SIGNAL1 w0.089: v2(49.96,71.03) 50.79,71.03 51.21,71.45 54.08,71.45 55.08,72.44 56.04,72.44 58.83,69.65 62.92,69.65 75.85,56.72 103.92,56.72 105.15,55.49 v5(109.86,55.49) ; v3(120.72,71.03) v5(120.49,70.75)
  L4-GND2 w0.102: v5(120.49,70.75) v6(120.18,70.45) ; v5(109.86,55.49) v6(110.19,55.49)
  L5-SIGNAL2 w0.102: v6(120.18,70.45) 120.18,59.74 115.21,54.76 112.38,54.76 111.65,55.49 v6(110.19,55.49) ; v2(49.96,71.03) 49.96,69.38 48.64,68.06 48.64,60.53 48.64,59.53 47.31,58.2 47.31,42.57 47.89,42 47.89,40.55 52.68,35.75 63.83,35.75 65.91,33.68 82.86,33.68 83.55,32.99 94.32,32.99 96.99,35.66 111.34,35.66 112.81,34.19 131.28,34.19 132.88,35.79 160.26,35.79 161.7,34.34 170.11,34.34 170.82,33.64 v2(181.75,33.64)
  BOTTOM w0.127: U259.6 R1196.2 185.04,32.31 183.71,33.64 v2(181.75,33.64)
  vias: v1(120.72,71.03)
MCU_WK1N: length 3.8
  TOP w0.127: U134.2 R647.1 R646.2 R645.2
MCUIO_1V8_IN+: length 4.8
  TOP w0.127: R583.1 187.96,37.23 188.07,37.34 C386.2 189.03,37.34 189.24,37.55 U106.10 191.28,37.55 U105.D3
MCUIO_1V8_IN-: length 6.3
  TOP w0.127: U105.D2 191.68,38.75 ; 191.68,38.75 U105.D1 ; 191.68,38.75 191.44,38.75 191.24,38.55 U106.8 189.39,38.55 189.1,38.26 ; 189.1,38.26 189.31,38.05 U106.9 ; 189.1,38.26 C386.1 188.03,38.26 187.92,38.37 R579.1
MCUIO_3V3_IN+: length 4.8
  TOP w0.127: R601.1 187.96,33.04 188.07,33.15 C398.2 189.03,33.15 189.24,33.36 U115.10 191.28,33.36 U114.D3
MCUIO_3V3_IN-: length 6.3
  TOP w0.127: 189.1,34.07 189.39,34.36 U115.8 191.22,34.36 191.42,34.56 191.68,34.56 ; 189.1,34.07 189.31,33.86 U115.9 ; 189.1,34.07 C398.1 188.03,34.07 187.92,34.18 R592.1 ; 191.68,34.56 U114.D2 ; 191.68,34.56 U114.D1
MDIO0_MDC: length 44.3
  TOP w0.127: R935.2 74.77,86.87 v3(74.77,86.87)
  L3-SIGNAL1 w0.089: v3(111.12,74.23) v5(110.89,73.95) ; v3(74.77,86.87) 74.77,85.61 76.33,84.06 78.64,84.06 79.59,83.11 83.65,83.11 85.43,81.33 85.62,81.33 86.61,80.33 86.61,79.89 v5(86.85,79.65)
  L4-GND2 w0.102: v6(87.09,79.43) 87.08,79.42 v5(86.85,79.65) ; v5(110.89,73.95) v6(110.58,73.65)
  L5-SIGNAL2 w0.102: v6(87.09,79.43) 88.21,78.31 88.43,78.31 88.81,77.93 90.61,77.93 92.39,76.15 99.12,76.15 101.51,73.76 108.95,73.76 109.25,74.07 110.16,74.07 v6(110.58,73.65)
  vias: v1(111.12,74.23)
MDIO0_MDIO: length 31.9
  TOP w0.127: R926.2 87.92,90.23 R933.2 87.94,89.45 v2(87.94,88.19)
  L3-SIGNAL1 w0.089: v3(108.72,78.23) 108.34,78.23 108.03,77.92 107.48,77.92 106.03,77.92 105.52,77.42 102.98,77.42 102.28,76.71 100.02,76.71 99.79,76.95 99.79,77.52 94.59,82.71 94.59,83.39 93.62,84.37 92.07,84.37 90.17,86.27 88.29,86.27 87.72,86.84 86.93,86.84 86.75,87.02 86.75,87.4 87.23,87.88 87.63,87.88 v2(87.94,88.19)
  vias: v1(108.72,78.23)
MIC1_L: length 6.8
  TOP w0.381: R656.1 R644.2 16.71,23.41 16,24.12 J29.5A
MIC1_L_N: length 33.5
  TOP w0.254: v2(39.11,23.9) 38.98,24.03 37.77,24.03 37.54,23.8 C447.2 36.87,23.8 36.46,24.21 35.7,24.21 35.43,23.95 R642.2 R651.2 ; U154.51 49.49,16.96 49.49,18.04 50.2,18.74 50.2,19.35 v2(50.33,19.48)
  BOTTOM w0.254: v2(39.11,23.9) 38.98,24.03 38.35,24.03 37.83,24.55 37.83,26.54 38.76,27.46 49.21,27.46 52.15,24.52 52.15,21.87 50.22,19.95 50.22,19.58 v2(50.33,19.48)
MIC1_L_P: length 31.4
  TOP w0.254: v2(39.11,24.61) 38.98,24.49 37.73,24.49 37.5,24.72 C447.1 36.46,24.72 36.14,25.04 R636.2 R632.2 R625.2 ; U154.52 49.04,16.96 49.04,18.22 49.74,18.93 49.74,19.35 v2(49.61,19.48)
  BOTTOM w0.254: v2(39.11,24.61) 38.98,24.49 38.54,24.49 38.29,24.74 38.29,26.35 38.95,27.01 49.02,27.01 51.69,24.33 51.69,22.06 49.77,20.14 49.77,19.63 v2(49.61,19.48)
MIC1_R: length 6.8
  TOP w0.381: R665.1 R675.2 16.71,18.03 16,17.32 J29.2A
MIC1_R_N: length 21.6
  TOP w0.254: R672.2 38.13,18.85 38.9,18.09 38.9,17 38.67,16.77 v2(38.3,16.77) 38.17,16.9 37.55,16.9 37.32,16.67 37.24,16.67 ; 37.24,16.67 36.56,16.67 36.12,16.23 R691.2 R692.2 ; 37.24,16.67 C491.1 37.24,16.67 ; v2(48.62,18.69) 48.49,18.56 48.49,16.96 U154.53
  BOTTOM w0.254: v2(38.3,16.77) 38.42,16.9 47.72,16.9 48.49,17.67 48.49,18.56 v2(48.62,18.69)
MIC1_R_P: length 17
  TOP w0.254: U154.54 48.04,16.96 48.04,18.56 v2(47.91,18.69) ; v2(38.3,17.48) 38.17,17.36 37.55,17.36 37.32,17.59 C491.2 36.53,17.59 36.19,17.93 R674.2 35.46,17.9 R685.2
  BOTTOM w0.254: v2(38.3,17.48) 38.42,17.36 47.53,17.36 48.04,17.86 48.04,18.56 v2(47.91,18.69)
