# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1V1_VDDUSB: length 15
  TOP w0.254: U11.25 v2(67.91,163.05) ; U11.37 v2(74.9,168.18) ; U11.60 v2(65.91,176.81) ; U11.63 v2(64.41,176.81) ; v2(64.65,162.99) 64.91,163.25 U11.19 ; v2(75.05,172.43) 74.52,172.43 74.26,172.18 U11.45 ; U11.53 v2(69.41,176.81)
  BOTTOM w0.254: C564.1 64.75,176.47 v2(64.41,176.81) ; C593.1 63.86,163.46 64.33,162.99 v2(64.65,162.99) 65.01,163.35 C592.1 ; C590.1 v2(67.91,163.05) ; C563.1 v2(65.91,176.81) ; C562.1 v2(69.41,176.81)
  vias: v2(60.04,164.02) v2(60.96,164.02)
V1V8_FT2232: length 11
  TOP w0.254: U144.64 183.29,15.43 183.09,15.63 v2(182.62,15.63) 182.62,14.06 TP243.1 ; U144.49 183.57,22.93 183.35,23.15 183.35,23.32 182.78,23.89 C445.2 v2(181.9,23.95) ; U144.12 192.04,13.48 v2(192.04,11.64) ; U144.37 192.04,24.88 v2(192.04,26.66)
V1V8_FT4232: length 51.5
  TOP w0.254: C449.2 208.88,23.85 209.8,22.93 U145.49 ; C449.2 210.85,23.95 v2(210.88,23.98) ; C449.2 208.88,25.03 TP322.1 ; U145.37 218.14,24.88 v2(218.14,26.66) ; U145.12 v2(218.14,11.64) ; U145.64 v2(208.85,15.43)
  L3-SIGNAL1 w0.305: v2(218.14,11.64) 218.14,13.55 217.99,13.7 217.99,15.56 215.67,17.88 212.38,17.88 209.93,15.43 v2(208.85,15.43) 208.22,16.06 206.64,16.06 205.98,16.72 205.98,22.43 207.5,23.95 210.85,23.95 v2(210.88,23.98) 211.67,24.77 211.67,25.67 213.25,27.25 213.77,27.25 214.65,28.13 216.68,28.13 v2(218.14,26.66)
V3V3_DP0: length 1.7
  BOTTOM w0.254: R791.1 126.64,167.75 C580.1
  vias: v2(125.32,174.84) v2(126.13,174.84)
V3V3_DP1: length 1.7
  BOTTOM w0.254: R766.1 106.1,176.33 106.4,176.63 107.2,176.63
  vias: v2(99.37,174.84) v2(100.39,174.84)
V3V3_FT2232: length 22.1
  TOP w0.254: C521.2 v2(175.83,19.38) U147.8 ; v2(194.67,12.66) 195.17,12.16 R701.2 ; U144.31 v2(198.14,22.43) ; U144.50 183.33,22.43 183.12,22.64 v2(182.67,22.64) C456.1 ; U144.56 v2(182.75,19.43) ; U144.42 v2(189.54,26.66) ; v2(197.71,16.67) 197.16,16.67 196.91,16.93 195.99,16.93 U144.20 ; U147.6 v2(178.37,19.07)
  TOP w0.508: TP244.1 199.32,11.13 v2(199.47,10.97)
  BOTTOM w0.254: C1235.1 v2(197.71,16.67) 197.16,16.67 197,16.83 U270.16 ; U259.16 182.92,23.76 182.67,23.52 C456.1
  BOTTOM w0.381: L43.1 v2(194.67,12.66) ; L40.1 v2(185.33,14.17)
  vias: v2(175.83,9.54) v2(177.1,9.54) v2(179.64,9.54) v2(198.82,10.24)
V3V3_FT4232: length 31.5
  TOP w0.254: U145.50 209.54,22.43 209.33,22.64 v2(208.77,22.64) C457.1 ; v2(214.87,26.66) C431.1 U145.42 ; v2(224.18,22.17) 223.66,22.17 223.41,22.43 U145.31 ; U145.56 v2(208.85,19.43) ; v2(223.8,16.67) 223.27,16.67 223.02,16.93 222.09,16.93 U145.20 ; R702.2 221.27,9.93 v2(221.43,9.76) ; U143.16 204.39,16.2 204.18,15.99 v2(204.18,15.46)
  BOTTOM w0.254: C1254.1 C1256.1 R1285.2 ; v2(204.18,15.46) 204.18,15.95 203.81,16.32 R1269.2 R1270.2 ; U273.16 v2(223.8,15.86) ; U275.8 v2(202.38,6.35) ; v2(224.18,22.17) 223.62,22.17 223.39,21.94 U264.16 ; U275.6 v2(204.92,7) ; R1266.2 v2(207.03,16.97)
  BOTTOM w0.381: L41.1 v2(211.35,14.17) ; L42.1 220.61,12.66 222.08,11.18 v2(222.08,10.49)
V3V3_REF_CDCI1: length 6
  TOP w0.254: U40.3 58.55,119.41 58.55,120.66 C166.2
  TOP w0.381: FL8.3 C164.1 C165.1 C166.2
V3V3_REF_CDCI2: length 6
  TOP w0.305: U22.3 113.19,158.18 C81.2
  TOP w0.381: FL1.3 C67.1 C71.1 C81.2
V3V3_VAUX_PCIE0: length 2.1
  BOTTOM w0.127: R825.2 J14.B10
V3V3_VAUX_PCIE1: length 1.9
  BOTTOM w0.127: R872.2 J17.B10
V3V3_VCO_CDCI1: length 6.2
  TOP w0.305: U40.24 60.35,118.61 60.52,118.61 61.04,119.13 61.2,119.13 C167.2
  TOP w0.381: C167.2 C168.1 C169.1 FL9.3
V3V3_VCO_CDCI2: length 6.6
  TOP w0.305: C98.2 111.54,154.95 111.15,155.34 U22.24
  TOP w0.381: C98.2 C102.1 C104.1 FL6.3
V3V3_VDD33USB: length 48.4
  TOP w0.254: U11.31 v2(70.91,163.05) ; U11.2 v2(60.78,173.18) ; U11.20 65.41,163.26 65.45,163.22 v2(65.45,162.88) ; U11.48 v2(74.54,173.68)
  L3-SIGNAL1 w0.381: v2(65.45,162.88) 66.35,163.79 70.17,163.79 v2(70.91,163.05) 72.47,164.62 72.47,166.23 73.67,167.42 76.16,167.42 76.41,167.67 v2(76.8,167.67) v2(77.41,167.67)
  L5-SIGNAL2 w0.381: v2(60.78,173.18) 61.42,173.18 62.52,172.08 63.6,172.08 64.24,172.72 69.66,172.72 70.97,174.03 74.19,174.03 v2(74.54,173.68) 74.2,173.34 74.2,169.93 75.24,168.89 76.31,168.89 76.8,168.4 v2(76.8,167.67)
  BOTTOM w0.254: C573.1 61.03,172.65 60.78,172.9 v2(60.78,173.18) 60.78,173.54 61.03,173.79 C567.1 ; v2(70.91,163.05) C594.1 ; v2(65.45,162.88) 66.15,163.58 C591.1 ; C569.1 v2(74.54,173.68)
V3V3_XDS_FB: length 4.2
  TOP w0.254: C29.2 29.71,172.9 R23.2 29.92,174.22 R17.1 29.11,175.22 28.63,175.7 28.4,175.7 U6.5
V5V0: length 32
  TOP w0.254: U46.6 v2(216.31,100.96)
  L3-SIGNAL1 w0.127: v3(228.11,93.94) 227.81,93.94 227.55,94.2 227.55,95.16 226.61,96.11 216.68,96.11 216.35,96.43 216.35,96.96 216.48,97.09 v3(216.85,97.09)
  L3-SIGNAL1 w0.254: v2(216.31,100.96) 216.31,99.97 216.82,99.46 225.15,99.46 228.86,95.75 v2(228.86,94.35)
V5V0_OPAMP: length 11.3
  TOP w0.254: v2(41.52,20.42) U136.8
  TOP w0.305: 29.74,19.77 C474.1 29.74,19.77 ; 29.74,19.77 U146.8 ; 29.74,19.77 29.74,20.27 29.93,20.45 30.49,20.45 30.83,20.8 v2(30.83,21.13)
  TOP w0.381: U141.8 25.57,23.42 24.8,24.19 C448.1 24.38,23.64 24.01,23.27 v2(23.78,23.27) ; U135.8 v2(31.69,21.22)
  BOTTOM w0.254: v2(30.83,21.13) 31.1,21.39 C1211.1
  vias: v2(24.96,11.56) v2(24.96,10.55)
V5V0_VOUT: length 20.6
  L3-SIGNAL1 w0.381: v2(36.86,30.03) 33.84,30.03 v2(32.24,28.43) 32.24,23.4 33.31,22.33 33.31,19.34 v2(32.5,18.52)
  BOTTOM w0.381: v2(32.24,28.43) 32.11,28.3 R1229.2 ; R1274.2 31.66,17.39 C1230.1 31.66,17.97 32.22,18.52 v2(32.5,18.52)
V12V0_VOUT: length 7
  BOTTOM w0.381: C1249.1 21.97,12.16 23.9,14.09 C1237.1 23.9,16.76 24.68,17.54 U267.8
V12V0_VSUP1: length 14.1
  TOP w0.254: U109.10 26.35,38.87 26.05,39.17 v2(26.05,39.64)
  L5-SIGNAL2 w0.381: v2(26.05,39.64) 20.87,39.64 18.97,37.74 v2(14.35,37.74)
VBAT_XDS: length 3.7
  BOTTOM w0.254: R751.2 C550.1 12.06,179.14 12.06,177.96 U170.68
VBUS_5V_CONN2:
  vias: v2(53.5,179.66) v2(54.48,180.4)
VBUS_USBC_CONN: length 10.6
  TOP w0.254: U8.15 v2(179.5,176.77)
  TOP w0.305: v2(150.82,181.76) J4.A4 ; J4.A9 v2(147.82,181.77)
  BOTTOM w0.254: TP1.1 181.97,187.76 185.02,187.76 185.26,187.52 R732.2
  vias: v2(139.57,179.25) v2(139.57,178.34) v2(147.46,183.4) v2(147.98,183.4) v2(148.07,185.61) v2(148.07,185.1) v2(150.46,183.4) v2(150.57,185.61) v2(150.57,185.1) v2(150.98,183.4) v2(179.74,188.11) v2(180.66,188.11)
VBUS_XDS_USB: length 25.3
  TOP w0.254: v2(25.45,180.63) 24.82,181.26 23.81,181.26 ; U2.6 20.04,182.49 ; U6.8 v2(28.4,178.45)
  L10-SIGNAL4 w0.254: v2(25.45,180.63) 24.47,179.65 24,179.65 23.23,178.88 23.23,167.86 21.65,166.28 v2(21.65,165.3)
  BOTTOM w0.254: v2(28.4,178.45) 27.62,179.23 27.62,179.74 26.72,180.63 v2(25.45,180.63)
VCC1V2_UFS: length 4.2
  TOP w0.203: U26.C5 v2(143.09,148.57) ; v2(143.09,148.57) U26.B5 v2(142.59,148.57) ; v2(143.09,148.57) U26.B4 v2(142.59,148.57) ; v2(143.09,148.57) U26.C4 ; v2(142.59,148.57) U26.A4 v2(142.09,148.57) U26.A5 v2(142.59,148.57) ; U26.E5 v2(144.59,148.57) U26.F5
VCC1V8_EMMC: length 15.8
  TOP w0.203: U52.C6 v2(173.33,97.81) ; U52.N4 U52.P3 178.87,96.31 v2(179.06,96.12) ; U52.N4 U52.M4 177,96.81 v2(176.94,96.87) ; U52.N4 U52.P5
  TOP w0.305: v2(166.06,99.91) R284.1 R293.1 v3(166.06,95.79) v3(166.06,94.42) v3(166.06,93.05) R322.1
  BOTTOM w0.203: C804.1 176.97,96.25 176.69,95.97 176.69,95.54 176.52,95.37 R966.1 ; R961.1 177.78,97.16 177.94,97.01 177.94,96.4
  BOTTOM w0.254: C789.1 173.33,98.08 v2(173.33,97.81)
  vias: v2(166.06,101.28) v2(180.57,97.06)
VCC1V8_UFS: length 4.9
  TOP w0.203: U26.K6 v2(146.59,149.57) U26.K7 ; v2(143.09,149.57) U26.B7 v2(142.59,149.57) ; v2(143.09,149.57) U26.C6 v2(143.59,149.57) U26.C7 v2(143.09,149.57) ; v2(143.09,149.57) U26.B6 v2(142.59,149.57) ; v2(142.59,149.57) U26.A7 v2(142.09,149.57) U26.A6 v2(142.59,149.57)
VCC3V3_EMMC: length 5.5
  TOP w0.203: U52.J10 v2(175.94,99.06) 176.19,99.31 U52.K9 176.7,99.31 v2(176.94,99.07) ; U52.F5 174.56,97.43 v2(174.56,97.75) 174.49,97.81 U52.E6
  BOTTOM w0.381: v2(174.56,97.75) 175.04,97.75 175.27,97.98 175.27,98.84 175.49,99.06 v2(175.94,99.06)
VCC3V3_UFS: length 5.8
  TOP w0.203: U26.B8 v2(143.09,150.57) ; v2(143.09,150.57) U26.C9 143.49,150.82 v2(143.74,150.57) ; v2(143.09,150.57) U26.C8 143.49,150.32 v2(143.74,150.57) ; v2(143.09,150.57) U26.B9 ; U26.N9 v2(148.59,150.57) ; v2(148.59,150.57) U26.N8 ; v2(148.59,150.57) U26.P9 v2(149.09,150.57) U26.P8 v2(148.59,150.57) ; U26.K8 v2(146.28,150.32) ; v2(143.74,150.57) 143.99,150.32 U26.E8
VCC3V3_XDS: length 117.6
  TOP w0.254: R139.1 R140.1 v2(10.07,149.4) ; R19.2 v2(11.25,173.64) ; U10.23 13.19,176.68 C18.2 ; R738.1 8.1,138.49 R742.1 8.76,137.65 9.48,136.94 R1304.2 ; v2(28.14,172.86) C29.1 28.83,173.97 R23.1 ; v2(10.22,178.21) 11.24,178.21 12.42,177.03 C18.2 ; C18.2 12.54,176.72 U10.24 ; C59.1 21.21,161.52 20.96,161.27 v2(20.66,161.27) 20.28,161.27 19.95,161.6 C60.1 ; C15.1 v2(16.66,179.15)
  TOP w0.305: R1304.2 v2(10.07,136.17)
  TOP w0.381: C14.1 21.36,177.08 v2(21.04,176.76) ; v2(10.56,171.46) 10.71,171.31 C31.1
  L7-SIGNAL3 w0.381: v2(11.95,160.73) 11.41,160.73 10.73,160.05 10.73,153.83 11.11,153.45 11.11,150.44 v2(10.07,149.4) v2(10.07,136.17) 10.72,135.52 10.72,113.58 16.19,108.11 16.19,102.01 17.2,101 22.14,101 v2(22.84,100.3)
  BOTTOM w0.203: U170.16 17.26,161.53 17.54,161.25 v2(17.54,160.69) ; v2(21.04,176.76) 20.86,176.94 U170.90 ; U170.26 13.26,162.56 13.26,161.13 v2(12.86,160.73) 12.46,161.13 12.46,162.56 U170.28 ; U170.122 v2(25.99,166.46) ; U170.113 25.71,170.06 v2(25.99,170.34) ; U170.8 20.46,161.47 v2(20.66,161.27) 20.86,161.48 U170.7
  BOTTOM w0.254: v2(6.62,168.43) R789.2 ; v2(16.66,179.15) 16.46,178.95 U170.79 ; U170.39 8.37,166.46 v2(8.17,166.66) ; U170.51 10.36,171.26 v2(10.56,171.46) 10.36,171.66 U170.52 ; R768.2 v2(6.5,175.29) ; U170.47 v2(8.18,169.66) ; U170.69 12.46,177.96 12.46,179.25 12.62,179.41 v2(12.62,179.96) ; R736.1 v2(14.03,184.67) ; v2(25.99,174.78) 25.92,174.86 24.76,174.86 U170.101
  vias: v2(6.5,177.58) v2(9.02,179.96) v2(13.16,167.24) v2(19.22,166.89) v2(26.22,172.24) v2(27.11,172.24) v2(27.87,172.24)
VCC_1V1: length 9.1
  TOP w0.254: C423.1 74.28,29.36 v2(74.09,29.55) ; C442.1 78.04,24.95 v2(78.24,25.14) ; C477.1 v2(73.96,20.66)
  BOTTOM w0.254: U262.31 73.96,28.52 73.96,29.42 v2(74.09,29.55) ; U262.6 73.96,21.52 v2(73.96,20.66) C477.1 ; R1265.1 60.77,16.34 60.63,16.2 v2(59.62,16.2) ; U262.24 v2(68.72,27.77) ; v2(78.24,25.14) 78.1,25.27 U262.42
  vias: v2(39.4,168.03) v2(40.39,168.03) v2(55.86,165.21) v2(56.78,165.21) v2(58.86,16.2) v2(69.13,29.01) v2(69.68,29.84) v2(70.05,29.01)
VCC_1V2: length 11
  TOP w0.305: v2(100.34,124.31) 100.86,123.8 C157.1 ; C151.1 114.04,125.63 v2(114.19,125.49) ; C136.1 v2(103.52,134.94) ; C148.1 v2(114.16,126.81)
  BOTTOM w0.254: 92.99,128.86 92.99,129.62 92.65,129.95 R866.1 ; v2(114.19,125.49) 114.01,125.31 U187.62 ; v2(112.97,133.01) U187.49 ; U187.17 v2(100.34,124.31) ; U187.59 v2(114.16,126.81)
  BOTTOM w0.305: U187.33 103.52,134.94 v2(103.52,134.94)
  vias: v2(83.18,129.55) v2(97.19,133.29) v2(98.2,133.29) v2(98.84,133.29) v2(137.4,154.55) v2(137.4,153.64) v2(138.31,154.55) v2(138.31,153.64)
VCC_12V0: length 114.1
  TOP w0.254: R724.1 116.69,7.7 v2(117.79,7.7) U148.10
  L7-SIGNAL3 w0.508: v2(117.79,7.7) 119.5,9.41 170.51,9.41 173.45,6.48 183.63,6.48 186.34,3.77 221.84,3.77 J47.2
  vias: v2(14.1,31.76) v2(14.1,30.74) v2(15.12,31.76) v2(15.12,30.74) v2(16.13,31.76) v2(16.13,30.74) v2(22.03,4.73) v2(38.34,81.21) v2(38.34,80.3) v2(39.3,81.21) v2(39.3,80.3) v2(40.27,81.21) v2(40.27,80.3) v2(161.14,165.5) v2(161.14,164.49) v2(162.28,165.5) v2(162.28,164.49) v2(163.42,165.5) v2(163.42,164.49) v2(202.26,61.53) v2(214.17,28.7) v2(214.8,28.7) v2(215.44,28.7) v2(217.79,80.63) v2(217.79,79.71) v2(218.5,80.63) v2(218.5,79.71) v12(222.82,79.59) v12(222.82,77.55) v12(224.6,79.59) v12(224.6,77.55) v12(226.37,79.59) v12(228.05,76.61) v12(228.05,74.84) v12(228.05,73.06)
VCC_12V0_IN+: length 4.8
  BOTTOM w0.127: R1082.1 240.01,68.59 C1057.2 240.01,67.02 239.8,66.81 U239.10 239.8,64.85 U238.D3
VCC_12V0_IN-: length 6.3
  BOTTOM w0.127: 239.09,67.02 238.8,66.73 U239.8 238.8,64.86 238.6,64.66 238.6,64.45 ; 239.09,67.02 C1057.1 239.09,68.59 R1083.1 ; 239.09,67.02 239.3,66.81 U239.9 ; U238.D1 238.6,64.45 ; 238.6,64.45 U238.D2
VCC_12V0_N: length 10.8
  TOP w0.127: R418.1 v2(233.95,72.76)
  BOTTOM w0.127: R1083.2 239.39,69.96 239.39,70.29 239.14,70.55 233.39,70.55 232.99,70.95 232.99,71.99 233.3,72.3 233.84,72.3 233.95,72.41 v2(233.95,72.76)
VCC_12V0_P: length 10.2
  TOP w0.127: R418.4 v2(233.95,71.58)
  BOTTOM w0.127: R1082.2 239.7,69.97 239.7,70.42 239.26,70.85 233.52,70.85 233.29,71.08 233.29,71.86 233.43,72 233.81,72 233.94,71.87 233.94,71.59 v2(233.95,71.58)
VCC_CSI_IO: length 23.4
  TOP w0.254: R501.1 R510.1 212.07,50.4 211.72,50.05 211.24,50.05 v2(211.23,50.05) 210.65,50.05 210.5,49.9 U88.2 ; U80.1 196.6,55.8 v2(196.66,55.86) ; TP225.1 v2(180.63,26.88)
  L3-SIGNAL1 w0.305: v2(186.75,57.46) 186.75,56.65 186.5,56.4 186.5,55.66 187.21,54.95 188.86,54.95 189.93,53.88 192.82,53.88 v2(193.41,54.47)
  BOTTOM w0.254: R1134.1 v2(186.75,57.46) ; v2(180.63,26.88) 179.52,26.88 v2(179.48,26.92) R1241.2 R1240.2 ; v2(193.41,54.47) 193.91,54.97 U242.2
  vias: v2(199.89,42.13) v2(199.89,41.22) v2(200.81,42.13) v2(200.81,41.22) v2(202.88,95.94) v2(202.88,95.03) v2(203.79,95.94) v2(203.79,95.03)
VCC_LM5141: length 4.4
  TOP w0.254: D38.2 212.49,56.59 211.5,57.58 C308.1 209.97,57.94 U81.10
VCC_USBC_PD_5V: length 5.3
  TOP w0.254: U8.21 176.01,178.42 176.34,178.74 176.34,179.75 C8.1 C6.2 175.98,181.88 v2(176.72,182.61)
  vias: v2(176.74,181.69)
VCCA_1V2: length 25.7
  TOP w0.305: C140.1 109.17,134.63 108.86,134.93 v2(108.71,134.93) ; v2(107.34,134.93) 107.19,134.93 106.88,134.63 C138.1 ; C137.1 v2(105.03,134.94) ; v2(102.76,125.29) 102.76,125.19 102.38,124.81 C152.1 ; C141.1 v2(111.02,134.94)
  BOTTOM w0.254: v2(107.34,134.93) 107.52,134.75 U187.41 ; U187.43 108.52,134.75 v2(108.71,134.93) ; v2(109.63,120.6) 109.63,120.66 110.02,121.05 U187.3 ; v2(102.76,125.29) 102.76,125.07 102.51,124.81 U187.18 ; U187.14 C711.1
  BOTTOM w0.305: v2(109.63,120.6) 109.64,120.6 109.64,120.07 109.41,119.84 104.83,119.84 104.52,120.15 C711.1 ; v2(111.02,134.94) U187.48 ; FL63.1 99.99,133.35 100.15,133.19 C685.1 100.15,131.62 100.46,131.31 U187.31 ; U187.36 v2(105.02,134.94)
  vias: v2(101.41,134.94) v2(102.43,134.94)
VCCA_3V3: length 184.5
  TOP w0.254: v2(167.55,51.16) 167.55,51.8 167.29,52.05 R504.2 ; C260.1 173.4,81.87 ; v4(80.31,65.01) 80.31,65.07 81.07,65.83 U75.4 ; U62.4 81.73,78.96 82.03,78.67 C266.1 83.04,77.91 v4(83.14,77.8) ; U87.8 180.21,48.21 180.07,48.07 C354.1 181.2,47.48 v2(181.49,47.77) R538.2 ; R1309.1 79.56,69.47 ; U68.12 v4(172.86,71.82) ; C261.1 178.76,81.87 ; 74.91,73.21 v4(74.94,73.18) 74.87,73.11 ; U70.4 73.45,70.88 73.45,72.36 v2(73.42,72.4) 73.92,72.4 74.1,72.22 74.1,71.28 74.23,71.15 74.23,67.56 73.93,67.26 C1269.1 74.23,66.67 74.48,66.93 U279.5 ; U89.8 172.69,50.64 v2(172.88,50.83) 172.88,51.99 C331.1 ; U68.48 176.83,77.48 176.63,77.27 v2(176.26,77.27) ; Q3.4 v2(158.34,49.75)
  TOP w0.305: U68.10 v4(172.86,72.82) ; U68.35 180.91,73.82 v2(181.03,73.95) ; 173.83,78.86 U68.54 ; v2(171.26,75.8) 171.28,75.82 U68.4 ; U68.45 178.33,78.86 ; U68.8 v4(172.86,73.82)
  TOP w0.381: R1310.1 v2(155.01,48.2)
  L7-SIGNAL3 w0.305: v2(172.88,50.83) 172.88,50.52 174.53,48.87 180.4,48.87 v2(181.49,47.77)
  L7-SIGNAL3 w0.381: v2(158.34,49.75) 156.79,48.2 v2(155.01,48.2)
  L9-PWR2 w0.381: v2(128.99,26.93) 129.54,26.39 138.72,26.39 139.72,27.38 157.56,27.38 159.77,25.18 171.29,25.18 v2(171.93,25.82)
  L14-SIGNAL6 w0.203: v11(175.97,70.8) 173.88,70.8 v4(172.86,71.82)
  L14-SIGNAL6 w0.254: v2(227.6,14.07) v2(229.55,14.07) ; v2(187.46,63.57) 187.46,64.65 188.86,66.05 190.48,66.05 191.87,67.44 199.71,67.44 v2(200.55,68.28)
  L14-SIGNAL6 w0.305: v2(227.6,14.07) 225.45,14.07 224.76,13.38 210.7,13.38 206.92,9.6 197.87,9.6 197.46,10.01 182.46,10.01 175.09,17.38 175.09,23.57 v2(172.84,25.82)
  BOTTOM w0.254: v2(174.03,87.41) 174.51,87.89 R982.1 ; U234.5 v2(200.55,68.28)
  vias: v2(72.54,116.62) v2(165.86,121.27) v2(172.73,121.96) v2(172.65,86.01) v2(172.78,88.04) v2(172.78,87.41) v2(172.78,86.77) v2(178.13,88.17) v2(178.13,87.41) v2(178.13,86.65) v2(178.37,86.01) v2(179.39,87.41) v2(181.71,53.42) v2(182.68,92.4) v2(182.68,91.48) v2(182.68,90.57) v2(182.68,89.65) v2(182.68,88.74) v2(183.6,92.4) v2(183.6,91.48) v2(183.6,90.57) v2(183.6,89.65) v2(183.6,88.74) v2(184.51,91.48) v2(184.51,90.57) v2(184.51,89.65) v2(184.51,88.74) v4(75.83,73.18) v4(76.72,73.18) v4(78.39,77.8) v4(79.41,77.8) v4(79.59,68.87) v4(80.35,68.87) v4(85.4,73.18) v4(86.1,73.18) v4(86.25,77.8) v4(87.22,77.8) v4(88.18,77.8) v4(107.33,118.63) v4(107.33,117.99) v4(160.46,52.74) v4(160.59,53.63) v4(161.48,53.63) v4(173.09,81.15) v4(173.09,80.21) v4(173.72,81.15) v4(173.72,80.21) v4(178.44,81.15) v4(178.44,80.21) v4(179.08,81.15) v4(179.08,80.21) v4(182.32,74.51) v4(182.32,73.87) v4(183.26,74.51) v4(183.26,73.87)
VCCA_3V3_CORE: length 0.8
  TOP w0.254: U42.11 v2(73.98,115.65)
  vias: v2(70.3,115.98) v2(70.3,113.7) v2(70.38,102.52) v2(75.11,128.07) v2(75.11,127.05) v2(75.11,126.04) v2(75.11,123.9) v2(75.11,122.89) v2(75.11,121.87) v2(76.13,128.07) v2(76.13,127.05) v2(76.13,126.04) v2(76.13,123.9) v2(76.13,122.89) v2(76.13,121.87) v2(77.14,128.07) v2(77.14,127.05) v2(77.14,126.04) v2(77.14,123.9) v2(77.14,122.89) v2(77.14,121.87) v4(75.08,117.89) v4(75.08,116.49) v4(75.08,110.9) v4(75.08,109.51) v4(75.08,106.71) v4(75.08,105.32) v4(75.08,99.73) v4(75.08,98.33) v4(76.68,117.89) v4(76.68,116.49) v4(76.68,110.9) v4(76.68,109.51) v4(76.68,106.71) v4(76.68,105.32) v4(76.68,99.73) v4(76.68,98.33)
VCCA_3V3_CORE_IN+: length 4.8
  BOTTOM w0.127: U204.D3 66.62,112.19 U203.10 66.62,114.15 66.83,114.36 C722.2 66.83,115.4 66.94,115.51 R927.1
VCCA_3V3_CORE_IN-: length 6.3
  BOTTOM w0.127: 65.91,114.36 C722.1 65.91,115.44 65.79,115.55 R928.1 ; 65.91,114.36 66.12,114.15 U203.9 ; 65.91,114.36 65.62,114.07 U203.8 65.62,112.21 65.42,112.01 65.42,111.79 ; 65.42,111.79 U204.D1 ; 65.42,111.79 U204.D2
VCCA_3V3_CORE_N: length 19.2
  TOP w0.127: R185.5 v2(76.34,124.97)
  L3-SIGNAL1 w0.089: v2(76.34,124.97) 76.37,124.95 77.45,124.95 77.58,124.82 77.58,124.67 77.48,124.57 71.29,124.57 66.23,119.51 66.23,118.82 v2(65.66,118.25)
  BOTTOM w0.127: R928.2 66.21,117.3 66.21,118.12 66.08,118.25 v2(65.66,118.25)
VCCA_3V3_CORE_P: length 19.7
  TOP w0.127: R185.2 v2(79.44,124.97)
  L3-SIGNAL1 w0.089: v2(79.44,124.97) 77.92,124.97 77.8,124.85 77.8,124.58 77.56,124.34 71.37,124.34 66.45,119.42 66.45,118.87 v2(67.07,118.25)
  BOTTOM w0.127: R927.2 66.51,117.31 66.51,118.12 66.64,118.25 v2(67.07,118.25)
VCCA_3V3_CPU_AVS: length 0.7
  TOP w0.254: U35.11 v2(171.57,121.12)
  vias: v2(169.02,124.8) v2(171.31,124.8) v2(180.22,124.88) v2(191.6,124.83) v4(163.32,125.54) v4(163.83,124.31) v4(164.34,126.3) v4(164.34,125.54) v4(164.59,129.57) v4(164.59,128.32) v4(164.84,124.31) v4(165.35,126.3) v4(165.45,129.57) v4(165.45,128.32) v4(165.46,120.02) v4(165.46,118.42) v4(166.37,129.57) v4(166.37,128.32) v4(166.37,126.3) v4(166.86,120.02) v4(166.86,118.42) v4(167.38,129.57) v4(167.38,128.32) v4(167.38,126.3) v4(168.4,129.57) v4(168.4,128.32) v4(172.45,120.02) v4(172.45,118.42) v4(173.85,120.02) v4(173.85,118.42) v4(176.89,120.02) v4(176.89,118.42) v4(178.29,120.02) v4(178.29,118.42) v4(183.88,120.02) v4(183.88,118.42) v4(185.28,120.02) v4(185.28,118.42) v4(188.07,120.02) v4(188.07,118.42) v4(189.47,120.02) v4(189.47,118.42) v4(195.06,120.02) v4(195.06,118.42) v4(196.45,120.02) v4(196.45,118.42)
VCCA_3V3_CPU_AVS_IN+: length 4.8
  TOP w0.127: U31.D3 204.17,134.94 U32.10 204.17,132.9 204.38,132.69 C146.2 204.38,131.73 204.5,131.62 R179.1
VCCA_3V3_CPU_AVS_IN-: length 6.3
  TOP w0.127: U32.9 203.67,132.98 203.46,132.77 ; 203.46,132.77 203.17,133.06 U32.8 203.17,134.91 202.97,135.11 202.97,135.34 ; 203.46,132.77 C146.1 203.46,131.69 203.35,131.58 R178.1 ; 202.97,135.34 U31.D2 ; 202.97,135.34 U31.D1
VCCA_3V3_CPU_AVS_N: length 52.2
  TOP w0.127: R178.2 203.78,129.82 203.78,129.01 203.65,128.88 v2(203.22,128.88) ; R180.5 v2(161.81,127.51)
  L12-SIGNAL5 w0.102: v2(161.81,127.51) 160.63,127.51 160.36,127.24 160.36,125.41 160.69,125.08 168.13,125.08 168.82,125.77 201.49,125.77 203.72,128 203.72,128.78 203.62,128.88 v2(203.22,128.88)
VCCA_3V3_CPU_AVS_P: length 53.2
  TOP w0.127: R180.2 v2(158.76,127.51) ; R179.2 204.08,129.83 204.08,129.01 204.21,128.88 v2(204.63,128.88)
  L12-SIGNAL5 w0.102: v2(158.76,127.51) 159.83,127.51 160.05,127.29 160.05,125.28 160.56,124.77 168.26,124.77 168.95,125.46 201.62,125.46 204.03,127.87 204.03,128.78 204.13,128.88 v2(204.63,128.88)
VCCA_3V3_DDR: length 2.1
  TOP w0.305: U68.17 173.83,69.15 173.64,68.95 ; U68.26 178.33,69.18
  vias: v2(172.78,65.9) v2(174.03,65.9) v2(178.13,65.9) v2(179.39,65.9) v2(189.73,88.25) v2(189.73,87.34) v2(189.73,86.42) v2(190.64,88.25) v2(190.64,87.34) v2(190.64,86.42) v2(191.56,88.25) v2(191.56,87.34) v2(191.56,86.42) v2(192.47,88.25) v2(192.47,87.34) v2(192.47,86.42) v4(173.09,67.94) v4(173.09,67) v4(173.72,67.94) v4(173.72,67) v4(178.44,67.94) v4(178.44,67) v4(179.08,67.94) v4(179.08,67)
VCCA_3V3_DDR_IN+: length 4.8
  BOTTOM w0.127: R974.1 191.54,84.27 191.65,84.16 C801.2 192.69,84.16 192.9,83.95 U212.10 194.86,83.95 U211.D3
VCCA_3V3_DDR_IN-: length 6.3
  BOTTOM w0.127: R973.1 191.5,83.13 191.61,83.24 C801.1 192.69,83.24 ; 195.26,82.75 195.04,82.75 194.84,82.95 U212.8 192.98,82.95 192.69,83.24 ; 195.26,82.75 U211.D1 ; 195.26,82.75 U211.D2 ; U212.9 192.9,83.45 192.69,83.24
VCCA_3V3_DDR_N: length 10.2
  TOP w0.127: R338.1 188.99,88.97 v2(188.41,88.97)
  BOTTOM w0.127: v2(188.41,88.97) 188.78,88.6 188.78,88.2 187.49,86.9 187.49,83.85 187.82,83.52 188.27,83.52 TP301.1 188.8,83.41 188.93,83.54 189.75,83.54 R973.2
VCCA_3V3_DDR_P: length 10.8
  TOP w0.127: R338.4 188.99,89.89 v2(188.41,89.89)
  BOTTOM w0.127: v2(188.41,89.89) 189.11,89.18 189.11,88.09 187.79,86.77 187.79,84.04 188.01,83.83 188.22,83.83 TP302.1 188.8,83.97 188.93,83.85 189.74,83.85 R974.2
VCCAD_5V0: length 23.3
  TOP w0.254: C505.1 39.81,14.12 39.94,13.99 U154.3 ; C483.1 C482.1 51.09,18.88 50.51,18.31 U154.49
  TOP w0.381: C505.1 v2(38.02,14.12)
  L3-SIGNAL1 w0.381: v2(38.02,14.12) 40.23,14.12 42.55,16.44 51.14,16.44 v2(52.99,18.3)
VCCDA_5V0: length 26.2
  TOP w0.254: C529.1 C528.1 53.71,8.11 53.58,7.99 U154.34 ; C527.1 39.81,8.61 39.94,8.49 U154.14
  TOP w0.381: C527.1 v2(38.02,8.61)
  L7-SIGNAL3 w0.508: v2(38.02,8.61) 38.45,9.05 49.72,9.05 50.61,8.16 57.02,8.16 v2(57.31,8.45)
VDD1_DDR_1V8: length 47
  TOP w0.254: v2(176.41,49.47) 176.81,49.88 U87.4
  TOP w0.305: U54.U12 146.33,93.28 v2(145.83,93.37) ; U54.G9 v2(148.33,87.1) ; v2(152.33,70.97) 152.73,71.3 U71.T4 ; v2(148.33,92.31) 148.73,92.63 U54.T9 ; U71.G4 v2(153.13,65.12) ; v2(145.96,64.5) 145.96,64.49 U71.F12 ; U71.U12 146.33,71.95 v2(145.8,72.27) ; v2(155.53,92.96) 155.13,93.28 U54.U1 ; U71.F1 v2(155.53,64.47) ; U54.F12 v2(145.93,85.8) ; U71.G9 v2(148.33,65.77) ; U71.T9 148.73,71.3 v2(148.33,70.97) ; v2(152.33,92.31) 152.73,92.63 U54.T4 ; v2(155.53,71.62) 155.13,71.95 U71.U1 ; U54.G4 v2(152.33,86.45) ; U54.F1 v2(155.53,85.8)
  L10-SIGNAL4 w0.305: v2(176.41,49.47) 175.69,50.19 171.71,50.19 170.8,51.1 168.74,51.1 167.63,49.99 161.63,49.99 160.88,49.24 155.21,49.24 153.83,50.62 v4(153.83,52.31)
  BOTTOM w0.254: C884.1 145.79,85.66 v2(145.93,85.8) ; v2(145.96,64.5) 145.79,64.34 C1024.1
  BOTTOM w0.305: C814.1 145.77,93.3 v2(145.83,93.37) 146.36,92.84 147.8,92.84 v2(148.33,92.31) ; C1066.1 155.61,71.7 v2(155.53,71.62) ; C817.1 156.39,93.04 155.61,93.04 v2(155.53,92.96) ; v2(148.33,70.97) 147.63,71.67 146.53,71.67 v2(145.8,72.27) 145.49,72.08 C1068.1
  vias: v2(146.37,81.65) v2(147.07,80.25) v2(148.47,99.3) v2(148.57,78.34) v2(148.7,59.34) v2(151.52,80.25) v2(152.89,98.9) v2(153.02,78.34) v2(152.99,58.75) v2(155.33,97.79) v2(155.33,76.45) v2(157.84,81.77) v4(150.74,56.93) v4(152.14,101.25) v4(153.83,54.24) v4(153.83,53.27) v4(154.52,52.81)
VDD1_DDR_1V8_IN+: length 4.8
  TOP w0.127: U129.D3 153.84,29.32 U128.10 153.84,31.36 153.63,31.57 153.63,31.94 ; 153.63,31.94 C402.2 153.63,31.94 ; 153.63,31.94 153.63,32.53 153.52,32.64 R594.1
VDD1_DDR_1V8_IN-: length 7.9
  TOP w0.127: R595.1 154.66,32.68 154.55,32.57 C402.1 154.55,31.49 ; U129.D2 154.84,28.92 154.34,29.42 U128.9 154.34,31.28 154.55,31.49 ; 154.55,31.49 154.84,31.2 U128.8 154.83,30.32 154.83,29.38 155.24,28.98 U129.D1
VDD1_DDR_1V8_N: length 25.5
  TOP w0.127: R595.2 154.66,34.64 154.79,34.77 v2(154.79,35.38)
  L7-SIGNAL3 w0.109: v2(154.59,55.06) 154.8,55.27 154.8,55.78 154.65,55.92 154.14,55.92 153.32,55.1 153.32,51.51 152.04,50.23 152.04,45.07 154.27,42.85 154.27,35.9 v2(154.79,35.38)
VDD1_DDR_1V8_P: length 26.7
  TOP w0.127: v2(153.38,35.38) 153.38,34.76 153.52,34.62 R594.2
  L7-SIGNAL3 w0.109: v2(153.38,35.38) 154.03,36.03 154.03,42.6 151.7,44.93 151.7,50.38 152.97,51.65 152.97,55.24 154,56.27 154.8,56.27 155.31,55.75 v2(155.31,55.06)
VDD1_DDR_1V8_PG: length 4.4
  TOP w0.127: R1300.2 TP173.1 163.12,51.49 R511.1 160.85,51.49 160.74,51.59 U85.5
VDD1_DDR_1V8_REG: length 7.3
  L7-SIGNAL3 w0.381: v2(155.39,52.88) 157.89,50.38 161.24,50.38 v2(161.51,50.65)
VDD12_CDCI1: length 6.3
  TOP w0.254: U40.16 58.55,113.88 C187.2
  TOP w0.381: FL27.3 58.91,109.13 58.91,109.93 58.86,109.99 C197.1 C191.1 C187.2
VDD12_CDCI2: length 6.3
  TOP w0.305: U22.16 106.76,158.18 106.46,157.87 C87.2
  TOP w0.381: C87.2 C86.1 C85.1 102.76,157.87 102.6,157.71 FL4.3
VDD34_CDCI1: length 6.5
  TOP w0.254: U40.15 58.05,113.88 C186.2
  TOP w0.381: C186.2 C190.1 C196.1 57.74,109.49 FL26.3
VDD34_CDCI2: length 6.3
  TOP w0.305: C74.2 106.49,158.99 106.79,158.68 U22.15
  TOP w0.381: C74.2 C73.1 C72.1 102.88,158.99 102.72,159.14 FL3.3
VDD_1V0: length 8.4
  TOP w0.254: v2(110.75,30.18) 110.75,31.07 110.96,31.27 R611.1 ; v2(99.74,29.55) 99.93,29.36 C425.1 ; C443.1 103.7,24.95 v2(103.89,25.14)
  BOTTOM w0.254: U261.24 v2(94.37,27.77) ; U261.6 99.61,21.52 v2(99.61,20.66) C1222.1 ; U261.42 103.76,25.27 v2(103.89,25.14) ; v2(99.74,29.55) 99.61,29.42 99.61,28.52 U261.31
  vias: v2(94.79,29.01) v2(95.7,29.01) v2(110.75,29.27) v2(111.95,29.76)
VDD_1V8_CDCEL: length 9.2
  TOP w0.381: U23.3 88.78,156.09 88.53,156.34 C89.1 C83.1 C75.1 88.53,160.24 FL2.3 87.45,160.7 86.29,159.54 R99.2
VDD_2V5: length 17.9
  TOP w0.254: C476.1 v2(72.46,20.66) ; TP232.1 84.97,21.98 v2(84.97,21.94) ; C478.1 v2(75.46,20.66)
  L7-SIGNAL3 w0.381: v2(84.21,21.94) 84.21,25.72 83.58,26.35 83.58,29.07 85.66,31.15 v2(85.66,31.74)
  BOTTOM w0.254: v2(84.97,21.94) 85.77,21.94 86.06,22.23 R1248.1 ; U262.3 75.46,21.52 v2(75.46,20.66) C478.1 ; U262.9 v2(72.46,20.66) C476.1
VDD_CORE_0V8: length 279.2
  TOP w0.254: U48.3 v2(73.98,100.59) ; U87.10 181.39,50.38 arc(181.49,50.36) 181.57,50.31 182.01,49.87 arc(182.09,49.81) 182.19,49.79 v2(182.47,49.79) ; U42.3 v2(73.98,111.77)
  TOP w0.305: U59.AB25 114.32,85.44 v2(113.92,85.83) ; U59.N14 123.12,78.23 v2(123.52,77.83) ; U59.M13 123.92,77.43 v2(124.32,77.03) ; v2(114.72,88.23) 115.12,87.84 U59.AE24 ; U59.AD11 125.52,87.03 v2(125.92,87.43) ; U59.W26 113.52,83.04 v2(113.12,83.43) ; U59.U26 113.51,81.43 v2(113.12,81.03) ; v2(122.72,87.43) 122.32,87.03 U59.AD15 ; U59.L14 123.12,76.63 v2(123.52,76.23) ; v2(126.72,77.83) 126.32,78.23 U59.N10 ; U59.K17 120.71,75.83 v2(120.32,75.43) ; U59.AA26 113.52,84.64 v2(113.12,85.03) ; U59.N24 115.11,78.23 v2(114.72,77.83) ; U59.AC24 115.12,86.24 v2(114.72,86.63) ; U59.N16 121.52,78.23 v2(121.92,77.83) ; v2(121.92,88.23) 121.52,87.83 U59.AE16 ; U59.AB27 112.72,85.44 v2(112.32,85.83) ; v2(116.32,88.23) 116.72,87.84 U59.AE22 ; U59.R22 116.71,79.83 v2(116.32,79.43) ; U59.AD27 112.72,87.04 v2(112.32,87.43) ; U59.T23 115.91,80.63 v2(115.52,80.23) ; v2(115.52,87.43) 115.92,87.04 U59.AD23 ; U59.AE14 123.12,87.83 v2(123.52,88.23) ; v2(117.92,88.23) 118.32,87.84 U59.AE20 ; U59.AD21 117.52,87.04 v2(117.12,87.43) ; v2(125.92,75.43) 125.52,75.83 U59.K11 ; U59.AC28 111.92,86.24 v2(111.52,86.63) ; U59.AE18 119.92,87.84 v2(119.52,88.23) ; v2(127.52,78.63) 126.98,79.1 127.12,79.03 U59.P9 ; v2(113.92,78.63) 114.31,79.03 U59.P25 ; v2(118.72,89.03) 119.12,88.64 U59.AF19 ; v2(116.32,83.43) 116.72,83.04 U59.W22 ; v2(114.72,85.03) 115.12,84.64 U59.AA24 ; U59.V23 115.92,82.24 v2(115.52,82.63) ; v2(126.72,79.43) 126.32,79.83 U59.R10 ; U59.AA28 111.92,84.64 v2(111.52,85.03) ; U59.U22 116.71,81.43 v2(116.32,81.03) ; U59.K15 122.32,75.83 v2(122.72,75.43) ; U59.V27 112.72,82.24 v2(112.32,82.63) ; v2(126.72,76.23) 126.32,76.63 U59.L10 ; U59.AD25 114.32,87.04 v2(113.92,87.43) ; U59.AE12 124.72,87.83 v2(125.12,88.23) ; v2(127.52,75.43) 127.12,75.83 U59.K9 ; U59.M9 127.12,77.43 v2(127.52,77.03) ; v2(113.12,77.83) 113.51,78.23 U59.N26 ; U59.W28 111.92,83.04 v2(111.52,83.43) ; U59.R24 115.11,79.83 v2(114.72,79.43) ; U59.AC26 113.52,86.24 v2(113.12,86.63) ; v2(120.32,87.43) 120.72,87.04 U59.AD17 ; U59.N12 124.72,78.23 v2(125.12,77.83) ; U59.W24 115.12,83.04 v2(114.72,83.43) ; U59.L16 121.52,76.63 v2(121.92,76.23) ; v2(113.92,80.23) 114.31,80.63 U59.T25 ; U59.AB23 115.92,85.44 v2(115.52,85.83) ; v2(120.32,77.03) 120.71,77.43 U59.M17 ; U59.U28 111.91,81.43 v2(111.52,81.03) ; U59.R26 113.51,79.83 v2(113.12,79.43) ; v2(126.72,88.23) 126.32,87.83 U59.AE10 ; U59.Y23 115.92,83.84 v2(115.52,84.23) ; U59.Y27 112.72,83.84 v2(112.32,84.23) ; U59.L12 124.72,76.63 v2(125.12,76.23) ; U59.M15 122.32,77.43 v2(122.72,77.03) ; v2(114.72,81.03) 115.11,81.43 U59.U24 ; U59.N22 116.71,78.23 v2(116.32,77.83) ; U59.M11 125.52,77.43 v2(125.92,77.03) ; U59.AE28 111.92,87.84 v2(111.52,88.23) ; U59.AC22 116.72,86.24 v2(116.32,86.63) ; U59.P11 125.52,79.03 v2(125.92,78.63)
  TOP w0.381: TP70.1 65.17,103.33 R266.1
  L5-SIGNAL2 w0.127: v2(73.98,100.59) 72.91,101.67 72.91,102.82 71.61,104.12 71.61,109.98 72.85,111.22 arc(72.89,111.25) 72.94,111.26 73.42,111.26 arc(73.47,111.27) 73.51,111.3 v2(73.98,111.77)
  L8-PWR1 w0.508: 96.81,84.36 96.76,84.31 96.76,82.72 arc(96.72,82.52) 96.61,82.36 94.57,80.32 92.52,80.32 91.07,78.87 82.27,78.87 81.47,78.07 81.47,77.19 82.18,76.48 83.45,76.48 v2(84.08,75.85)
  L10-SIGNAL4 w0.127: v2(182.47,49.79) 181.76,49.79 arc(181.71,49.78) 181.67,49.76 178.41,46.5 arc(178.37,46.47) 178.32,46.46 170.15,46.46 arc(170.1,46.45) 170.06,46.43 166.87,43.24 arc(166.83,43.22) 166.78,43.21 148.8,43.21 arc(148.75,43.22) 148.71,43.24 141.38,50.57 136.89,50.57 121.06,66.4 121.06,75.38 v2(121.92,76.23)
  L14-SIGNAL6 w0.127: v2(118.72,89.03) 118.33,88.65 111.36,88.65 111.33,88.67 109.79,88.67 108.24,87.12 91.32,87.12 88.44,90 88.44,97.14 86.88,98.7 84.62,98.7 83.42,99.9 78.47,99.9 77.78,100.59 v2(73.98,100.59)
  BOTTOM w0.127: TP70.1 66.14,103.06 75.9,93.29 84.21,93.29 91.39,86.11 92.96,86.11 94.67,84.41 112.01,84.41 U50171.3
  BOTTOM w0.254: U50104.3 111.53,86.61 v2(111.52,86.63) ; v2(125.12,76.23) 125.08,76.2 U50147.1 ; v2(114.72,77.83) 114.72,77.83 U50131.3 ; v2(116.32,77.83) 116.31,77.83 U50131.1 ; v2(113.12,86.63) 113.1,86.61 U50104.1 ; v4(88.39,111.6) U5075.3 ; v4(90.68,110.46) U5077.1 ; v2(127.52,75.43) 127.52,75.43 U50159.1 ; U50147.3 123.55,76.2 v2(123.52,76.23) ; v4(90.68,111.6) U5074.1 ; U50174.3 114.7,85.01 v2(114.72,85.03) ; v4(88.39,112.75) U5073.3 ; v2(113.12,85.03) 113.13,85.01 U50174.1 ; v2(116.32,79.43) 116.31,79.43 U50105.3 ; v4(88.39,109.32) U5080.1 ; v2(116.32,81.03) 116.31,81.03 U50105.1 ; v4(88.39,110.46) U5078.1 ; v4(88.39,113.89) U5064.3 ; U50159.3 v2(127.52,77.03) ; v4(90.68,112.75) U5072.1 ; v4(90.68,109.32) U5079.1
  BOTTOM w0.305: 94.39,101.12 v4(94.29,101.12)
  vias: v4(80.82,114.84) v4(80.82,114.08) v4(80.82,113.32) v4(80.82,112.55) v4(80.82,103.66) v4(80.82,102.9) v4(80.82,102.14) v4(80.82,101.38) v4(81.09,118.27) v4(81.09,117) v4(81.09,110.4) v4(81.09,109) v4(81.09,107.09) v4(81.09,105.7) v4(81.09,99.22) v4(81.09,97.82) v4(81.72,118.27) v4(81.72,117) v4(81.72,110.4) v4(81.72,109) v4(81.72,107.09) v4(81.72,105.7) v4(81.72,99.22) v4(81.72,97.82) v4(81.83,114.84) v4(81.83,114.08) v4(81.83,113.32) v4(81.83,112.55) v4(81.83,103.66) v4(81.83,102.9) v4(81.83,102.14) v4(81.83,101.38) v4(84.19,112.75) v4(84.19,111.6) v4(84.19,110.46) v4(84.19,109.32) v4(84.19,105.38) v4(84.19,104.24) v4(84.19,103.09) v4(84.19,101.95) v4(84.76,115.8) v4(85.34,112.75) v4(85.34,111.6) v4(85.34,110.46) v4(85.34,109.32) v4(85.34,105.38) v4(85.34,104.24) v4(85.34,103.09) v4(85.34,101.95) v4(85.97,115.8) v4(86.48,112.75) v4(86.48,111.6) v4(86.48,110.46) v4(86.48,109.32) v4(86.48,105.38) v4(86.48,104.24) v4(86.48,103.09) v4(86.48,101.95) v4(87.08,115.8) v4(88.39,105.38) v4(88.39,104.24) v4(88.39,103.09) v4(88.39,101.95) v4(88.39,100.81) v4(89.54,113.89) v4(89.54,112.75) v4(89.54,111.6) v4(89.54,110.46) v4(89.54,109.32) v4(89.54,105.38) v4(89.54,104.24) v4(89.54,103.09) v4(89.54,101.95) v4(89.54,100.81) v4(90.68,105.38) v4(90.68,104.24) v4(90.68,103.09) v4(90.68,101.95) v4(90.74,94.16) v4(91.45,94.16) v4(91.82,112.75) v4(91.82,111.6) v4(91.82,110.46) v4(91.82,109.32) v4(91.82,105.38) v4(91.82,104.24) v4(91.82,103.09) v4(91.82,101.95) v4(92.61,94.13) v4(93.62,94.13) v4(93.66,112.43) v4(93.66,111.16) v4(93.66,109.13) v4(93.66,107.86) v4(93.66,105.82) v4(93.66,104.55) v4(93.66,102.52) v4(93.66,101.12) v4(93.66,99.22) v4(93.66,97.82) v4(94.29,112.43) v4(94.29,111.16) v4(94.29,109.13) v4(94.29,107.86) v4(94.29,105.82) v4(94.29,104.55) v4(94.29,102.52) v4(94.29,99.22) v4(94.29,97.82) v4(94.64,94.13) v4(95.86,92.78) v4(97.21,95.32) v4(97.21,93.72) v4(97.21,92.79) v4(99.5,97.86) v4(99.5,96.26) v4(99.5,95.32) v4(99.5,93.72) v4(99.5,92.78) v4(99.5,91.18)
VDD_CORE_0V8_N: length 2
  BOTTOM w0.127: TP263.1 66.4,123.65 66.27,123.52 65.45,123.52 R898.2
VDD_CORE_0V8_P: length 2
  BOTTOM w0.127: R904.2 65.46,123.22 66.27,123.22 66.4,123.09 TP264.1
VDD_CPU_AVS: length 436.4
  TOP w0.254: U87.12 181.18,51.38 181.77,51.97 v2(182.47,51.97) ; R93.1 162.37,159.63
  TOP w0.305: v2(125.12,79.43) 124.72,79.83 U59.R12 ; v2(119.52,74.63) 119.91,75.03 U59.J18 ; U59.M19 119.11,77.43 v2(118.72,77.03) ; U59.P15 122.32,79.03 v2(122.72,78.63) ; U59.AB11 125.52,85.43 v2(125.92,85.83) ; U59.AB17 120.72,85.44 v2(120.32,85.83) ; v2(128.32,83.43) 127.92,83.03 U59.W8 ; U59.U10 126.32,81.43 v2(126.72,81.03) ; v2(120.32,78.63) 120.71,79.03 U59.P17 ; U59.Y19 119.12,83.84 v2(118.72,84.23) ; v2(127.52,87.43) 127.12,87.03 U59.AD9 ; U59.W20 118.32,83.04 v2(117.92,83.43) ; U59.AC20 118.32,86.24 v2(117.92,86.63) ; U59.AC12 124.72,86.23 v2(125.12,86.63) ; U59.L25 114.31,76.63 v2(113.92,76.23) ; v2(128.32,81.03) 127.92,81.43 U59.U8 ; U59.U18 119.91,81.43 v2(119.52,81.03) ; U59.W10 126.32,83.03 v2(126.72,83.43) ; U59.R20 118.31,79.83 v2(117.92,79.43) ; v2(123.52,86.63) 123.12,86.23 U59.AC14 ; v2(118.72,73.83) 119.11,74.23 U59.H19 ; v2(118.72,82.63) 119.12,82.24 U59.V19 ; v2(119.52,76.23) 119.91,76.63 U59.L18 ; U59.V21 117.52,82.24 v2(117.12,82.63) ; v2(119.52,86.63) 119.92,86.24 U59.AC18 ; v2(118.72,80.23) 119.11,80.63 U59.T19 ; v2(117.92,85.03) 118.32,84.64 U59.AA20 ; v2(118.72,78.63) 119.11,79.03 U59.P19 ; U59.AB13 123.92,85.43 v2(124.32,85.83) ; v2(117.12,85.83) 117.52,85.44 U59.AB21 ; v2(117.92,77.83) 118.31,78.23 U59.N20 ; U59.Y21 117.52,83.84 v2(117.12,84.23) ; U59.AA10 126.32,84.63 v2(126.72,85.03) ; U59.T9 127.12,80.63 v2(127.52,80.23) ; v2(125.92,80.23) 125.52,80.63 U59.T11 ; v2(125.92,82.63) 125.52,82.23 U59.V11 ; U59.AA12 124.72,84.63 v2(125.12,85.03) ; v2(128.32,85.03) 127.92,84.63 U59.AA8 ; U59.U20 118.31,81.43 v2(117.92,81.03) ; 162.37,159.63 162.37,157.96 TP22.1 ; U59.P21 117.51,79.03 v2(117.12,78.63) ; v2(120.32,80.23) 120.71,80.63 U59.T17 ; U59.N18 119.91,78.23 v2(119.52,77.83) ; U59.AC16 v2(121.92,86.63) ; U59.AB15 v2(122.72,85.83) ; U59.W18 119.92,83.04 v2(119.52,83.43) ; U59.H21 117.51,74.23 v2(117.12,73.83) ; U59.Y9 127.12,83.83 v2(127.52,84.23) ; U59.AB19 119.12,85.44 v2(118.72,85.83) ; v2(117.92,76.23) 118.31,76.63 U59.L20 ; U59.AC8 127.92,86.23 v2(128.32,86.63) ; v2(125.12,83.43) 124.72,83.03 U59.W12 ; U59.Y17 120.72,83.84 v2(120.32,84.23) ; U59.J20 118.31,75.03 v2(117.92,74.63) ; v2(127.52,85.83) 127.12,85.43 U59.AB9 ; U59.T21 117.51,80.63 v2(117.12,80.23)
  L3-SIGNAL1 w0.305: v6(115.65,114.55) v5(115.65,114.15) ; v6(115.65,116.18) v5(115.65,115.77) ; v6(114.89,115.37) v5(114.89,114.96) ; v6(115.65,115.37) v5(115.65,114.96) ; v6(114.89,116.18) v5(114.89,115.77) ; v6(114.89,116.99) v5(114.89,116.59) ; v6(115.65,116.99) v5(115.65,116.59) ; v6(114.89,114.55) v5(114.89,114.15)
  L4-GND2 w0.305: v5(115.65,116.59) v6(115.65,116.99) ; v5(115.65,115.77) v6(115.65,116.18) ; v5(115.65,114.15) v6(115.65,114.55) ; v5(115.65,114.96) v6(115.65,115.37) ; v5(114.89,116.59) v6(114.89,116.99) ; v5(114.89,114.96) v6(114.89,115.37) ; v5(114.89,114.15) v6(114.89,114.55) ; v5(114.89,115.77) v6(114.89,116.18)
  L7-SIGNAL3 w0.127: TP22.1 161.15,157.58 160.94,157.38 160.94,155.76 159.88,154.69 153.32,154.69 151.39,152.76 151.39,145.35 148.47,142.42 148.47,130.67 152.73,126.4 152.73,122.8 149.12,119.19 119.86,119.19 117.54,116.87 116.72,116.87 116.05,116.2 116.05,115.85 114.39,114.2 113.76,114.2 113.06,113.5 113.06,102.55 113.66,101.95 113.66,99.43 114.89,98.2 117.72,98.2 120.25,95.66 120.25,92.84 120.52,92.56 120.52,92.2 120.3,91.98 120.3,90.72 120.99,90.04 120.99,86.51 v2(120.32,85.83) ; v2(163.49,121.53) 163.49,122.13 163.36,122.25 162.12,122.25 158.25,118.38 120.84,118.38 116.69,114.22 116.22,114.22 113.67,111.68 113.67,103.78 114.59,102.86 114.59,99.78 115.35,99.02 117.77,99.02 120.79,96.01 120.79,92.95 121.04,92.7 121.04,91.58 121.64,90.98 121.64,90.65 121.52,90.53 121.52,87.03 v2(121.92,86.63)
  L10-SIGNAL4 w0.127: v2(119.52,74.63) 119.93,74.22 119.93,66.39 137.24,49.07 140.88,49.07 147.39,42.56 168.09,42.56 170.87,45.34 180.85,45.34 183.65,48.15 183.65,51.6 183.29,51.97 v2(182.47,51.97) ; v2(164.33,120.69) 163.52,120.69 162.64,121.57 155.25,121.57 140.73,136.1 139.38,136.1 138.56,135.28 122.12,135.28 118.55,131.71 118.55,129.36 123.45,124.47 123.45,109.18 v4(123.76,108.87)
  L10-SIGNAL4 w0.254: 119.46,101.35 v2(119.46,101.34) ; 119.46,101.35 118.96,100.84 118.96,100.11 v2(119.44,99.62) ; 119.46,101.35 v2(119.46,102.81) 119.46,103.43 120.79,104.75 120.79,110.86 v2(120.2,111.45)
  BOTTOM w0.254: v2(125.12,85.03) 125.1,85.02 U50135.1 ; U50152.1 v2(119.52,77.83) ; U50125.1 118.71,82.63 v2(118.72,82.63) ; U50129.3 120.47,78.79 v2(120.32,78.63) ; v2(117.12,82.63) 117.12,82.63 U50125.3 ; U50152.3 119.52,76.23 v2(119.52,76.23) ; v2(125.12,83.43) 125.1,83.44 U50135.3
  BOTTOM w0.305: 147.38,108.14 v4(147.38,108.24) ; U5093.3 v4(151.01,105.96) ; U5091.3 v4(154.82,105.96) ; U5091.1 v4(154.82,107.56) ; U5093.1 v4(151.01,107.56) ; 137.98,108.14 v4(137.98,108.24) ; 148.65,108.14 v4(148.65,108.24) ; U5090.3 v4(156.73,105.96) ; 136.71,108.14 v4(136.71,108.24) ; U5092.3 v4(152.92,105.96) ; U5092.1 v4(152.92,107.56) ; U5090.1 v4(156.73,107.56)
  vias: v1(111.24,108.94) v1(111.24,108.18) v1(112.05,108.94) v1(112.05,108.18) v1(112.86,108.94) v1(112.86,108.18) v1(113.67,108.94) v1(113.67,108.18) v2(121.62,82.99) v2(121.62,81.39) v2(121.92,80.16) v2(122.73,82.83) v2(122.73,81.43) v2(122.73,80.04) v2(124.24,82.68) v2(124.16,81.64) v2(124.21,80.19) v2(128.74,100.73) v2(128.74,99.47) v2(128.74,96.97) v2(130.64,100.73) v2(130.64,99.47) v2(130.64,96.97) v2(132.55,100.73) v2(132.55,99.47) v2(132.55,96.97) v2(134.7,100.73) v2(134.7,99.47) v2(164.04,102.83) v3(111.24,108.94) v3(111.24,108.18) v3(112.05,108.94) v3(112.05,108.18) v3(112.86,108.94) v3(112.86,108.18) v3(113.67,108.94) v3(113.67,108.18) v4(115.38,108.87) v4(115.38,108.24) v4(116.65,108.87) v4(116.65,108.24) v4(118.93,108.87) v4(118.93,108.24) v4(120.2,108.87) v4(120.2,108.24) v4(122.49,108.87) v4(122.49,108.24) v4(123.76,108.24) v4(126.04,108.87) v4(126.04,108.24) v4(127.31,108.87) v4(127.31,108.24) v4(129.6,108.87) v4(129.6,108.24) v4(130.87,108.87) v4(130.87,108.24) v4(133.16,108.87) v4(133.16,108.24) v4(134.43,108.87) v4(134.43,108.24) v4(136.71,108.87) v4(137.98,108.87) v4(140.27,108.87) v4(140.27,108.24) v4(141.54,108.87) v4(141.54,108.24) v4(143.82,108.87) v4(143.82,108.24) v4(145.09,108.87) v4(145.09,108.24) v4(147.38,108.87) v4(148.65,108.87) v4(154.23,109.75) v4(154.23,108.61) v4(155.37,115.97) v4(155.37,114.83) v4(155.37,113.69) v4(155.37,112.54) v4(155.37,110.89) v4(155.37,109.75) v4(155.37,108.61) v4(156.52,115.97) v4(156.52,114.83) v4(156.52,113.69) v4(156.52,112.54) v4(156.52,110.89) v4(156.52,109.75) v4(156.52,108.61) v4(157.66,115.97) v4(157.66,114.83) v4(157.66,113.69) v4(157.66,112.54) v4(158.8,115.97) v4(158.8,114.83) v4(158.8,113.69) v4(158.8,112.54) v4(158.8,108.61) v4(158.8,107.46) v4(158.8,106.32) v4(158.91,105.18) v4(159.95,115.97) v4(159.95,114.83) v4(159.95,113.69) v4(159.95,112.54) v4(159.95,108.61) v4(159.95,107.46) v4(159.95,106.32) v4(159.95,105.18) v4(161.86,114.83) v4(161.86,113.69) v4(161.86,112.54) v4(161.86,108.61) v4(161.86,107.46) v4(161.86,106.32) v4(161.86,105.18) v4(163,114.83) v4(163,113.69) v4(163,112.54) v4(163,108.61) v4(163,107.46) v4(163,106.32) v4(163,105.18) v4(164.15,114.83) v4(164.15,113.69) v4(164.15,112.54) v4(164.15,108.61) v4(164.15,107.46) v4(164.15,106.32) v4(164.15,105.18) v4(164.96,114.02) v4(164.96,113.38) v4(166.35,114.02) v4(166.35,113.38) v4(168.51,114.33) v4(169.27,114.33) v4(170.04,114.33) v4(170.8,114.33) v4(172.83,114.02) v4(172.83,113.38) v4(174.23,114.02) v4(174.23,113.38) v4(176.39,114.02) v4(176.39,113.38) v4(177.78,114.02) v4(177.78,113.38) v4(179.95,114.34) v4(180.71,114.34) v4(181.47,114.34) v4(182.23,114.34) v4(184.26,114.02) v4(184.26,113.38) v4(185.66,114.02) v4(185.66,113.38) v4(187.56,114.02) v4(187.56,113.38) v4(188.96,114.02) v4(188.96,113.38) v4(191.12,114.33) v4(191.88,114.33) v4(192.64,114.33) v4(193.4,114.33) v4(195.44,114.02) v4(195.44,113.38) v4(196.83,114.02) v4(196.83,113.38) v7(123.53,89.76)
VDD_CPU_AVS_N: length 2
  BOTTOM w0.127: R911.2 158.5,120.55 159.32,120.55 159.44,120.67 TP271.1
VDD_CPU_AVS_P: length 2
  BOTTOM w0.127: R919.2 158.5,120.24 159.32,120.24 159.44,120.11 TP277.1
VDD_CPU_HCPS_GOSNS: length 46.1
  TOP w0.127: C158.1 165.81,122.7 166.13,122.38 167.06,122.38 167.82,121.62 U35.2 ; C158.1 164.76,123.79 164.33,123.36 v2(164.33,123.35) ; C158.1 165.85,123.83 R186.1 ; U36.2 179.37,121.62 179.17,121.83 v2(179.17,122.07) 178.28,122.95 178.28,124.61 178.55,124.88 C154.1 ; U37.2 190.9,121.62 190.88,121.6 190.52,121.6 190.34,121.78 v2(190.34,122.03) 190.34,122.53 189.67,123.21 189.67,124.57 189.92,124.83 C156.1
  L5-SIGNAL2 w0.102: v2(190.34,122.03) 189.9,121.59 188.5,121.59 186.68,123.41 182.16,123.41 180.99,122.23 179.74,122.23 179.57,122.07 v2(179.17,122.07) 178.69,121.59 177.92,121.59 175.73,123.78 169.63,123.78 168.42,122.57 165.11,122.57 v2(164.33,123.35)
VDD_CPU_HCPS_VOSNS: length 35.6
  TOP w0.127: U37.3 v2(190.34,121.12) ; v2(164.33,121.53) 165.06,121.53 165.42,121.89 167.05,121.89 167.81,121.12 U35.3 ; U36.3 v2(179.17,121.12)
  L5-SIGNAL2 w0.102: v2(190.34,121.12) 190.14,121.32 188.37,121.32 186.57,123.13 182.28,123.13 181.11,121.96 180,121.96 v2(179.17,121.12) 178.97,121.32 177.71,121.32 175.5,123.54 169.79,123.54 168.48,122.22 165.02,122.22 v2(164.33,121.53)
VDD_DDR_1V1: length 223.6
  TOP w0.089: v3(147.96,64.82) 148.26,65.12 149.21,65.12 U71.F8 149.21,64.47 148.26,64.47 U71.F10 ; U71.U8 149.21,72.27 148.32,72.27 v3(147.96,71.91) ; 149.2,92.95 U54.U8 149.21,93.6 148.26,93.6 U54.U10 148.26,92.95 148.6,92.95 148.6,92.95 148.87,92.95 148.87,92.95 149.2,92.95 ; U54.F10 148.26,85.81 149.21,85.81 U54.F8 149.21,86.45 148.26,86.45 U54.F10
  TOP w0.254: U71.U5 151.86,71.94 v2(151.53,71.62) 151.52,71.61 151.52,71.07 151.93,70.66 U71.R5 ; U71.W12 145.94,73.24 v2(145.83,73.14) ; U71.H12 145.5,65.26 145.5,64.29 v3(146.34,63.45) ; U71.D1 155.37,63.49 155.99,64.11 155.99,66.13 v2(155.69,66.44) ; U54.H12 145.45,86.55 145.45,85.57 145.91,85.12 146.05,85.12 U54.D12 ; U54.F5 151.67,86.13 151.39,86.41 151.39,86.96 v2(151.53,87.16) ; U68.22 176.33,69.38 v2(176.59,69.12) ; v3(147.93,74.54) U71.AB9 ; v2(157.92,43.97) 157.92,43.64 158.17,43.39 R557.2 ; v3(147.93,95.88) U54.AB9 ; U54.W12 v2(145.83,94.21)
  TOP w0.305: U59.H17 120.71,74.23 v2(120.32,73.83) ; v2(152.33,61.22) 152.73,61.54 U71.A4 ; U59.J14 123.12,75.03 v2(123.52,74.63) ; U59.G12 124.72,73.43 v2(125.12,73.03) ; U54.N10 147.45,90.19 146.82,90.19 U54.N12 146.33,90.68 v2(146.73,91.01) ; v2(155.53,92.31) 155.13,91.98 U54.R1 ; v2(148.99,97.01) 148.99,96.79 148.73,96.53 U54.AB9 ; v2(149.93,92.31) 149.53,91.98 U54.R8 ; v2(153.13,92.96) 153.53,93.28 U54.U3 ; U71.U8 149.53,71.95 v2(149.93,72.27) ; U71.H5 v2(151.53,65.77) ; v2(128.32,79.43) 127.92,79.83 U59.R8 ; v2(153.13,71.62) 153.53,71.95 U71.U3 ; v2(155.53,89.06) U54.K1 ; U59.M7 v2(129.12,77.03) ; v2(153.13,67.07) U71.K3 ; U54.R12 146.33,91.98 v2(145.93,91.66) ; U5049.3 v2(145.97,56.8) ; U71.R8 149.53,70.65 v2(149.93,70.97) ; U59.H13 123.92,74.23 v2(124.32,73.83) ; v2(149.93,93.61) 149.53,93.28 U54.U8 ; U54.B3 v2(153.13,83.2) ; v2(155.53,94.26) 155.13,94.58 U54.W1 ; v2(125.12,74.63) 124.72,75.03 U59.J12 ; U71.B3 v2(153.13,61.87) ; v2(155.53,67.72) U71.K1 ; U54.A9 v2(149.13,82.55) ; v2(153.93,74.87) 153.53,74.55 U71.AA3 ; v2(152.33,82.55) 152.73,82.88 U54.A4 ; v2(122.72,73.83) 122.32,74.23 U59.H15 ; U71.N1 v2(155.46,68.83) 154.05,68.83 U71.N3 ; U54.H8 v2(149.13,87.1) ; U59.J10 126.32,75.03 v2(126.72,74.63) ; U5053.1 v2(142.18,53.75) ; U54.AA3 153.53,95.88 v2(153.93,96.21) ; v2(125.92,73.83) 125.52,74.23 U59.H11 ; v2(155.69,66.44) 155.53,66.42 U71.H1 ; U59.A2 132.72,68.63 v2(133.12,68.23) ; v2(123.52,73.03) 123.12,73.43 U59.G14 ; U59.J16 121.52,75.03 v2(121.92,74.63) ; v2(145.71,67.28) 145.85,67.39 U71.K12 146.82,67.88 147.45,67.88 U71.K10 ; v2(128.32,74.63) 127.92,75.03 U59.J8 ; U71.R12 146.33,70.65 v2(145.93,70.32) ; U54.F8 v2(149.93,85.8) ; U54.AB4 v2(152.59,97.08) ; U59.N8 v2(128.32,77.83) ; U59.G18 119.91,73.43 v2(119.52,73.03) ; U5050.3 v2(143.43,55.15) ; U71.W1 155.33,73.04 155.4,73.04 156.02,72.42 156.02,71.39 155.6,70.97 v2(155.53,70.97) 155.13,70.65 U71.R1 ; U59.K7 128.72,75.83 v2(129.12,75.43) ; U71.F8 v2(149.93,64.47) ; U71.N10 147.45,68.86 146.82,68.86 U71.N12 146.33,69.35 v2(146.73,69.67) ; v2(121.92,73.03) 121.52,73.43 U59.G16 ; U71.AB4 v2(152.73,75.74) ; U54.R5 151.93,91.98 v2(151.53,92.31) 151.5,92.34 151.5,92.85 U54.U5 ; U54.K10 147.45,89.22 146.82,89.22 U54.K12 v2(145.91,88.4) ; U54.B10 v2(147.53,83.2) ; v2(155.69,87.78) 155.53,87.75 U54.H1 ; v2(153.13,88.41) U54.K3 ; U59.G10 126.32,73.43 v2(126.72,73.03) ; U54.N3 154.05,90.16 v2(155.46,90.16) U54.N1 ; U54.D1 v2(155.53,84.5) ; U59.P7 128.72,79.03 v2(129.12,78.63) ; v2(148.99,75.67) 148.99,75.45 148.73,75.2 U71.AB9 ; C315.1 v4(141.77,56.42) ; v2(127.52,73.83) 127.12,74.23 U59.H9 ; U71.F5 v2(152.33,65.12) ; U71.F3 v2(153.93,64.47) ; U59.AH1 133.52,90.23 v2(133.92,90.63) ; v2(128.32,76.23) 127.92,76.63 U59.L8 ; U71.B10 v2(148.33,61.87) ; C307.1 v4(141.77,57.31) ; U5050.1 v2(142.18,55.15) ; U71.A9 v2(149.13,61.22) ; U54.H12 v2(146.73,87.75) ; U54.H5 v2(151.53,87.16) ; U5049.1 v2(144.72,56.8) ; U71.H8 v2(149.13,65.77) ; U5053.3 v2(143.43,53.75) ; U71.H12 v2(146.73,66.42) ; U54.F3 v2(153.93,85.8)
  TOP w0.381: R544.1 162.8,45.15 TP183.1
  L10-SIGNAL4 w0.127: v2(123.52,73.03) 121.78,71.29 121.78,66.8 136.5,52.08 140.94,52.08 148.12,44.9 157.94,44.9 159.03,46 163.97,46 164.31,45.66 164.31,44.9 164.18,44.77 TP183.1 ; v2(129.12,75.43) 129.6,75.92 134.69,75.92 136.73,73.89 150.92,73.89 151.86,72.95 159.86,72.95 160.45,72.37 166.19,72.37 166.8,72.98 170.91,72.98 173.38,70.52 175.92,70.52 176.27,70.17 176.27,69.44 v2(176.59,69.12)
  BOTTOM w0.254: R1020.1 R1019.1 152.14,81.87 152.33,82.07 ; U50188.3 121.92,74.63 v2(121.92,74.63) ; v2(123.52,74.63) 123.51,74.63 U50188.1
  BOTTOM w0.305: C792.1 149.07,97.1 v2(148.99,97.01) ; v2(149.13,61.22) 148.85,60.94 C981.1 ; C915.1 148.85,82.27 v2(149.13,82.55) ; C914.1 153.14,81.66 152.63,81.66 152.33,81.95 v2(152.33,82.55) 152.98,83.2 v2(153.13,83.2) ; C913.1 144.99,89.2 v2(145.07,89.12) ; v2(148.99,75.67) 149.07,75.76 C1083.1 ; v2(145.91,88.4) 145.89,88.4 145.82,88.47 145.09,88.47 C846.1 ; v2(145.07,67.91) 145.08,67.91 145.08,67.91 144.99,67.83 C1051.1 ; v2(155.46,68.83) 155.59,68.96 C1054.1 ; v2(145.71,67.28) 145.68,67.25 145.68,67.16 145.65,67.13 C1044.1 ; v2(152.59,97.08) 152.79,97.31 152.79,97.79 C793.1 ; C982.1 152.63,60.32 152.33,60.62 v2(152.33,61.22) 152.98,61.87 v2(153.13,61.87) ; v2(152.73,75.74) 152.79,75.79 C1084.1 ; R1041.1 151.54,60.55 150.55,60.55 R1040.1 v4(150.55,59.92) ; C839.1 156.37,90.29 155.59,90.29 v2(155.46,90.16)
  vias: v1(147.96,93.24) v1(147.96,86.16) v1(149.53,95.88) v1(149.53,94.58) v1(149.53,84.83) v1(149.53,83.53) v1(149.53,74.54) v1(149.53,73.24) v1(149.53,63.49) v1(149.53,62.19) v1(151.93,95.88) v1(151.93,94.58) v1(151.93,84.83) v1(151.93,83.53) v1(151.93,74.54) v1(151.93,73.24) v1(151.93,63.49) v1(151.93,62.19) v2(146.16,78.34) v2(146.31,99.3) v2(148.19,101.25) v2(148.19,57.06) v2(149.36,80.25) v2(150.73,78.34) v2(153.48,101.25) v2(153.48,57.06) v2(153.93,80.25) v2(155.15,58.75) v2(157.29,76.43) v2(157.35,101.25) v2(157.35,56.93) v2(158.04,94.29) v2(158.41,74.17) v2(158.41,70.99) v2(158.41,67.82) v2(158.41,63.77) v2(158.68,90.23) v2(158.68,87.06) v2(158.68,83.88) v2(160.97,97.01) v2(160.97,75.68) v2(161.96,78.68) v2(162.81,81.65) v2(162.81,79.77) v2(163.03,71.25) v2(163.03,66.17) v2(163.13,77.07) v2(164.79,80.87) v2(168.88,60.92) v2(168.88,60) v2(168.88,58.78) v2(168.88,57.87) v2(171.31,58.34) v2(171.31,57.7) v2(173.44,58.34) v2(173.44,57.7) v3(147.96,93.24) v3(147.96,86.16) v3(149.53,95.88) v3(149.53,94.58) v3(149.53,84.83) v3(149.53,83.53) v3(149.53,74.54) v3(149.53,73.24) v3(149.53,63.49) v3(149.53,62.19) v3(151.8,90.72) v3(151.93,95.88) v3(151.93,94.58) v3(151.93,84.83) v3(151.93,83.53) v3(151.93,74.54) v3(151.93,73.24) v3(151.93,63.49) v3(151.93,62.19) v4(144.97,76.07) v4(145.18,54.9) v4(145.18,52.99) v4(146.78,54.9) v4(146.78,52.99) v4(148.36,54.9) v4(148.36,52.99) v4(149.96,54.9) v4(149.96,52.99) v4(159.6,71.62) v4(159.58,67.63) v4(159.9,92.15) v4(159.92,85.09) v4(165.35,61.48) v4(165.35,60.46) v4(165.35,58.33) v4(165.35,57.31) v4(166.37,61.48) v4(166.37,60.46) v4(166.37,58.33) v4(166.37,57.31) v4(167.38,61.48) v4(167.38,60.46) v4(167.38,58.33) v4(167.38,57.31) v4(169.27,56.53) v4(169.27,55.52) v4(169.27,54.5) v4(170.24,64.8) v4(170.24,63.66) v4(170.24,62.52) v4(170.29,56.53) v4(170.29,55.52) v4(170.29,54.5) v4(171.13,64.8) v4(171.13,63.66) v4(171.13,62.52) v4(171.31,55.52) v4(172.02,64.8) v4(172.02,63.66) v4(172.02,62.52) v4(180.15,64.88) v4(180.15,63.74) v4(180.15,62.59) v4(181.03,64.88) v4(181.03,63.74) v4(181.03,62.59) v4(181.92,64.88) v4(181.92,63.74) v4(181.92,62.59) v6(130.34,71.86) v6(131.12,72.63) v6(131.14,71.86) v6(153.98,86.92) v9(131.61,84.53) v9(147.07,90.6) v9(147.71,68.12) v9(150.25,68.04) v9(150.9,89.38) v9(153.14,87.63) v9(153.37,86) v9(153.53,91.92) v9(153.93,92.96) v9(153.93,89.31) v9(153.91,68) v9(153.96,71.58)
