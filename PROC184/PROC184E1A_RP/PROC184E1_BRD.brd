# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR1_DQ19: length 30.7
  L3-SIGNAL1 w0.127: v5(130.67,76.73) v3(130.32,76.63)
  L3-SIGNAL1 w0.129: v3(154.33,71.94) 154.73,71.62 v5(154.73,71.62)
  L4-GND2 w0.146: v6(130.33,76.7) v5(130.67,76.73) ; v6(154.31,71.63) v5(154.73,71.62)
  L5-SIGNAL2 w0.152: v6(154.31,71.63) 154.06,71.37 154.06,71.27 153.35,70.56 147.28,70.56 146.9,70.94 142.73,70.94 141.23,72.44 133.16,72.44 132.63,72.97 130.99,72.97 130.68,73.27 130.68,74.22 129.98,74.92 129.98,75.34 130.26,75.87 v6(130.33,76.7)
  vias: v1(130.32,76.63) v1(154.33,71.94)
DDR1_DQ20: length 30.7
  L3-SIGNAL1 w0.127: v5(130.56,75.36) v3(130.32,75.03)
  L3-SIGNAL1 w0.129: v6(152.73,71.94) 152.4,71.54 v5(152.41,71.6)
  L4-GND2 w0.146: v6(130.33,75.1) v5(130.56,75.36) ; v6(152.73,71.94) v5(152.41,71.6)
  L5-SIGNAL2 w0.152: v6(152.73,71.94) 151.77,70.98 151.55,70.98 150.97,71.57 150.7,71.57 150.48,71.35 150.1,71.35 150.09,71.36 149.77,71.36 149.76,71.35 149.26,71.35 149.03,71.58 147.51,71.58 147.38,71.45 144.33,71.45 144.08,71.7 143.89,71.7 143.66,71.47 143.42,71.47 143.25,71.65 143.25,71.86 143.47,72.09 143.47,72.31 143.3,72.49 143.08,72.49 142.6,72 142.41,72 142.18,72.23 142.18,72.45 142.82,73.09 142.82,73.3 142.67,73.46 142.28,73.46 141.7,72.87 135.44,72.87 135.14,73.18 134.81,73.18 134.51,72.88 134.02,72.88 133.87,73.04 133.87,73.36 133.66,73.56 132.36,73.56 132.17,73.74 132,73.74 131.76,73.99 131.76,74.5 131.61,74.65 130.78,74.65 v6(130.33,75.1)
  vias: v1(130.32,75.03) v1(152.73,71.94)
DDR1_DQ21: length 30.7
  L3-SIGNAL1 w0.129: v5(152.41,72.25) 152.4,72.19 v6(152.73,72.59)
  L3-SIGNAL1 w0.132: v5(132.29,75.87) v3(131.92,75.83)
  L4-GND2 w0.146: v6(131.95,75.86) v5(132.29,75.87) ; v6(152.73,72.59) v5(152.41,72.25)
  L5-SIGNAL2 w0.152: v6(131.95,75.86) 132.17,75.64 132.77,75.64 133.05,75.36 133.05,74.55 133.21,74.4 133.79,74.4 134.06,74.13 134.39,74.13 134.74,74.48 134.95,74.48 135.38,74.05 136.68,74.05 136.97,73.76 141.11,73.76 141.27,73.92 141.27,74.82 141.42,74.98 141.71,74.98 142.31,74.38 144.04,74.38 144.24,74.18 144.24,73.99 143.78,73.53 143.78,73.25 144.53,72.5 144.73,72.5 144.87,72.63 144.87,72.82 144.49,73.2 144.49,73.41 144.65,73.58 144.84,73.58 145.67,72.75 146.42,72.75 146.56,72.88 146.56,73.07 146.69,73.2 146.88,73.2 147.01,73.07 147.01,72.88 147.15,72.75 149.44,72.75 149.54,72.85 149.54,73.08 149.77,73.31 150.09,73.31 150.32,73.08 150.32,72.73 150.45,72.59 v6(152.73,72.59)
  vias: v1(131.92,75.83) v1(152.73,72.59)
DDR1_DQ22: length 30.7
  L3-SIGNAL1 w0.129: v6(152.73,73.9) 152.33,74.22 v5(152.33,74.22)
  L3-SIGNAL1 w0.14: v5(131.49,76.63) v6(131.12,76.63)
  L4-GND2 w0.146: v6(131.12,76.63) v5(131.49,76.63) ; v6(152.73,73.9) v5(152.33,74.22)
  L5-SIGNAL2 w0.152: v6(152.73,73.9) 151.87,73.9 151.42,74.35 150.61,74.35 150.48,74.48 150.48,74.63 150.3,74.8 150.08,74.8 149.95,74.67 149.95,74.48 149.81,74.35 148.37,74.35 148.25,74.46 148.25,75 148.08,75.17 147.73,75.17 147.58,75.02 147.58,74.4 147.45,74.26 147.26,74.26 147.13,74.4 147.13,75.11 146.97,75.27 146.7,75.27 146.16,74.73 145.58,74.73 145.39,74.92 145.39,75.45 145.23,75.6 144.67,75.6 144.52,75.76 144.52,76.14 144.4,76.26 144.12,76.26 143.99,76.12 143.99,75.67 143.85,75.54 143.66,75.54 143.53,75.67 143.53,76.12 143.4,76.26 143.21,76.26 143.07,76.12 143.07,75.67 142.94,75.54 142.75,75.54 142.6,75.69 142.6,76.12 142.47,76.26 134.39,76.26 134.17,76.48 133.46,76.48 132.88,75.9 132.55,75.9 132.19,76.25 131.5,76.25 v6(131.12,76.63)
  vias: v1(131.12,76.63) v1(152.73,73.89)
DDR1_DQ23: length 30.7
  L3-SIGNAL1 w0.129: v6(152.73,74.55) 152.33,74.87 v5(152.33,74.87)
  L3-SIGNAL1 w0.14: v5(129.62,76.18) v3(129.52,75.83)
  L4-GND2 w0.146: v6(129.82,75.94) v5(129.62,76.18) ; v6(152.73,74.55) v5(152.33,74.87)
  L5-SIGNAL2 w0.152: v6(129.82,75.94) 129.83,75.95 129.83,76.91 130.26,77.34 131.4,77.34 131.78,76.97 132.83,76.97 133.08,77.22 134.58,77.22 134.67,77.12 145.47,77.12 145.68,76.91 145.7,76.91 145.73,76.89 150.82,76.89 150.95,76.75 150.95,75.62 151.09,75.49 151.28,75.49 151.41,75.62 151.41,76.75 151.54,76.89 152.18,76.89 152.33,76.73 152.33,74.95 v6(152.73,74.55)
  vias: v1(129.52,75.83) v1(152.73,74.54)
DDR1_DQ24: length 23.8
  L3-SIGNAL1 w0.14: v3(129.52,78.23) 130.13,78.23 130.77,78.87 130.77,79.17 130.97,79.38 131.53,79.38 131.78,79.12 132.27,79.12 132.57,79.43 132.78,79.43 132.95,79.26 133.17,79.26 133.17,79.26 133.74,79.26 133.74,79.26 134.16,79.26 134.33,79.43 142.6,79.43 142.78,79.25 142.78,79.06 142.34,78.62 142.34,78.43 143.04,77.73 143.22,77.73 143.35,77.86 143.35,78.05 142.97,78.43 142.97,78.62 143.1,78.75 143.28,78.75 147.13,74.9 v3(147.13,74.54)
DDR1_DQ25: length 23.8
  L3-SIGNAL1 w0.14: v3(131.12,79.03) 131.51,78.64 132.77,78.64 133.8,78.64 133.94,78.78 134.22,78.78 134.41,78.6 141.28,78.6 141.5,78.37 141.5,77.43 143.95,74.98 143.95,74.8 143.82,74.67 143.64,74.67 142.74,75.57 142.55,75.57 142.42,75.44 142.42,75.25 143.66,74.02 145.09,74.02 145.44,74.37 145.44,74.48 145.67,74.71 145.83,74.87 146.03,74.87 146.34,74.56 146.34,74.3 146.77,73.86 v3(147.13,73.86)
DDR1_DQ26: length 23.8
  L3-SIGNAL1 w0.14: v3(147.13,72.59) 146.62,72.59 146.46,72.75 145.63,72.75 145.22,72.34 145.22,72.04 145.09,71.91 144.9,71.91 144.77,72.04 144.77,72.41 144.64,72.54 144.46,72.54 144.33,72.41 144.33,72.04 144.2,71.91 144.01,71.91 143.88,72.04 143.88,72.41 143.75,72.54 143.14,72.54 140.26,75.42 140.26,75.73 140.11,75.87 137.27,75.87 137.13,76.01 137.13,77.26 136.93,77.46 136.71,77.46 136.57,77.32 136.57,76.66 136.43,76.52 136.4,76.52 136.23,76.52 136.09,76.66 136.09,77.32 135.95,77.46 135.75,77.46 135.61,77.32 135.61,76.66 135.47,76.52 135.28,76.52 135.14,76.66 135.14,77.29 135,77.43 134.32,77.43 134.21,77.33 133.94,77.33 133.75,77.52 133.75,77.58 133.05,78.28 131.97,78.28 v3(131.92,78.23)
DDR1_DQ27: length 23.8
  L3-SIGNAL1 w0.14: v3(130.32,77.43) 131.24,77.43 131.63,77.04 132.85,77.04 133.13,76.76 133.13,76.38 133.3,76.2 134.29,76.2 134.43,76.06 134.43,75.01 134.6,74.83 134.8,74.83 134.93,74.96 134.93,75.54 135.06,75.67 135.24,75.67 135.38,75.54 135.38,74.96 135.51,74.83 135.69,74.83 135.82,74.96 135.82,75.54 135.95,75.67 136.13,75.67 136.26,75.54 136.26,74.96 136.39,74.83 139.62,74.83 143.76,70.69 145.16,70.69 145.53,71.06 145.72,71.06 145.96,71.3 145.96,71.45 146.41,71.91 v3(147.13,71.91)
DDR1_DQ28: length 23.7
  L3-SIGNAL1 w0.14: v3(148.75,71.91) 148.33,71.55 147.28,71.55 146.43,70.71 145.77,70.71 145.22,70.16 143.65,70.16 139.4,74.4 134.35,74.4 133.97,74.78 133.97,75.24 133.83,75.38 133.36,75.38 133.25,75.5 132.59,75.5 132.59,75.5 131.68,75.5 131.53,75.65 131.53,75.97 131.28,76.23 130.18,76.23 129.99,76.42 129.99,76.96 v3(129.52,77.43)
DDR1_DQ29: length 23.8
  L3-SIGNAL1 w0.14: v3(148.7,72.59) 148.34,72.99 148.34,74.63 147.96,75.01 147.63,75.01 142.79,79.85 134.27,79.85 133.92,79.5 133.66,79.5 133.65,79.5 133.38,79.5 133.33,79.5 133.13,79.71 133.13,79.93 132.77,80.29 131.06,80.29 130.74,79.97 130.74,79.63 130.46,79.35 v3(130.32,79.03)
DDR1_DQ30: length 23.7
  L3-SIGNAL1 w0.14: v3(148.73,73.89) 149.11,73.52 149.11,72.49 148.89,72.27 148.56,72.27 146.35,72.27 145.56,71.48 145.17,71.48 144.8,71.11 143.94,71.11 139.73,75.31 136.85,75.31 136.71,75.45 136.71,75.96 136.57,76.1 135.03,76.1 134.63,76.51 134.63,76.82 134.49,76.96 133.61,76.96 133.4,77.18 133.4,77.43 132.91,77.92 132.15,77.92 132.11,77.88 131.45,77.88 131.12,78.21 v3(131.12,78.23)
DDR1_DQ31: length 23.8
  L3-SIGNAL1 w0.14: v3(148.73,74.54) 148.73,75.25 147.89,76.1 147.39,76.1 143.2,80.27 134.51,80.27 134.5,80.28 133.37,80.28 133.1,80.54 133.1,80.77 132.8,81.08 131.08,81.08 130.76,80.76 130.76,80.53 130.44,80.21 130.18,80.21 129.95,79.98 129.95,79.8 129.52,79.36 v3(129.52,79.03)
DDR1_DQS0_N: length 33.1
  L3-SIGNAL1 w0.127: v5(133.87,70.1) v3(133.52,70.23)
  L3-SIGNAL1 w0.129: v6(153.53,64.14) 153.93,63.82 v5(153.93,63.82)
  L4-GND2 w0.127: v6(133.53,70.3) v5(133.87,70.1) ; v6(153.53,64.14) v5(153.93,63.82)
  L5-SIGNAL2 w0.14: v6(133.53,70.3) 133.75,70.08 140.37,70.08 142.25,68.21 142.83,68.21 144.93,66.11 144.93,65.68 144.63,65.38 144.2,65.38 142.49,67.08 142.26,67.08 142.12,66.94 142.12,66.7 144.23,64.59 144.43,64.59 144.79,64.95 145.28,64.95 145.58,64.65 145.58,64.08 145.78,63.88 148.17,63.88 148.73,63.32 150.1,63.32 150.6,63.83 152.6,63.83 152.6,63.83 152.86,63.83 152.87,63.83 152.92,63.83 153.04,63.96 153.35,63.96 v6(153.53,64.14)
  vias: v1(133.52,70.23) v1(153.53,64.14)
DDR1_DQS0_P: length 33.1
  L3-SIGNAL1 w0.127: v5(133.87,69.34) v3(133.52,69.43)
  L3-SIGNAL1 w0.129: v6(153.53,63.49) 153.93,63.17 v5(153.93,63.17)
  L4-GND2 w0.127: v6(153.53,63.49) v5(153.93,63.17) ; v6(133.53,69.5) v5(133.87,69.34)
  L5-SIGNAL2 w0.14: v6(153.53,63.49) 153.35,63.68 153.16,63.68 153.03,63.55 152.98,63.55 152.98,63.55 152.49,63.55 152.48,63.55 150.72,63.55 150.21,63.04 148.61,63.04 148.05,63.6 145.66,63.6 145.3,63.97 145.3,64.54 145.16,64.67 144.9,64.67 144.55,64.31 144.12,64.31 141.84,66.59 141.84,67.06 142.15,67.36 142.61,67.36 144.32,65.65 144.51,65.65 144.65,65.79 144.65,65.99 142.72,67.93 142.13,67.93 140.26,69.8 133.83,69.8 v6(133.53,69.5)
  vias: v1(133.52,69.43) v1(153.53,63.49)
DDR1_DQS1_N: length 24.9
  TOP w0.229: U59.F1 133.52,72.63 v3(133.99,72.35)
  L3-SIGNAL1 w0.129: v3(133.99,72.35) 134.23,72.11 136.4,72.11 141.56,66.96 141.74,66.96 142.16,67.37 142.64,67.37 145.03,64.97 145.03,64.54 144.73,64.23 144.29,64.23 143.05,65.47 142.87,65.47 142.74,65.34 142.74,65.15 144.25,63.65 144.91,63.65 145.34,64.08 146.6,64.08 146.88,63.79 147.31,63.79 147.48,63.96 147.75,63.96 v3(147.93,64.14)
DDR1_DQS1_P: length 24.9
  TOP w0.229: U59.E1 133.52,71.83 v3(133.99,71.55)
  L3-SIGNAL1 w0.129: v3(147.93,63.49) 147.77,63.65 147.61,63.65 147.44,63.48 146.76,63.48 146.47,63.77 145.46,63.77 145.04,63.34 144.12,63.34 142.44,65.03 142.44,65.21 142.44,65.46 142.75,65.77 143.18,65.77 144.42,64.54 144.6,64.54 144.73,64.66 144.73,64.85 142.51,67.07 142.28,67.07 141.87,66.65 141.43,66.65 136.28,71.81 134.25,71.81 v3(133.99,71.55)
DDR1_DQS2_N: length 30.6
  L3-SIGNAL1 w0.129: v5(153.21,72.19) 153.2,72.19 v6(153.53,72.59) ; v5(133.87,75.72) v3(133.52,75.83)
  L4-GND2 w0.127: v6(133.87,75.34) v5(133.87,75.72) ; v6(153.53,72.59) v5(153.21,72.19)
  L5-SIGNAL2 w0.14: v6(153.53,72.59) 153.37,72.76 153.01,72.76 152.86,72.91 152.48,72.91 152.34,73.05 151.54,73.05 151.01,73.58 145.49,73.58 144.27,74.8 142.49,74.8 141.8,75.49 140.97,75.49 140.84,75.36 140.84,74.48 140.55,74.19 140.13,74.19 139.84,74.48 139.84,75.36 139.71,75.49 139.52,75.49 139.39,75.36 139.39,74.48 139.1,74.19 138.68,74.19 138.39,74.48 138.39,75.36 138.26,75.49 138.08,75.49 137.95,75.36 137.95,74.48 137.65,74.19 137.24,74.19 136.94,74.48 136.94,75.36 136.81,75.49 136.55,75.49 136.41,75.35 136.41,74.79 136.09,74.47 135.62,74.47 135.29,74.8 135.29,75.36 135.16,75.49 134.48,75.49 134.35,75.62 134.15,75.62 v6(133.87,75.34)
  vias: v1(133.52,75.83) v1(153.53,72.59)
DDR1_DQS2_P: length 30.6
  L3-SIGNAL1 w0.129: v6(153.53,73.24) 153.93,72.92 v5(153.93,72.92) ; v5(133.89,76.53) v3(133.52,76.63)
  L4-GND2 w0.127: v6(153.53,73.24) v5(153.93,72.92) ; v6(133.89,76.15) v5(133.89,76.53)
  L5-SIGNAL2 w0.14: v6(153.53,73.24) 153.33,73.04 153.13,73.04 152.98,73.19 152.6,73.19 152.46,73.33 151.66,73.33 151.13,73.86 145.6,73.86 144.38,75.08 142.61,75.08 141.92,75.77 140.86,75.77 140.56,75.47 140.56,74.6 140.43,74.47 140.25,74.47 140.12,74.6 140.12,75.47 139.82,75.77 139.41,75.77 139.11,75.47 139.11,74.6 138.98,74.47 138.8,74.47 138.67,74.6 138.67,75.47 138.38,75.77 137.96,75.77 137.67,75.47 137.67,74.6 137.54,74.47 137.35,74.47 137.22,74.6 137.22,75.47 136.93,75.77 136.43,75.77 136.13,75.47 136.13,74.91 135.97,74.75 135.73,74.75 135.57,74.92 135.57,75.47 135.27,75.77 134.59,75.77 134.46,75.9 134.15,75.9 v6(133.89,76.15)
  vias: v1(133.52,76.63) v1(153.53,73.24)
DDR1_DQS3_N: length 23.8
  TOP w0.229: v3(134.08,77.65) 133.52,78.23 U59.N1
  L3-SIGNAL1 w0.129: v3(134.08,77.65) 134.3,77.88 138.94,77.88 139.07,77.75 139.07,77.57 138.94,77.44 137.91,77.44 137.6,77.14 137.6,76.7 137.91,76.4 139.86,76.4 140.17,76.71 140.17,77.75 140.29,77.88 140.5,77.88 140.67,77.7 140.67,75.62 143.34,72.95 145.1,72.95 145.67,73.52 145.99,73.52 146.46,73.05 147.2,73.05 147.46,72.8 147.73,72.8 v3(147.93,72.59)
DDR1_DQS3_P: length 23.8
  TOP w0.229: U59.P1 133.52,79.03 v3(134.08,78.45)
  L3-SIGNAL1 w0.129: v3(147.93,73.24) 147.79,73.1 147.58,73.1 147.33,73.36 146.58,73.36 146.11,73.83 145.55,73.83 144.97,73.25 143.47,73.25 140.98,75.74 140.98,77.83 140.62,78.18 140.17,78.18 139.86,77.88 139.86,76.83 139.73,76.7 138.03,76.7 137.9,76.83 137.9,77.01 138.03,77.14 139.07,77.14 139.37,77.44 139.37,77.88 139.07,78.18 134.35,78.18 v3(134.08,78.45)
DDR1_ODT_CA_A: length 6.8
  TOP w0.127: U71.G2 v2(154.73,65.77)
  L12-SIGNAL5 w0.102: v2(159.58,65.73) 159.57,65.74 157.23,65.74 156.83,65.33 155.17,65.33 v2(154.73,65.77)
  BOTTOM w0.127: R1054.2 v2(159.58,65.73)
DDR1_ODT_CA_B: length 7.5
  TOP w0.127: U71.T2 v2(154.73,70.97)
  L12-SIGNAL5 w0.102: v2(154.73,70.97) 154.73,70.5 155.33,69.9 158.72,69.9 v2(159.6,70.78)
  BOTTOM w0.127: R1127.1 v2(159.6,70.78)
DDR1_RET: length 41.1
  L3-SIGNAL1 w0.089: v3(127.91,73.43) v5(128.13,73.13)
  L4-GND2 w0.102: v5(128.13,73.13) v7(128.05,73.53)
  L10-SIGNAL4 w0.109: v2(164.79,76.8) 164.39,76.4 162.49,76.4 162.01,76.89 129.72,76.89 129.45,76.61 128.16,76.61 127.94,76.39 127.94,74.48 128.05,74.36 v7(128.05,73.53)
  vias: v1(127.92,73.43)
DDR1_RST#: length 30.1
  TOP w0.127: v2(146.73,70.32) 146.74,70.33 146.74,70.9 U71.T11
  L3-SIGNAL1 w0.089: v5(130.69,73.56) v3(130.32,73.43)
  L4-GND2 w0.102: v7(131.12,73.38) v5(130.69,73.56)
  L12-SIGNAL5 w0.102: v7(131.12,73.38) 131.61,72.77 132.9,72.77 134.32,71.35 145.7,71.35 v2(146.73,70.32) 151.79,70.32 152.81,69.29 157.15,69.29 v2(157.41,69.03)
  vias: v1(130.32,73.43)
DDR1_ZQ0: length 0.5
  TOP w0.127: U71.A5 151.93,61.54 v2(151.53,61.22)
DDR1_ZQ1: length 1.7
  TOP w0.127: v2(149.93,61.87) 149.93,61.87 U71.A8
  BOTTOM w0.127: R1040.2 150.16,61.16 149.93,61.38 v2(149.93,61.87)
DDR3_IO_PLL_REFCLK_TEST0P: length 288.7
  L3-SIGNAL1 w0.089: v3(109.52,83.03) v5(109.51,82.7)
  L4-GND2 w0.102: v5(109.51,82.7) 109.51,83.06 v7(109.36,83.21)
  L12-SIGNAL5 w0.102: v7(109.36,83.21) 109.07,83.49 93.18,83.49 92.41,82.73 88.12,82.73 86.44,84.4 86.44,86.39 87.53,87.47 87.53,89.18 92.03,93.68 v2(92.03,95.4) 91.37,96.06 88.68,96.06 88.12,95.5 81.29,95.5 79.83,94.05 72.45,94.05 71.81,93.4 67.81,93.4 64.92,90.52 64.92,60.97 68.49,57.4 68.49,47.47 71.81,44.15 73.43,44.15 77.54,40.04 77.54,35.72 81.24,32.02 81.24,31.41 83.82,28.83 83.82,26.66 86.09,24.39 86.91,24.39 92.7,18.59 108.72,18.59 116.65,10.67 133.43,10.67 134.18,11.42 171.65,11.42 177.62,17.39 181.32,17.39 183.58,19.64 191.86,19.64 193.4,21.18 209.71,21.18 211.69,19.2 213.62,19.2 213.9,19.48 213.9,20.25 212.76,21.39 212.76,23.05 v2(212.33,23.48)
  BOTTOM w0.127: R1247.2 212.3,24.16 212.3,23.5 v2(212.33,23.48) ; TP295.1 92.01,95.43 v2(92.03,95.4)
  vias: v1(109.51,83.03)
DDR3_IO_PLL_TESTOUT0P: length 274.7
  L3-SIGNAL1 w0.089: v3(110.32,82.23) v5(110.24,81.89)
  L4-GND2 w0.102: v5(110.24,81.89) v7(109.99,82.22)
  L12-SIGNAL5 w0.102: v2(212.3,22.79) 211.21,22.79 210.87,23.14 208.26,23.14 207.49,22.37 205.04,22.37 204.27,23.14 194.59,23.14 193.18,21.72 184.12,21.72 182.45,20.06 181.89,20.06 179.66,17.83 177.39,17.83 171.42,11.86 133.64,11.86 133,11.23 116.8,11.23 107.79,20.23 102.99,20.23 101.11,22.12 94.53,22.12 84.44,32.21 82.07,32.21 77.99,36.3 77.99,40.29 72.66,45.62 71.84,45.62 71.6,45.86 71.6,46.11 69.6,48.11 69.6,49.19 70.01,49.6 70.01,52.45 69.5,52.96 69.5,58.98 66.13,62.35 66.13,90.9 67.34,92.11 79.31,92.11 82.1,94.9 88.79,94.9 v2(89.23,95.35) 89.23,91.81 87.08,89.67 87.08,87.7 85.97,86.58 85.97,84.24 87.93,82.28 88.11,82.28 92.97,82.28 93.04,82.21 100.22,82.21 100.97,82.96 107.81,82.96 108.97,81.79 109.56,81.79 v7(109.99,82.22)
  vias: v1(110.31,82.23)
DIR1: length 13.8
  L14-SIGNAL6 w0.089: v2(54.73,51.3) 54.37,50.94 54.37,49.17 v2(57.59,45.96)
  BOTTOM w0.127: U248.3 57.38,46.17 v2(57.59,45.96) 57.4,45.77 U248.2 ; v2(54.73,51.3) 55.11,50.92 U244.3 57.38,50.92 57.59,50.71 57.4,50.52 U244.2
DIR2: length 1.7
  BOTTOM w0.127: R1109.1 55.04,63.91 54.74,64.21 U233.2
DLL_0V8_IN+: length 4.8
  TOP w0.127: R562.1 187.96,41.42 188.07,41.53 C371.2 189.03,41.53 189.24,41.74 U100.10 191.28,41.74 U99.D3
DLL_0V8_IN-: length 6.3
  TOP w0.127: 189.1,42.45 189.39,42.74 U100.8 191.26,42.74 191.46,42.94 191.68,42.94 ; 189.1,42.45 C371.1 188.03,42.45 187.92,42.56 R558.1 ; 189.1,42.45 189.31,42.24 U100.9 ; 191.68,42.94 U99.D1 ; 191.68,42.94 U99.D2
DP0_AUX_N: length 1.8
  TOP w0.094: C52.2 125.2,165.71 arc(125.16,165.77) 125.15,165.82 125.15,166.46 arc(125.18,166.59) 125.26,166.71 arc(125.39,166.91) 125.44,167.15 L18.1
DP0_AUX_P: length 1.8
  TOP w0.094: C51.2 124.83,165.71 arc(124.86,165.77) 124.87,165.82 124.87,166.48 arc(124.85,166.6) 124.78,166.71 arc(124.64,166.92) L18.4
DP0_CONFIG1: length 2.7
  TOP w0.127: v2(121.26,178.62) 121.46,178.41 J9.13
  BOTTOM w0.127: v2(121.26,178.62) 121.31,178.62 R757.1
DP0_CONFIG2: length 2.3
  TOP w0.127: J9.14 v2(121.96,179.23)
DP0_HPD: length 4
  TOP w0.127: v2(123.7,178.59) 123.96,178.33 J9.18
  BOTTOM w0.127: U167.2 123.59,177.17 123.8,177.39 R759.2 123.8,178.49 v2(123.7,178.59)
DP0_HPD_BUF: length 191.7
  L3-SIGNAL1 w0.089: v3(107.9,83.73) 107.66,83.73 106.79,82.86 106.31,82.86 106.1,82.65 103.01,82.65 102.34,83.32 101.82,83.32 95.46,89.68 95.46,91.16 94.47,92.15 v2(91.98,92.15)
  L7-SIGNAL3 w0.109: v2(124.24,173.41) 120.84,170.01 103.26,170.01 102.82,170.45 83.79,170.45 54.24,140.9 54.24,137.98 53.2,136.94 53.2,136.43 52.76,136 52.76,135.04 53.12,134.68 53.12,133.9 54.06,132.95 54.06,131.1 50.89,127.93 50.89,124.7 v2(51.25,124.34)
  L14-SIGNAL6 w0.089: v2(51.25,124.34) 52.86,125.95 62.64,125.95 63.1,126.42 64.71,126.42 68.28,122.84 68.28,121.43 70.26,119.46 81.77,119.46 85.39,115.84 85.39,114.82 87.28,112.93 87.28,100.94 89.72,98.5 89.72,94.41 v2(91.98,92.15)
  BOTTOM w0.127: U167.4 v2(124.24,173.41)
  vias: v1(107.89,83.73)
DP0_PWR_SW_EN: length 8
  L3-SIGNAL1 w0.089: v2(134.16,165.49) 133.33,164.66 133.33,160.64 133.79,160.18 v3(134.1,160.18)
  BOTTOM w0.127: U174.5 133.39,166.55 133.64,166.3 133.64,166.01 v2(134.16,165.49)
DP0_TX0_N: length 1.8
  TOP w0.094: L14.1 113.52,169.03 arc(113.47,168.79) 113.34,168.59 arc(113.26,168.48) 113.24,168.34 113.24,167.71 arc(113.25,167.65) 113.28,167.6 C45.2
DP0_TX0_P: length 1.8
  TOP w0.094: C44.2 112.91,167.6 arc(112.94,167.65) 112.96,167.71 112.96,168.36 arc(112.93,168.49) 112.86,168.59 arc(112.72,168.8) L14.4
DP0_TX1_N: length 1.8
  TOP w0.094: L11.1 116.44,170.43 arc(116.39,170.19) 116.26,169.99 arc(116.18,169.88) 116.16,169.74 116.16,169.11 arc(116.17,169.05) 116.2,169 C38.2
DP0_TX1_P: length 1.8
  TOP w0.094: C37.2 115.83,169 arc(115.86,169.05) 115.88,169.11 115.88,169.76 arc(115.85,169.88) 115.78,169.99 arc(115.64,170.2) L11.4
DP0_TX2_N: length 1.8
  TOP w0.094: C47.2 119.15,167.35 arc(119.11,167.4) 119.1,167.46 119.1,168.09 arc(119.13,168.22) 119.21,168.34 arc(119.34,168.54) 119.39,168.78 L16.1
DP0_TX2_P: length 1.8
  TOP w0.094: C46.2 118.78,167.35 arc(118.81,167.4) 118.82,167.46 118.82,168.11 arc(118.8,168.23) 118.73,168.34 arc(118.59,168.55) L16.4
DP0_TX3_N: length 1.8
  TOP w0.094: C40.2 122.15,169 arc(122.12,169.05) 122.1,169.11 122.1,169.74 arc(122.13,169.87) 122.21,169.99 arc(122.34,170.19) 122.39,170.43 L12.1
DP0_TX3_P: length 1.8
  TOP w0.094: C39.2 121.78,169 arc(121.81,169.05) 121.83,169.11 121.83,169.76 arc(121.8,169.88) 121.73,169.99 arc(121.59,170.2) L12.4
DP1_AUX_N: length 43.7
  TOP w0.094: v3(99.57,166.47) L17.1
  L3-SIGNAL1 w0.079: v3(99.57,166.47) v5(99.57,166.11)
  L4-GND2 w0.089: v7(99.57,165.69) v5(99.57,166.11)
  L12-SIGNAL5 w0.089: v7(99.57,165.69) 99.36,165.48 arc(99.28,165.37) 99.25,165.23 99.25,157.9 arc(99.38,157.23) 99.76,156.67 101.75,154.68 arc(102.4,153.7) 102.63,152.55 102.63,152.1 arc(102.84,151.06) 103.43,150.18 111.16,142.45 arc(111.63,141.75) 111.79,140.93 111.79,140.1 arc(111.81,140.01) 111.85,139.94 v8(111.97,139.83)
  L13-GND5 w0.089: v8(111.97,139.83) v9(111.97,139.5)
  L14-SIGNAL6 w0.079: v11(104.21,136.99) 104.01,137.18 arc(103.98,137.22) 103.97,137.27 103.97,138.66 arc(104.2,139.21) 104.75,139.44 108.67,139.44 arc(109.13,139.35) 109.51,139.09 109.84,138.76 arc(110.08,138.6) 110.36,138.54 111.22,138.54 arc(111.63,138.71) 111.8,139.13 111.8,139.25 arc(111.81,139.29) 111.82,139.32 111.86,139.39 v9(111.97,139.5)
DP1_AUX_P: length 43.7
  TOP w0.094: L17.4 v3(98.72,166.47)
  L3-SIGNAL1 w0.079: v3(98.72,166.47) v5(98.72,166.11)
  L4-GND2 w0.089: v5(98.72,166.11) v7(98.72,165.69)
  L12-SIGNAL5 w0.089: v7(98.72,165.69) 98.93,165.48 arc(99,165.37) 99.03,165.23 99.03,157.9 arc(99.18,157.15) 99.61,156.51 101.6,154.52 arc(102.2,153.62) 102.42,152.55 102.42,152.1 arc(102.64,150.98) 103.27,150.03 111.01,142.3 arc(111.43,141.67) 111.57,140.93 111.57,140.1 arc(111.56,140.01) 111.51,139.94 v8(111.39,139.83)
  L13-GND5 w0.089: v8(111.39,139.83) v9(111.39,139.5)
  L14-SIGNAL6 w0.079: v11(103.5,136.99) 103.69,137.18 arc(103.72,137.22) 103.73,137.27 103.73,138.66 arc(104.03,139.38) 104.75,139.68 108.67,139.68 arc(109.22,139.57) 109.68,139.26 110.01,138.93 arc(110.17,138.83) 110.36,138.79 111.22,138.79 arc(111.46,138.89) 111.56,139.13 111.56,139.25 arc(111.56,139.29) 111.55,139.32 111.5,139.39 v9(111.39,139.5)
DP1_CONFIG1: length 2.7
  TOP w0.127: v2(95.39,178.62) 95.59,178.41 J8.13
  BOTTOM w0.127: v2(95.39,178.62) 95.43,178.62 R758.1
DP1_CONFIG2: length 2.3
  TOP w0.127: J8.14 v2(96.09,179.23)
DP1_HPD: length 4.2
  TOP w0.127: J8.18 98.09,178.33 v2(97.82,178.59)
  BOTTOM w0.127: v2(97.82,178.59) 97.82,178.1 97.89,178.04 R760.2 97.45,177.37 U168.2
DP1_HPD_BUF: length 2.7
  BOTTOM w0.127: R776.2 98.24,172.58 98.41,172.75 98.41,173.27 98.1,173.58 U168.4
DP1_PWR_SW_EN: length 37.7
  TOP w0.127: U18.3 134.6,159.65 v3(134.29,159.34)
  L3-SIGNAL1 w0.089: v2(104.81,168.32) 105.13,168.64 106.92,168.64 107.13,168.43 107.13,166.04 109.78,163.38 116.55,163.38 117.21,162.73 123.08,162.73 123.83,161.97 129.95,161.97 130.61,161.32 131.95,161.32 133.52,159.76 133.88,159.76 v3(134.29,159.34)
  BOTTOM w0.127: v2(104.81,168.32) 105.33,168.84 105.62,168.84 105.87,169.09 U169.5
DP1_TX0_N: length 43.7
  TOP w0.094: v3(87.65,168.35) L13.1
  L3-SIGNAL1 w0.079: v3(87.65,168.35) v5(87.65,168)
  L4-GND2 w0.089: v7(87.65,167.58) v5(87.65,168)
  L12-SIGNAL5 w0.089: v7(87.65,167.58) 87.45,167.38 arc(87.36,167.25) 87.33,167.1 87.33,164.32 arc(87.17,163.94) 86.78,163.78 86.31,163.78 arc(85.98,163.45) 86.31,163.11 86.78,163.11 arc(87.17,162.96) 87.33,162.57 87.33,161.68 arc(87.17,161.29) 86.78,161.13 86.26,161.13 arc(85.93,160.8) 86.26,160.47 86.78,160.47 arc(87.17,160.31) 87.33,159.93 87.33,158.02 arc(87.42,157.59) 87.66,157.23 89.26,155.63 105.12,139.77 arc(105.37,139.39) 105.46,138.94 105.46,137.98 arc(105.48,137.9) 105.53,137.82 v8(105.71,137.64)
  L13-GND5 w0.089: v8(105.71,137.64) v9(105.71,137.31)
  L14-SIGNAL6 w0.079: v11(105.71,136.99) v9(105.71,137.31)
DP1_TX0_P: length 43.7
  TOP w0.094: L13.4 v3(86.8,168.35)
  L3-SIGNAL1 w0.079: v3(86.8,168.35) v5(86.8,168)
  L4-GND2 w0.089: v5(86.8,168) v7(86.8,167.58)
  L12-SIGNAL5 w0.089: v7(86.8,167.58) 87,167.38 arc(87.09,167.25) 87.11,167.1 87.11,164.32 arc(87.02,164.09) 86.78,163.99 86.31,163.99 arc(85.76,163.45) 86.31,162.9 86.78,162.9 arc(87.02,162.8) 87.11,162.57 87.11,161.68 arc(87.02,161.45) 86.78,161.35 86.26,161.35 arc(85.72,160.8) 86.26,160.26 86.78,160.26 arc(87.02,160.16) 87.11,159.93 87.11,158.02 arc(87.22,157.51) 87.51,157.07 88.74,155.85 104.96,139.62 arc(105.17,139.31) 105.24,138.94 105.24,137.98 arc(105.23,137.9) 105.18,137.82 v8(105,137.64)
  L13-GND5 w0.089: v8(105,137.64) v9(105,137.31)
  L14-SIGNAL6 w0.079: v9(105,137.31) v11(105,136.99)
DP1_TX1_N: length 43.7
  TOP w0.094: v3(90.57,169.75) L9.1
  L3-SIGNAL1 w0.079: v3(90.57,169.75) v5(90.57,169.4)
  L4-GND2 w0.089: v7(90.57,168.98) v5(90.57,169.4)
  L12-SIGNAL5 w0.089: v8(107.55,137.64) 107.37,137.83 arc(107.32,137.89) 107.31,137.98 107.31,138.49 arc(107.13,139.4) 106.61,140.17 92.57,154.21 arc(90.86,156.78) 90.25,159.81 90.25,162.8 arc(90.09,163.19) 89.71,163.35 89.28,163.35 arc(88.95,163.68) 89.28,164.01 89.71,164.01 arc(90.09,164.17) 90.25,164.55 90.25,165.96 arc(90.09,166.34) 89.71,166.5 89.45,166.5 arc(89.12,166.83) 89.45,167.16 89.71,167.16 arc(90.09,167.32) 90.25,167.71 90.25,168.53 arc(90.28,168.65) 90.34,168.75 v7(90.57,168.98)
  L13-GND5 w0.089: v8(107.55,137.64) v9(107.55,137.31)
  L14-SIGNAL6 w0.079: v11(107.55,136.99) v9(107.55,137.31)
DP1_TX1_P: length 43.7
  TOP w0.094: L9.4 v3(89.72,169.75)
  L3-SIGNAL1 w0.079: v3(89.72,169.75) v5(89.72,169.4)
  L4-GND2 w0.089: v5(89.72,169.4) v7(89.72,168.98)
  L12-SIGNAL5 w0.089: v8(106.84,137.64) 107.03,137.83 arc(107.07,137.89) 107.09,137.98 107.09,138.49 arc(106.93,139.31) 106.46,140.02 92.42,154.05 arc(90.66,156.69) 90.04,159.81 90.04,162.8 arc(89.94,163.03) 89.71,163.13 89.28,163.13 arc(88.73,163.68) 89.28,164.22 89.71,164.22 arc(89.94,164.32) 90.04,164.55 90.04,165.96 arc(89.94,166.19) 89.71,166.29 89.45,166.29 arc(88.91,166.83) 89.45,167.38 89.71,167.38 arc(89.94,167.48) 90.04,167.71 90.04,168.53 arc(90.01,168.65) 89.94,168.75 v7(89.72,168.98)
  L13-GND5 w0.089: v8(106.84,137.64) v9(106.84,137.31)
  L14-SIGNAL6 w0.079: v11(106.84,136.99) v9(106.84,137.31)
DP1_TX2_N: length 43.6
  TOP w0.094: v3(93.52,168.1) L15.1
  L3-SIGNAL1 w0.079: v5(93.52,167.75) v3(93.52,168.1)
  L4-GND2 w0.089: v7(93.52,167.33) v5(93.52,167.75)
  L12-SIGNAL5 w0.089: v8(109.21,137.64) 109.04,137.81 arc(108.98,137.9) 108.96,138 108.96,138.95 arc(108.82,139.63) 108.44,140.2 95.2,153.45 arc(93.72,155.66) 93.2,158.27 93.2,159.94 arc(93.04,160.32) 92.65,160.48 91.66,160.48 arc(91.33,160.81) 91.66,161.14 92.65,161.14 arc(93.04,161.3) 93.2,161.69 93.2,162.17 arc(93.04,162.56) 92.65,162.72 91.92,162.72 arc(91.59,163.05) 91.92,163.38 92.65,163.38 arc(93.04,163.54) 93.2,163.93 93.2,166.87 arc(93.22,167) 93.3,167.11 v7(93.52,167.33)
  L13-GND5 w0.089: v9(109.21,137.31) v8(109.21,137.64)
  L14-SIGNAL6 w0.079: v11(109.21,136.99) v9(109.21,137.31)
DP1_TX2_P: length 43.6
  TOP w0.094: L15.4 v3(92.67,168.1)
  L3-SIGNAL1 w0.079: v3(92.67,168.1) v5(92.67,167.75)
  L4-GND2 w0.089: v5(92.67,167.75) v7(92.67,167.33)
  L12-SIGNAL5 w0.089: v8(108.5,137.64) 108.67,137.81 arc(108.72,137.9) 108.74,138 108.74,138.95 arc(108.63,139.55) 108.29,140.05 95.04,153.29 arc(93.52,155.58) 92.98,158.27 92.98,159.94 arc(92.89,160.17) 92.65,160.27 91.66,160.27 arc(91.12,160.81) 91.66,161.36 92.65,161.36 arc(92.89,161.46) 92.98,161.69 92.98,162.17 arc(92.89,162.41) 92.65,162.5 91.92,162.5 arc(91.37,163.05) 91.92,163.6 92.65,163.6 arc(92.89,163.69) 92.98,163.93 92.98,166.87 arc(92.96,167) 92.88,167.11 v7(92.67,167.33)
  L13-GND5 w0.089: v9(108.5,137.31) v8(108.5,137.64)
  L14-SIGNAL6 w0.079: v11(108.5,136.99) v9(108.5,137.31)
DP1_TX3_N: length 43.6
  TOP w0.094: v3(96.52,169.75) L10.1
  L3-SIGNAL1 w0.079: v5(96.52,169.4) v3(96.52,169.75)
  L4-GND2 w0.089: v7(96.52,168.98) v5(96.52,169.4)
  L12-SIGNAL5 w0.089: v8(111.05,137.64) 110.87,137.83 arc(110.82,137.89) 110.81,137.98 110.81,139.25 arc(110.53,140.67) 109.73,141.86 97.53,154.06 arc(96.54,155.53) 96.2,157.26 96.2,164.06 arc(96.04,164.44) 95.65,164.6 95.09,164.6 arc(94.76,164.93) 95.09,165.26 95.65,165.26 arc(96.2,165.81) 95.65,166.35 95.09,166.35 arc(94.76,166.68) 95.09,167.02 95.65,167.02 arc(96.04,167.18) 96.2,167.56 96.2,168.55 arc(96.22,168.65) 96.28,168.73 v7(96.52,168.98)
  L13-GND5 w0.089: v8(111.05,137.64) v9(111.05,137.31)
  L14-SIGNAL6 w0.079: v11(111.05,136.99) v9(111.05,137.31)
DP1_TX3_P: length 43.6
  TOP w0.094: L10.4 v3(95.67,169.75)
  L3-SIGNAL1 w0.079: v3(95.67,169.75) v5(95.67,169.4)
  L4-GND2 w0.089: v5(95.67,169.4) v7(95.67,168.98)
  L12-SIGNAL5 w0.089: v8(110.34,137.64) 110.53,137.83 arc(110.57,137.89) 110.59,137.97 110.59,137.98 110.59,139.25 arc(110.33,140.58) 109.57,141.71 97.37,153.91 arc(96.35,155.45) 95.98,157.26 95.98,164.06 arc(95.89,164.29) 95.65,164.39 95.09,164.39 arc(94.55,164.93) 95.09,165.48 95.65,165.48 arc(95.98,165.81) 95.65,166.14 95.09,166.14 arc(94.55,166.68) 95.09,167.23 95.65,167.23 arc(95.89,167.33) 95.98,167.56 95.98,168.55 arc(95.96,168.65) 95.91,168.73 v7(95.67,168.98)
  L13-GND5 w0.089: v8(110.34,137.64) v9(110.34,137.31)
  L14-SIGNAL6 w0.079: v11(110.34,136.99) v9(110.34,137.31)
DSI0_TX0_N: length 52
  L3-SIGNAL1 w0.084: v3(113.52,92.63) v5(113.24,92.86)
  L4-GND2 w0.084: v5(113.24,92.86) v7(112.93,93.17)
  L13-GND5 w0.084: v9(112.64,93.45) 112.72,93.38 v7(112.93,93.17)
  L14-SIGNAL6 w0.084: v9(112.64,93.45) 112.7,93.51 arc(112.77,93.62) 112.8,93.76 112.8,93.93 arc(112.75,94.04) 112.63,94.09 112.45,94.09 arc(112.23,94.14) 112.05,94.26 110.53,95.77 arc(110.28,96.15) 110.19,96.6 110.19,100.62 arc(110.03,101.03) 109.62,101.19 108.71,101.19 arc(108.34,101.27) 108.03,101.47 103.89,105.62 arc(103.7,106.09) 103.89,106.55 104.58,107.25 arc(104.68,107.48) 104.58,107.71 104.58,107.71 arc(104.35,107.81) 104.12,107.71 103.42,107.01 arc(102.96,106.82) 102.49,107.01 101.49,108.02 arc(101.22,108.42) 101.13,108.9 101.13,109.8 arc(101.32,110.26) 101.78,110.45 102.04,110.45 arc(102.22,110.53) 102.29,110.71 102.29,110.78 arc(102.2,111.01) 101.97,111.11 101.78,111.11 arc(101.13,111.77) 101.78,112.42 102.04,112.42 arc(102.22,112.5) 102.29,112.68 102.29,112.75 arc(102.2,112.98) 101.97,113.08 101.78,113.08 arc(101.32,113.27) 101.13,113.74 101.13,114.7 arc(100.94,115.61) 100.42,116.39 96.88,119.94 arc(96.56,120.41) 96.45,120.96 96.45,124.76 arc(96.74,125.44) 97.42,125.73 97.63,125.73 arc(97.81,125.76) v11(97.96,125.87)
  BOTTOM w0.127: U187.20 101.56,125.82 98.06,125.82 arc(98.01,125.83) v11(97.96,125.87)
  vias: v1(113.51,92.63)
DSI0_TX0_P: length 52
  L3-SIGNAL1 w0.084: v3(114.32,92.63) v5(114.04,92.86)
  L4-GND2 w0.084: v5(114.04,92.86) v7(113.73,93.17)
  L13-GND5 w0.084: v7(113.73,93.17) 113.52,93.38 v9(113.44,93.45)
  L14-SIGNAL6 w0.084: v9(113.44,93.45) 113.44,93.39 arc(113.28,93.23) 113.13,93.39 113.13,93.93 arc(112.98,94.28) 112.63,94.42 112.45,94.42 arc(112.36,94.44) 112.28,94.5 110.77,96.01 arc(110.59,96.28) 110.52,96.6 110.52,100.62 arc(110.26,101.26) 109.62,101.52 108.71,101.52 arc(108.47,101.57) 108.27,101.71 104.12,105.85 arc(104.03,106.09) 104.12,106.32 104.82,107.01 arc(105.01,107.48) 104.82,107.94 arc(104.35,108.14) 103.89,107.94 103.19,107.25 arc(102.96,107.15) 102.73,107.25 101.72,108.25 arc(101.53,108.55) 101.46,108.9 101.46,109.8 arc(101.55,110.03) 101.78,110.12 102.04,110.12 arc(102.45,110.29) 102.62,110.71 102.62,110.78 arc(102.43,111.25) 101.97,111.44 101.78,111.44 arc(101.46,111.77) 101.78,112.09 102.04,112.09 arc(102.45,112.27) 102.62,112.68 102.62,112.75 arc(102.43,113.22) 101.97,113.41 101.78,113.41 arc(101.55,113.51) 101.46,113.74 101.46,114.7 arc(101.25,115.74) 100.66,116.62 97.11,120.17 arc(96.87,120.53) 96.78,120.96 96.78,124.76 arc(96.97,125.21) 97.42,125.4 97.63,125.4 arc(97.81,125.36) v11(97.96,125.26)
  BOTTOM w0.127: U187.19 101.56,125.3 98.06,125.3 arc(98.01,125.29) v11(97.96,125.26)
  vias: v1(114.31,92.63)
DSI0_TX1_N: length 51.9
  L3-SIGNAL1 w0.084: v3(112.72,91.83) v5(112.44,92.06)
  L4-GND2 w0.084: v5(112.44,92.06) v7(112.13,92.37)
  L13-GND5 w0.084: v7(112.13,92.37) 111.92,92.58 v9(111.84,92.65)
  L14-SIGNAL6 w0.084: v11(96.95,126.86) 96.94,126.86 arc(96.79,126.76) 96.6,126.72 96.43,126.72 arc(96.12,126.66) 95.86,126.49 95.26,125.88 arc(95.03,125.55) 94.95,125.14 94.95,120.12 arc(95.05,119.64) 95.32,119.23 95.94,118.61 arc(96.03,118.38) 95.94,118.15 95.7,117.91 arc(95.51,117.45) 95.7,116.98 arc(96.17,116.79) 96.63,116.98 96.87,117.22 arc(97.1,117.32) 97.33,117.22 arc(97.43,116.99) 97.33,116.76 97.09,116.52 arc(96.9,116.05) 97.09,115.59 arc(97.56,115.4) 98.02,115.59 98.26,115.83 arc(98.49,115.92) 98.73,115.83 99.43,115.13 arc(99.78,114.59) 99.91,113.97 99.91,109.04 arc(100.11,108.01) 100.7,107.13 108.62,99.21 arc(108.88,98.82) 108.97,98.35 108.97,96.16 arc(109.09,95.58) 109.42,95.09 110.96,93.54 arc(111.24,93.36) 111.57,93.29 111.81,93.29 arc(111.92,93.24) 111.97,93.13 111.97,92.87 arc(111.96,92.79) 111.91,92.73 v9(111.84,92.65)
  BOTTOM w0.127: U187.22 101.56,126.82 97.05,126.82 arc(96.99,126.83) v11(96.95,126.86)
  vias: v1(112.71,91.83)
DSI0_TX1_P: length 51.9
  L3-SIGNAL1 w0.084: v3(113.52,91.83) v5(113.24,92.06)
  L4-GND2 w0.084: v5(113.24,92.06) v7(112.93,92.37)
  L13-GND5 w0.084: v7(112.93,92.37) 112.72,92.58 v9(112.64,92.65)
  L14-SIGNAL6 w0.084: v9(112.64,92.65) 112.64,92.61 arc(112.47,92.45) 112.3,92.61 112.3,93.13 arc(112.16,93.48) 111.81,93.62 111.57,93.62 arc(111.36,93.66) 111.19,93.78 109.65,95.32 arc(109.39,95.7) 109.3,96.16 109.3,98.35 arc(109.19,98.95) 108.85,99.45 100.93,107.37 arc(100.42,108.14) 100.24,109.04 100.24,113.97 arc(100.09,114.72) 99.66,115.36 98.96,116.06 arc(98.49,116.25) 98.03,116.06 97.79,115.82 arc(97.56,115.73) 97.33,115.82 arc(97.23,116.05) 97.33,116.29 97.57,116.52 arc(97.76,116.99) 97.57,117.45 arc(97.1,117.65) 96.64,117.45 96.4,117.22 arc(96.17,117.12) 95.93,117.22 arc(95.84,117.45) 95.93,117.68 96.17,117.92 arc(96.36,118.38) 96.17,118.85 95.55,119.47 arc(95.35,119.76) 95.28,120.12 95.28,125.14 arc(95.34,125.42) 95.49,125.65 96.09,126.25 arc(96.25,126.35) 96.43,126.39 96.63,126.39 arc(96.8,126.36) v11(96.95,126.26)
  BOTTOM w0.127: U187.21 101.56,126.3 97.05,126.3 arc(96.99,126.29) v11(96.95,126.26)
  vias: v1(113.51,91.83)
DSI0_TX2_N: length 51.8
  L3-SIGNAL1 w0.084: v3(114.32,93.43) v5(114.04,93.66)
  L4-GND2 w0.084: v5(114.04,93.66) v7(113.73,93.97)
  L13-GND5 w0.084: v9(113.44,94.25) 113.52,94.18 v7(113.73,93.97)
  L14-SIGNAL6 w0.084: v9(113.44,94.25) 113.5,94.31 arc(113.57,94.42) 113.6,94.56 113.6,94.75 arc(113.57,94.91) 113.48,95.04 112.75,95.77 112.19,96.33 arc(111.91,96.74) 111.82,97.22 111.82,100.56 arc(111.75,100.91) 111.55,101.21 107.63,105.13 arc(107.42,105.44) 107.35,105.81 107.35,106.42 arc(107.28,106.78) 107.07,107.08 104.65,109.51 arc(103.88,110.65) 103.61,112.01 103.61,117.75 arc(103.47,118.1) 103.13,118.24 101.23,118.24 arc(100.83,118.4) 100.67,118.8 100.67,119.34 arc(100.82,119.71) 101.19,119.86 102.61,119.86 arc(102.73,119.91) 102.78,120.03 102.78,120.92 arc(102.65,121.23) 102.34,121.36 99.98,121.36 arc(99.01,121.76) 98.61,122.73 98.61,128.09 arc(98.58,128.26) 98.48,128.4 98.16,128.72 arc(98.04,128.9) 98,129.11 98,129.23 arc(98.15,129.58) 98.5,129.73 98.67,129.73 arc(98.85,129.76) v11(99,129.87)
  BOTTOM w0.127: U187.28 101.56,129.82 99.1,129.82 arc(99.05,129.83) v11(99,129.87)
  vias: v1(114.31,93.43)
DSI0_TX2_P: length 51.9
  L3-SIGNAL1 w0.084: v3(115.12,93.43) v5(114.84,93.66)
  L4-GND2 w0.084: v5(114.84,93.66) v7(114.53,93.97)
  L13-GND5 w0.084: v9(114.24,94.25) 114.32,94.18 v7(114.53,93.97)
  L14-SIGNAL6 w0.084: v9(114.24,94.25) 114.24,94.21 arc(114.08,94.06) 113.93,94.21 113.93,94.75 arc(113.87,95.03) 113.72,95.27 112.42,96.56 arc(112.22,96.86) 112.15,97.22 112.15,100.56 arc(112.05,101.04) 111.79,101.44 107.86,105.36 arc(107.73,105.57) 107.68,105.81 107.68,106.42 arc(107.58,106.9) 107.3,107.32 104.88,109.74 arc(104.19,110.78) 103.95,112.01 103.95,117.75 arc(103.71,118.33) 103.13,118.57 101.23,118.57 arc(101.07,118.63) 101,118.8 101,119.34 arc(101.05,119.48) 101.19,119.53 102.61,119.53 arc(102.96,119.68) 103.11,120.03 103.11,120.92 arc(102.88,121.47) 102.34,121.69 99.98,121.69 arc(99.25,122) 98.94,122.73 98.94,128.09 arc(98.88,128.38) 98.72,128.63 98.4,128.95 arc(98.35,129.02) 98.33,129.11 98.33,129.23 arc(98.38,129.35) 98.5,129.4 98.67,129.4 arc(98.85,129.36) v11(99,129.26)
  BOTTOM w0.127: U187.27 101.56,129.3 99.1,129.3 arc(99.06,129.3) 99.01,129.31 99.01,129.27 v11(99,129.26)
  vias: v1(115.11,93.43)
DSI0_TX3_N: length 51.8
  L3-SIGNAL1 w0.084: v3(115.12,94.23) v5(114.84,94.46)
  L4-GND2 w0.084: v5(114.84,94.46) v7(114.53,94.77)
  L13-GND5 w0.084: v7(114.53,94.77) 114.32,94.98 v9(114.24,95.05)
  L14-SIGNAL6 w0.084: v11(100.37,130.87) 100.28,130.77 arc(100.23,130.74) 100.18,130.73 100.01,130.73 arc(99.66,130.58) 99.51,130.23 99.51,129.92 arc(99.58,129.57) 99.78,129.28 99.94,129.11 arc(100.09,128.9) 100.14,128.65 100.14,127.43 arc(100.31,127) 100.74,126.82 106.13,126.82 arc(106.33,126.74) 106.41,126.54 106.41,125.69 arc(106.36,125.58) 106.24,125.53 104.17,125.53 arc(103.54,125.27) 103.28,124.64 103.28,123.2 arc(103.36,122.83) 103.57,122.52 104.93,121.15 arc(105,121.06) 105.02,120.95 105.02,111.4 arc(105.11,110.93) 105.37,110.53 109.53,106.38 arc(109.7,106.12) 109.76,105.82 109.76,105.28 arc(109.82,105) 109.97,104.77 112.31,102.43 arc(112.91,101.54) 113.11,100.49 113.11,99.33 arc(113.19,98.96) 113.4,98.65 113.49,98.55 114.01,98.04 arc(114.3,97.61) 114.4,97.09 114.4,95.36 arc(114.37,95.22) 114.3,95.11 v9(114.24,95.05)
  BOTTOM w0.127: U187.30 101.56,130.82 100.48,130.82 arc(100.42,130.83) v11(100.37,130.87)
  vias: v1(115.11,94.23)
DSI0_TX3_P: length 51.9
  L3-SIGNAL1 w0.084: v3(115.92,94.23) v5(115.64,94.46)
  L4-GND2 w0.084: v5(115.64,94.46) v7(115.33,94.77)
  L13-GND5 w0.084: v9(115.04,95.05) 115.12,94.98 v7(115.33,94.77)
  L14-SIGNAL6 w0.084: v11(100.37,130.26) 100.28,130.36 arc(100.23,130.39) 100.18,130.4 100.01,130.4 arc(99.89,130.35) 99.84,130.23 99.84,129.92 arc(99.88,129.7) 100.01,129.51 100.18,129.35 arc(100.39,129.03) 100.47,128.65 100.47,127.43 arc(100.55,127.23) 100.74,127.15 106.13,127.15 arc(106.56,126.97) 106.74,126.54 106.74,125.69 arc(106.59,125.34) 106.24,125.2 104.17,125.2 arc(103.78,125.03) 103.61,124.64 103.61,123.2 arc(103.66,122.96) 103.8,122.75 105.17,121.38 arc(105.3,121.18) 105.35,120.95 105.35,111.4 arc(105.42,111.06) 105.61,110.77 109.77,106.61 arc(110.01,106.25) 110.09,105.82 110.09,105.28 arc(110.12,105.13) 110.2,105 112.54,102.66 arc(113.21,101.67) 113.44,100.49 113.44,99.33 arc(113.49,99.09) 113.63,98.88 114.24,98.28 arc(114.6,97.73) 114.73,97.09 114.73,94.99 arc(114.88,94.83) 115.04,94.99 v9(115.04,95.05)
  BOTTOM w0.127: U187.29 101.56,130.3 100.48,130.3 arc(100.42,130.29) v11(100.37,130.26)
  vias: v1(115.91,94.23)
DSI0_TX_CALIB: length 30
  L3-SIGNAL1 w0.089: v3(114.32,90.23) v5(114.04,90.46)
  L4-GND2 w0.102: v5(114.04,90.46) v7(113.73,90.77)
  L12-SIGNAL5 w0.102: v7(113.73,90.77) 113.54,90.58 113.54,88.9 113.29,88.65 95.03,88.65 94.65,88.27 89.71,88.27 v2(87.44,85.99)
  vias: v1(114.31,90.23)
DSI0_TXCLK_N: length 51.9
  L3-SIGNAL1 w0.084: v3(111.92,91.03) v5(111.64,91.26)
  L4-GND2 w0.084: v5(111.64,91.26) v7(111.33,91.57)
  L13-GND5 w0.084: v7(111.33,91.57) 111.12,91.78 v9(111.04,91.85)
  L14-SIGNAL6 w0.084: v9(111.04,91.85) 111.11,91.93 arc(111.16,91.99) 111.17,92.07 111.17,92.33 arc(111.13,92.44) 111.02,92.48 110.22,92.48 arc(108.48,93.2) 107.76,94.95 107.76,97.51 arc(107.69,97.86) 107.49,98.16 99.07,106.58 arc(98.6,107.28) 98.44,108.1 98.44,111.04 arc(98.25,111.97) 97.72,112.77 94.83,115.66 arc(94.05,116.83) 93.77,118.21 93.77,125.81 arc(93.85,126.23) 94.09,126.58 95.4,127.89 arc(95.79,128.15) 96.26,128.25 97.44,128.25 arc(97.6,128.28) v11(97.73,128.36)
  BOTTOM w0.127: U187.25 101.56,128.32 97.83,128.32 arc(97.78,128.33) v11(97.73,128.36)
  vias: v1(111.91,91.03)
DSI0_TXCLK_P: length 51.9
  L3-SIGNAL1 w0.084: v3(112.72,91.03) v5(112.44,91.26)
  L4-GND2 w0.084: v5(112.44,91.26) v7(112.13,91.57)
  L13-GND5 w0.084: v9(111.84,91.85) 111.92,91.78 v7(112.13,91.57)
  L14-SIGNAL6 w0.084: v9(111.84,91.85) 111.84,91.84 arc(111.79,91.72) 111.67,91.67 arc(111.55,91.72) 111.5,91.84 111.5,92.33 arc(111.36,92.67) 111.02,92.81 110.22,92.81 arc(108.71,93.44) 108.09,94.95 108.09,97.51 arc(107.99,97.99) 107.72,98.39 99.3,106.81 arc(98.91,107.4) 98.77,108.1 98.77,111.04 arc(98.56,112.1) 97.96,113 95.06,115.9 arc(94.35,116.96) 94.1,118.21 94.1,125.81 arc(94.16,126.1) 94.32,126.35 95.63,127.65 arc(95.92,127.85) 96.26,127.91 97.36,127.91 arc(97.56,127.87) v11(97.73,127.76)
  BOTTOM w0.127: U187.24 101.56,127.8 97.83,127.8 arc(97.78,127.79) v11(97.73,127.76)
  vias: v1(112.71,91.03)
DSI1_TX_CALIB: length 23.7
  L3-SIGNAL1 w0.089: v3(112.72,90.23) v5(112.44,90.46)
  L4-GND2 w0.102: v5(112.44,90.46) v7(112.13,90.77)
  L13-GND5 w0.102: v9(111.84,90.48) 111.92,90.55 v7(112.13,90.77)
  L14-SIGNAL6 w0.089: v9(111.84,90.48) 109.33,90.48 108.23,91.58 107.36,91.58 106.79,91.01 102.7,91.01 101.08,89.39 96.94,89.39 96.89,89.43 95.36,89.43 94.85,88.93 91.29,88.93 v11(91.06,88.69)
  vias: v1(112.71,90.23)
EDP_ADDR: length 4.1
  BOTTOM w0.127: U187.1 111.02,121.8 111.38,121.44 113.55,121.44 R915.1
EDP_GPIO1: length 6.5
  BOTTOM w0.127: R893.2 R894.1 117.09,125.67 116.98,125.79 115.86,125.79 114.33,127.31 U187.58
EDP_GPIO2: length 5.9
  BOTTOM w0.127: R883.2 R884.1 117.09,127.92 116.96,128.05 115.65,128.05 115.39,128.31 U187.56
EDP_GPIO3: length 4.2
  BOTTOM w0.127: U187.54 114.77,129.31 R874.1 115.23,130.19 115.45,130.41 115.93,130.41 116.07,130.55 R864.2
EDP_GPIO4: length 6.2
  BOTTOM w0.127: U187.57 114.98,127.81 115.86,126.93 116.92,126.93 117.09,126.77 R890.1 R889.2
EDP_I2C4_SCL: length 76.6
  TOP w0.127: R113.2 128.47,157.88 U20.3 128.58,158.89 128.58,159.94 129.17,160.52 130.56,160.52 v2(130.9,160.86)
  L7-SIGNAL3 w0.109: v2(101.73,120.43) 102.52,121.22 112.62,121.22 120.53,129.14 120.53,130.73 138.3,148.5 138.3,150.96 139.25,151.91 139.25,155.53 136.1,158.68 132.88,158.68 130.9,160.66 v2(130.9,160.86)
  BOTTOM w0.127: U187.15 104.02,120.97 103.49,120.43 v2(101.73,120.43)
EDP_I2C4_SDA: length 73.9
  TOP w0.127: v2(130.9,160.01) 129.29,160.01 129.12,159.84 U20.4 129.12,158.22 R112.2
  L7-SIGNAL3 w0.109: v2(101.74,122.62) 113.68,122.62 120.25,129.19 120.25,130.89 137.98,148.62 137.98,151.08 138.97,152.07 138.97,155.4 136.08,158.3 132.88,158.3 131.16,160.01 v2(130.9,160.01)
  BOTTOM w0.127: v2(101.74,122.62) 101.74,122.21 101.73,122.2 101.73,121.66 102.41,120.99 103.15,120.99 103.52,121.36 U187.16
EDP_IRQ: length 141.5
  L3-SIGNAL1 w0.089: v2(70.57,84.69) 70.44,84.56 42.76,84.56 42.16,85.15 34.92,85.15 31.66,88.42 28.39,88.42 v2(26.88,86.9)
  L7-SIGNAL3 w0.109: v2(70.57,84.69) 71.92,86.04 71.92,91.67 70.85,92.74 70.85,95.33 72.07,96.55 72.07,101.04 72.58,101.55 72.58,102.93 71.94,103.56 71.94,113.6 71.55,113.99 71.55,118.53 73.68,120.66 80.56,120.66 81.89,121.99 81.89,124.37 83.25,125.73 95.74,125.73 101.83,119.64 109.18,119.64 109.51,119.96 111.29,119.96 112.35,118.9 112.68,118.9 113.32,119.53 113.32,120.65 v2(114.53,121.86)
  BOTTOM w0.127: U187.61 113.83,125.81 113.99,125.97 114.51,125.97 114.82,125.66 114.82,122.15 v2(114.53,121.86) ; v2(26.88,86.9) U220.2
EDP_REFCLK: length 7
  BOTTOM w0.127: R858.2 116.82,132.68 116.56,132.42 TP258.1 115.13,133.4 R857.1 114.8,132.77 114.62,132.6 114.62,131.35 114.09,130.81 U187.51
EDP_TEST1: length 5
  BOTTOM w0.127: R897.2 115.81,124.06 115.81,124.06 115.56,124.06 115.15,124.48 115.15,125.81 114.65,126.31 U187.60
EDP_TEST2: length 5.9
  BOTTOM w0.127: U187.55 115.38,128.81 115.76,129.19 116.92,129.19 117.09,129.03 R881.2 R880.1
EDP_TEST3: length 5.6
  BOTTOM w0.127: U187.50 113.94,131.31 114.3,131.68 114.3,132.85 113.91,133.24 113.91,134.79 C668.2
EMMC_RSTZ: length 16.3
  TOP w0.127: v2(176.19,96.81) 176.44,97.06 U52.K5 ; TP289.1 182.18,101.96 v2(181.69,101.96)
  L3-SIGNAL1 w0.089: v2(176.19,96.81) 176.19,96.81 175.35,97.65 175.35,100.07 176.79,101.51 181.24,101.51 v2(181.69,101.96)
  BOTTOM w0.127: v2(181.69,101.96) 182.06,101.6 U213.4 ; R966.2 176.08,96.7 v2(176.19,96.81)
EN1_LM5140: length 1.9
  TOP w0.127: R255.1 212.28,107.04 U46.31
EN1_LM5143: length 2.3
  TOP w0.127: U25.31 207.47,148.1 207.6,147.96 207.6,147.4 207.83,147.18 R148.1
EN2_LM5140: length 7.9
  TOP w0.127: R1308.1 206.98,101.51 208.21,102.74 211.39,102.74 211.51,102.62 R271.1 212.1,102.19 212.44,102.54 U46.40
EN2_LM5143: length 1.6
  TOP w0.127: R125.1 207.74,153.08 207.26,152.6 U25.40
EN_3V3_VIO: length 376.2
  TOP w0.127: v2(206.94,96.9) 206.31,97.54 R1308.2 ; U281.3 63.35,91.39 65.46,89.28 72.91,89.28 v2(72.99,89.36) 72.8,89.55 U53.3 ; v2(82.1,77.8) R401.2 81.39,78.27 81.23,78.42 U62.3 ; U68.19 v3(174.83,70.82)
  L3-SIGNAL1 w0.089: v2(186.62,66.8) 184.72,66.8 181.16,70.36 175.83,70.36 175.36,70.82 v3(174.83,70.82) 173.59,70.82 172.35,69.58 172.35,65.72 172.68,65.39 172.68,60.17 180.57,52.29 180.57,48.38 v3(178.82,46.63) 178.62,46.43 162.33,46.43 150.01,34.11 114.69,34.11 109.46,39.35 99.02,39.35 93.52,44.84 84.47,44.84 v2(83.37,43.74)
  L7-SIGNAL3 w0.109: v2(72.99,89.36) 72.99,89.06 75.73,86.33 75.73,83.32 77.81,81.23 77.81,79.71 78.95,78.58 81.33,78.58 v2(82.1,77.8) 83.67,79.38 85.94,79.38 86.32,79.76 86.32,82.96 86.83,83.47 86.83,94.37 86.27,94.93 79.64,94.93 77.43,97.14 77.43,118.9 78.26,119.74 81.03,119.74 82.64,121.34 82.64,123.78 83.74,124.88 95.43,124.88 103.16,117.15 112.79,117.15 v7(112.96,117.32)
  L13-GND5 w0.102: v9(113.37,117.17) 113.22,117.32 v7(112.96,117.32)
  L14-SIGNAL6 w0.089: v2(82.1,77.8) 82.25,77.66 82.25,73.3 75.04,66.09 75.04,44.75 77.94,41.85 82.61,41.85 83.11,42.35 83.11,43.48 v2(83.37,43.74) ; v11(114.13,115.04) 114.13,116.41 v9(113.37,117.17) ; v2(186.62,66.8) 187.38,67.56 190.81,67.56 191.19,67.94 197.67,67.94 205.55,75.82 205.55,95.5 v2(206.94,96.9)
  BOTTOM w0.127: U201.4 R932.1
EN_DDR_RET_1V1: length 107.3
  TOP w0.127: U68.24 177.33,69.34 v2(177.55,69.12) ; R404.2 165.45,77.82 165.87,77.82 166.05,78 v2(166.05,79.38) 166.05,80.69 165.87,80.87 165.45,80.87 R378.2 ; Q4.2 155.23,42.16 155.53,41.86 158.5,41.86 159.63,42.98 R557.1 160.21,43.39 160.33,43.51 160.33,43.84 v2(160.47,43.98)
  L3-SIGNAL1 w0.089: v2(160.47,43.98) 162.68,46.18 179.44,46.18 180.79,47.53 180.79,52.4 176.12,57.06 176.12,60.83 ; v2(177.55,69.12) 176.99,68.56 176.63,68.56 176.12,68.06 176.12,60.83 ; 176.12,60.83 181.42,60.83 187.26,66.67 187.26,67.44 186.88,67.82 186.5,67.82 180.27,74.04 180.27,76.58 180.74,77.05 181.33,77.05 181.61,77.32 181.61,77.88 181.42,78.06 177.9,78.06 176.66,76.82 174.02,76.82 173.85,76.99 173.85,77.44 171.91,79.38 v2(166.05,79.38)
EN_DDR_VDD1: length 5.4
  TOP w0.127: U85.4 160.06,49.17 159.95,49.06 ; 159.95,49.06 159.1,49.06 158.91,48.87 158.91,47.22 158.62,46.93 Q3.3 ; 159.95,49.06 R534.1 159.95,49.06
EN_DRV_OUT: length 8.4
  TOP w0.127: v3(185.61,67.5) R433.2
  L3-SIGNAL1 w0.089: v3(185.61,67.5) 185.61,67.96 182.74,70.82 180.09,70.82 v3(180.08,70.81)
EN_EFUSE_VPP: length 24.6
  TOP w0.127: R414.1 R416.2 69.32,73.13 69.89,73.7 69.89,75.81 71.19,77.12 83.77,77.12 84.82,76.08 R407.1 85.81,76.08 86.02,75.87 U67.4
EN_GPIO_RET_3V3: length 156.2
  TOP w0.127: v2(176.83,70.83) U68.23 ; U70.2 72.8,67.79 72.08,67.06 71.36,67.06 v2(70.24,65.95) 70.24,65.71 70.93,65.02 73.21,65.02 74.17,65.98 75.16,65.98 U279.6
  L7-SIGNAL3 w0.109: v2(70.24,65.95) 69.08,65.95 66.07,62.94 66.07,59.92 71.97,54.03 78.47,54.03 85.61,46.89 98.79,46.89 106.81,54.92 112.2,54.92 116.59,59.3 128.86,59.3 129.62,59.3 140.98,59.3 145.61,59.3 146.11,58.8 151.19,58.8 151.57,59.18 155.41,59.18 161.22,65 161.22,72.68 164.72,76.18 164.91,76.18 165.46,76.73 167.73,76.73 168.77,75.69 169.15,75.69 169.68,75.16 169.68,73.46 171.88,71.25 176.4,71.25 v2(176.83,70.83)
EN_GPIORET_VIO: length 10.2
  TOP w0.127: U279.4 76.07,67.88 76.39,67.56 76.39,66.04 77.02,65.41 77.02,64.64 77.15,64.52 78.04,64.52 79.18,65.66 80.07,65.66 80.2,65.79 R437.2 U75.3
EN_GPIORET_WKLG: length 17.6
  TOP w0.127: U66.4 75.93,75.87 R409.2 75.92,76.39 75.66,76.65 71.32,76.65 70.54,75.87 70.54,70.57 71.39,69.72 73.22,69.72 73.45,69.49 73.45,68.78 U70.3
EN_LM5141_ON: length 4.6
  TOP w0.127: U81.23 204.41,56.94 203.92,56.45 203.92,56.14 203.13,55.35 R481.1 202.61,54.98 R1305.1
EN_SD_3V3: length 9.5
  TOP w0.127: U281.4 66.05,92.14 66.05,91.36 66.81,90.6 68.31,90.6 68.64,90.93 68.64,92.02 69.05,92.43 71.78,92.43 72.47,91.74 U53.1
EN_TPS61240: length 1.9
  TOP w0.127: R662.2 172.38,21.48 172.18,21.69 U139.4
EVM_PDN_TEST: length 5.8
  TOP w0.127: R663.2 226.44,19.69 SW16.3 228.65,19.69 v2(230.2,18.14)
  BOTTOM w0.127: v2(230.2,18.14) U268.1
EVM_PMIC_EN: length 4.7
  TOP w0.127: v2(226.63,23.63) 226.44,23.44 R652.2 SW16.1
  BOTTOM w0.127: U268.11 226.95,23.31 v2(226.63,23.63)
EVM_SVS_EN: length 6.2
  TOP w0.127: v2(230.17,20.96) 230.17,20.96 SW16.2 226.44,20.96 R660.2
  BOTTOM w0.127: U268.14 228.9,21.33 229.26,20.96 v2(230.17,20.96)
EXP_3V3: length 6.8
  BOTTOM w0.254: C597.1 J14.A10 ; C654.1 J17.A10 ; C630.1 J14.B8 ; C691.1 J17.B8
  vias: v2(29.02,149.5) v2(29.02,129.43) v2(41.84,36.89) v2(41.84,35.97) v2(42.76,36.89) v2(42.76,35.97) v2(43.67,36.89) v2(43.67,35.97) v2(203.22,41.35) v2(203.22,40.43) v2(204.13,41.35) v2(206.2,95.03) v2(206.2,94.11) v2(207.12,95.03) v2(207.12,94.11) v12(206.59,133.38) v12(206.59,131.6) v12(206.59,129.83) v12(208.62,133.38) v12(208.62,131.6) v12(208.62,129.83) v12(210.65,133.38) v12(210.65,131.6) v12(210.65,129.83) v12(212.68,133.38) v12(212.68,131.6) v12(212.68,129.83) v12(214.71,133.38) v12(214.71,131.6) v12(214.71,129.83)
EXP_3V3_N: length 9.5
  L3-SIGNAL1 w0.089: v3(208.15,127.57) 208.15,127.09 208.02,126.96 204.35,126.96 202.21,129.1 201.41,129.1 201.25,129.26 TP32.1
EXP_3V3_P: length 9.5
  L3-SIGNAL1 w0.089: TP36.1 201.3,127.61 201.3,128.73 201.46,128.89 202.12,128.89 204.26,126.74 208.06,126.74 208.15,126.66 v3(208.15,126.07)
EXP_EEPROM_A0: length 2.8
  BOTTOM w0.127: R1177.2 32.36,40.63 J56.19
EXP_EEPROM_A1: length 2.5
  BOTTOM w0.127: R1171.2 J56.21
EXP_EEPROM_A2: length 2.8
  BOTTOM w0.127: J56.23 32.37,41.63 31.73,42.27 R1168.2
EXP_MUX2: length 73.1
  TOP w0.127: U43.15 v2(45.38,110.57)
  L12-SIGNAL5 w0.102: v2(45.38,110.57) 40.86,106.06 40.86,79.83 38.31,77.27 38.31,52.81 39.34,51.77 39.34,46.34 v2(41.55,44.13)
  BOTTOM w0.127: J56.34 v2(41.55,44.13)
EXP_MUX3: length 75.3
  TOP w0.127: v2(46.38,109.66) 45.88,110.16 45.88,111.41 U43.16
  L12-SIGNAL5 w0.102: v2(42.57,44.13) 42.36,44.13 40.8,45.69 40.8,51.46 38.54,53.73 38.54,77.08 41.09,79.64 41.09,96.85 41.1,96.85 44.23,99.99 44.23,107.51 v2(46.38,109.66)
  BOTTOM w0.127: J56.36 42.07,44.63 v2(42.57,44.13)
EXP_REFCLK: length 167.1
  L3-SIGNAL1 w0.089: v3(98.62,150.02) v5(98.97,150.02)
  L4-GND2 w0.102: v5(98.97,150.02) v7(99.37,150.02)
  L5-SIGNAL2 w0.102: v7(99.37,150.02) 95.11,145.75 v2(50.3,145.75)
  L7-SIGNAL3 w0.109: v2(50.3,145.75) 46.01,141.46 46.01,138.05 45.02,137.06 45.02,133.76 46.01,132.77 46.01,130.56 46.59,129.97 46.59,121.11 47.37,120.34 47.37,111.98 47.79,111.57 47.79,99.68 48.62,98.84 48.62,95.38 44.18,90.93 44.18,79.93 42.57,78.32 42.57,72.14 40.9,70.48 40.9,42.3 v2(42.57,40.63)
  BOTTOM w0.127: v2(42.57,40.63) 42.07,41.13 J56.22
