# Allegro board PROC184E1_BRD.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CAP0201_0-5
  rect 0.457x0.432 smd: 1(-0.34,0) 2(0.34,0)
CAP0402_0-75
  rect 0.483x0.584 smd: 1(-0.46,0) 2(0.46,0)
CAP0603_1
  rect 0.711x0.889 smd: 1(-0.7,0) 2(0.7,0)
CAP0603_1-25
  rect 0.711x0.889 smd: 1(-0.7,0) 2(0.7,0)
CAP0805_0-75
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
CAP0805_1
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
CAP0805_1-5
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
CAP0805_1-5#2
  rect 0.94x1.346 smd: 1(-0.8,0) 2(0.8,0)
CAP0805_1-25
  rect 0.94x1.346 smd: 1(-0.8,0) 2(0.8,0)
CAP1206_1-25
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1206_1-75
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1206_2
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
CAP1210_2-75
  rect 1.448x2.794 smd: 1(-1.6,0) 2(1.6,0)
CAP1210_3
  rect 1.448x2.794 smd: 1(-1.6,0) 2(1.6,0)
CAP2220_2-75
  rect 0.813x5.41 smd: 1(-2.95,0) 2(2.95,0)
CAPAE_B6CASE_6
  rect 2.896x1.651 smd: 1(-2.15,0) 2(2.15,0)
CAPAE_C6CASE_6
  rect 3.2x1.651 smd: 1(-2.65,0) 2(2.65,0)
CAPAE_CASE8383_10-5
  rect 3.861x2.159 smd: 1(-3.45,0) 2(3.45,0)
CAPAE_CASE173173_22-5
  rect 6.858x2.388 smd: 1(-6.55,0) 2(6.55,0)
CAPT3528T_1-25
  rect 2.057x2.54 smd: 1(-1.35,0)
  rect 2.261x2.159 smd: 2(1.25,0)
CAPT7343D_3-25
  rect 2.362x2.438 smd: 1(-3.1,0) 2(3.1,0)
CON_AV6_STX-4235-3-3_S_R_T_26
  oval 1.854x3.886 hole 1.981x4.013 unplated: (-7,0) (-3,0)
  rect 2.21x2.21 hole 1.524: 1A(0,0)
  round 2.21 hole 1.524: 1B(-10,0) 2A(1.25,7.5) 2B(-10,5) 5A(-11.25,7.5) 5B(0,5)
CON_FLEX40X1_FH12A_S_R_S
  rect 0.33x1.397 smd: 1(-9.75,3.575) 2(-9.25,3.575) 3(-8.75,3.575) 4(-8.25,3.575) 5(-7.75,3.575) 6(-7.25,3.575) 7(-6.75,3.575) 8(-6.25,3.575) 9(-5.75,3.575) 10(-5.25,3.575) 11(-4.75,3.575) 12(-4.25,3.575) 13(-3.75,3.575) 14(-3.25,3.575) 15(-2.75,3.575) 16(-2.25,3.575) 17(-1.75,3.575) 18(-1.25,3.575) 19(-0.75,3.575) 20(-0.25,3.575) 21(0.25,3.575) 22(0.75,3.575) 23(1.25,3.575) 24(1.75,3.575) 25(2.25,3.575) 26(2.75,3.575) 27(3.25,3.575) 28(3.75,3.575) 29(4.25,3.575) 30(4.75,3.575) 31(5.25,3.575) 32(5.75,3.575) 33(6.25,3.575) 34(6.75,3.575) 35(7.25,3.575) 36(7.75,3.575) 37(8.25,3.575) 38(8.75,3.575) 39(9.25,3.575) 40(9.75,3.575)
  rect 1.803x2.311 smd: 41(-11.65,0.325) 42(11.65,0.325)
CON_MUSBB5_1051640001_S_R_S_2-5
  rect 0.457x1.372 smd: 1(1.3,2.143) 2(0.65,2.143) 3(0,2.143) 4(-0.65,2.143) 5(-1.3,2.143)
  oval 1.397x2.108 hole 0.61x1.321: SH1(-3.95,-0.517) SH2(3.95,-0.517)
  rect 1.473x2.108 smd: SH3(-2.463,1.783) SH4(2.463,1.783)
  rect 1.372x1.905 smd: SH5(-0.937,-0.517) SH6(0.937,-0.517)
CON_PCIE2X32_10142333-10111_S_S_T_11
  round 2.21 hole 2.337 unplated: (11.65,-1.25) (34.8,-1.25)
  rect 1.397x1.397 hole 0.711: A1(0,0)
  round 1.397 hole 0.711: A2(1,2) A3(2,0) A4(3,2) A5(4,0) A6(5,2) A7(6,0) A8(7,2) A9(8,0) A10(9,2) A11(10,0) A12(13,2) A13(14,0) A14(15,2) A15(16,0) A16(17,2) A17(18,0) A18(19,2) A19(20,0) A20(21,2) A21(22,0) A22(23,2) A23(24,0) A24(25,2) A25(26,0) A26(27,2) A27(28,0) A28(29,2) A29(30,0) A30(31,2) A31(32,0) A32(33,2) B1(0,-2.5) B2(1,-4.5) B3(2,-2.5) B4(3,-4.5) B5(4,-2.5) B6(5,-4.5) B7(6,-2.5) B8(7,-4.5) B9(8,-2.5) B10(9,-4.5) B11(10,-2.5) B12(13,-4.5) B13(14,-2.5) B14(15,-4.5) B15(16,-2.5) B16(17,-4.5) B17(18,-2.5) B18(19,-4.5) B19(20,-2.5) B20(21,-4.5) B21(22,-2.5) B22(23,-4.5) B23(24,-2.5) B24(25,-4.5) B25(26,-2.5) B26(27,-4.5) B27(28,-2.5) B28(29,-4.5) B29(30,-2.5) B30(31,-4.5) B31(32,-2.5) B32(33,-4.5)
CON_PMC2X20_QSH-020-01-D-DP-A_S_S_S_3-4
  round 0.889 hole 1.016 unplated: (-10.067,2.67) (10.067,2.67)
  rect 0.279x2.261 smd: 1(-7.257,-2.87) 2(-7.257,2.87) 3(-6.757,-2.87) 4(-6.757,2.87) 5(-5.757,-2.87) 6(-5.757,2.87) 7(-5.257,-2.87) 8(-5.257,2.87) 9(-4.257,-2.87) 10(-4.257,2.87) 11(-3.757,-2.87) 12(-3.757,2.87) 13(-2.757,-2.87) 14(-2.757,2.87) 15(-2.257,-2.87) 16(-2.257,2.87) 17(-1.257,-2.87) 18(-1.257,2.87) 19(-0.756,-2.87) 20(-0.756,2.87) 21(0.244,-2.87) 22(0.244,2.87) 23(0.744,-2.87) 24(0.744,2.87) 25(1.744,-2.87) 26(1.744,2.87) 27(2.244,-2.87) 28(2.244,2.87) 29(3.244,-2.87) 30(3.244,2.87) 31(3.744,-2.87) 32(3.744,2.87) 33(4.744,-2.87) 34(4.744,2.87) 35(5.244,-2.87) 36(5.244,2.87) 37(6.243,-2.87) 38(6.243,2.87) 39(6.743,-2.87) 40(6.743,2.87)
  rect 2.54x0.432 smd: SH1(-8.065,0) SH4(8.065,0)
  rect 4.699x0.432 smd: SH2(-3.175,0) SH3(3.175,0)
CON_PMC2X30_QSH-030-01-D-A_S_S_S_3-3
  round 0.889 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  rect 0.279x2.261 smd: 1(-7.255,-2.87) 2(-7.255,2.87) 3(-6.755,-2.87) 4(-6.755,2.87) 5(-6.255,-2.87) 6(-6.255,2.87) 7(-5.755,-2.87) 8(-5.755,2.87) 9(-5.255,-2.87) 10(-5.255,2.87) 11(-4.755,-2.87) 12(-4.755,2.87) 13(-4.255,-2.87) 14(-4.255,2.87) 15(-3.755,-2.87) 16(-3.755,2.87) 17(-3.255,-2.87) 18(-3.255,2.87) 19(-2.755,-2.87) 20(-2.755,2.87) 21(-2.255,-2.87) 22(-2.255,2.87) 23(-1.755,-2.87) 24(-1.755,2.87) 25(-1.255,-2.87) 26(-1.255,2.87) 27(-0.755,-2.87) 28(-0.755,2.87) 29(-0.255,-2.87) 30(-0.255,2.87) 31(0.245,-2.87) 32(0.245,2.87) 33(0.745,-2.87) 34(0.745,2.87) 35(1.245,-2.87) 36(1.245,2.87) 37(1.745,-2.87) 38(1.745,2.87) 39(2.245,-2.87) 40(2.245,2.87) 41(2.745,-2.87) 42(2.745,2.87) 43(3.245,-2.87) 44(3.245,2.87) 45(3.745,-2.87) 46(3.745,2.87) 47(4.245,-2.87) 48(4.245,2.87) 49(4.745,-2.87) 50(4.745,2.87) 51(5.245,-2.87) 52(5.245,2.87) 53(5.745,-2.87) 54(5.745,2.87) 55(6.245,-2.87) 56(6.245,2.87) 57(6.745,-2.87) 58(6.745,2.87) 59(7.245,-2.87) 60(7.245,2.87)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
CON_PMC60X2_HQCD-060_S_S_S_3-3
  round 0.889 hole 1.016 unplated: (-20.06,2.67) (20.07,2.67)
  rect 0.279x2.286 smd: 1(-17.25,-2.87) 2(-17.25,2.87) 3(-16.75,-2.87) 4(-16.75,2.87) 5(-16.25,-2.87) 6(-16.25,2.87) 7(-15.75,-2.87) 8(-15.75,2.87) 9(-15.25,-2.87) 10(-15.25,2.87) 11(-14.75,-2.87) 12(-14.75,2.87) 13(-14.25,-2.87) 14(-14.25,2.87) 15(-13.75,-2.87) 16(-13.75,2.87) 17(-13.25,-2.87) 18(-13.25,2.87) 19(-12.75,-2.87) 20(-12.75,2.87) 21(-12.25,-2.87) 22(-12.25,2.87) 23(-11.75,-2.87) 24(-11.75,2.87) 25(-11.25,-2.87) 26(-11.25,2.87) 27(-10.75,-2.87) 28(-10.75,2.87) 29(-10.25,-2.87) 30(-10.25,2.87) 31(-9.75,-2.87) 32(-9.75,2.87) 33(-9.25,-2.87) 34(-9.25,2.87) 35(-8.75,-2.87) 36(-8.75,2.87) 37(-8.25,-2.87) 38(-8.25,2.87) 39(-7.75,-2.87) 40(-7.75,2.87) 41(-7.25,-2.87) 42(-7.25,2.87) 43(-6.75,-2.87) 44(-6.75,2.87) 45(-6.25,-2.87) 46(-6.25,2.87) 47(-5.75,-2.87) 48(-5.75,2.87) 49(-5.25,-2.87) 50(-5.25,2.87) 51(-4.75,-2.87) 52(-4.75,2.87) 53(-4.25,-2.87) 54(-4.25,2.87) 55(-3.75,-2.87) 56(-3.75,2.87) 57(-3.25,-2.87) 58(-3.25,2.87) 59(-2.75,-2.87) 60(-2.75,2.87) 61(2.75,-2.87) 62(2.75,2.87) 63(3.25,-2.87) 64(3.25,2.87) 65(3.75,-2.87) 66(3.75,2.87) 67(4.25,-2.87) 68(4.25,2.87) 69(4.75,-2.87) 70(4.75,2.87) 71(5.25,-2.87) 72(5.25,2.87) 73(5.75,-2.87) 74(5.75,2.87) 75(6.25,-2.87) 76(6.25,2.87) 77(6.75,-2.87) 78(6.75,2.87) 79(7.25,-2.87) 80(7.25,2.87) 81(7.75,-2.87) 82(7.75,2.87) 83(8.25,-2.87) 84(8.25,2.87) 85(8.75,-2.87) 86(8.75,2.87) 87(9.25,-2.87) 88(9.25,2.87) 89(9.75,-2.87) 90(9.75,2.87) 91(10.25,-2.87) 92(10.25,2.87) 93(10.75,-2.87) 94(10.75,2.87) 95(11.25,-2.87) 96(11.25,2.87) 97(11.75,-2.87) 98(11.75,2.87) 99(12.25,-2.87) 100(12.25,2.87) 101(12.75,-2.87) 102(12.75,2.87) 103(13.25,-2.87) 104(13.25,2.87) 105(13.75,-2.87) 106(13.75,2.87) 107(14.25,-2.87) 108(14.25,2.87) 109(14.75,-2.87) 110(14.75,2.87) 111(15.25,-2.87) 112(15.25,2.87) 113(15.75,-2.87) 114(15.75,2.87) 115(16.25,-2.87) 116(16.25,2.87) 117(16.75,-2.87) 118(16.75,2.87) 119(17.25,-2.87) 120(17.25,2.87)
  rect 2.54x0.432 smd: 121(-18.06,0) 124(-1.93,0) 125(1.94,0) 128(18.07,0)
  rect 4.724x0.432 smd: 122(-13.17,0) 123(-6.82,0) 126(6.83,0) 127(13.18,0)
CON_POWERJACK4_PD-40S_S_R_T_15
  oval 1.295x3.2 hole 0.61x2.489: 1(0,0) 2(-5.8,0) 3(-0.4,3.65) 4(-5.4,3.65)
  oval 2.896x1.295 hole 2.184x0.61: 5(-2.9,9.15)
  oval 1.295x2.896 hole 0.61x2.184: 6(-10.7,-1.35) 7(4.9,-1.35)
  round 2.896 hole 2.184: SH1(-10.7,7.15) SH4(4.9,7.15)
  round 2.362 hole 1.676: SH2(-5.4,7.15) SH3(-0.4,7.15)
CON_RJ45-14_LPJG16314A4NL_S_R_T_13-6
  round 3.073 hole 3.2 unplated: (0,-8.89) (11.43,-8.89)
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(1.27,-2.54) 3(2.54,0) 4(3.81,-2.54) 5(5.08,0) 6(6.35,-2.54) 7(7.62,0) 8(8.89,-2.54) 9(10.16,0) 10(11.43,-2.54)
  round 1.702 hole 1.016: 11(12.44,-11.43) 12(12.44,-13.462) 13(-1.01,-11.43) 14(-1.01,-13.462)
  round 2.362 hole 1.676: 15(-2.032,-5.842) 16(13.462,-5.842)
CON_SD10_DM3BT-DSF-PEJS_S_R_S_2-4
  rect 0.711x1.422 smd: 1(-2.715,7.801) 2(-1.615,7.801) 3(-0.515,7.801) 4(0.585,7.801) 5(1.685,7.801) 6(2.785,7.801) 7(3.885,7.801) 8(4.985,7.801)
  rect 0.711x1.219 smd: 9(5.935,7.901)
  rect 1.016x1.422 smd: 10(-4.615,7.801)
  rect 1.219x1.219 smd: 11(6.785,3.601)
  rect 1.219x0.813 smd: 12(6.785,-2.599)
  rect 1.219x3.2 smd: 13(6.785,-6.199)
  rect 2.007x1.905 smd: 14(-6.265,-7.199)
CON_TB1X2_1757242_P_R_T_8-6
  rect 2.108x2.108 hole 1.422: 1(0,0)
  round 2.108 hole 1.422: 2(-5.08,0)
CON_TB1X2_1803277_P_R_T_7-3
  rect 1.905x1.905 hole 1.219: 1(0,0)
  round 1.905 hole 1.219: 2(-3.81,0)
CON_USB20_472720001_S_R_T_7
  round 1.346 hole 1.473 unplated: (0,-2.939)
  rect 0.305x2.388 smd: 1(5.5,7.341) 2(5,7.341) 3(4.5,7.341) 4(4,7.341) 5(3.5,7.341) 6(3,7.341) 7(2.5,7.341) 8(2,7.341) 9(1.5,7.341) 10(1,7.341) 11(0.5,7.341) 12(0,7.341) 13(-0.5,7.341) 14(-1,7.341) 15(-1.5,7.341) 16(-2,7.341) 17(-2.5,7.341) 18(-3,7.341) 19(-3.5,7.341) 20(-4,7.341)
  oval 1.346x2.997 hole 0.66x2.286: SH1(-8.25,4.741) SH2(8.25,4.741)
  oval 1.346x2.489 hole 0.66x1.778: SH3(-8.25,-2.039) SH4(8.25,-2.039)
CON_USBA8_AU-Y1008-2_S_R_T_15-5
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(2.5,0) 3(4.5,0) 4(7,0) 5(0,-2.62) 6(2.5,-2.62) 7(4.5,-2.62) 8(7,-2.62)
  round 2.997 hole 2.286: SH1(-3.07,0.35) SH2(10.07,0.35) SH3(-3.07,-5.33) SH4(10.07,-5.33)
CON_USBC24_2012670_S_R_S_3-9
  rect 0.305x0.762 smd: A1(-3,4.056) A2(-2.5,4.056) A3(-2,4.056) A4(-1.5,4.056) A5(-1,4.056) A6(-0.5,4.056) A7(0.5,4.056) A8(1,4.056) A9(1.5,4.056) A10(2,4.056) A11(2.5,4.056) A12(3,4.056) B2(2.25,2.356) B3(1.75,2.356) B4(1.25,2.356) B5(0.75,2.356) B6(0.25,2.356) B7(-0.25,2.356) B8(-0.75,2.356) B9(-1.25,2.356) B10(-1.75,2.356) B11(-2.25,2.356)
  rect 0.94x0.762 smd: B1(3.05,2.356) B12(-3.05,2.356)
  oval 1.194x2.21 hole 0.61x1.575: SH1(-4.32,3.246) SH2(4.32,3.246)
  oval 1.194x3.708 hole 0.61x2.083: SH3(4.62,-2.114) SH4(-4.62,-2.114)
D2PAK-3
  rect 1.041x4.064 smd: 1(-2.54,-8.587) 3(2.54,-8.587)
  rect 10.49x8.534 smd: 4(0,2.063)
DIO_DFN0402_0-5
  rect 0.356x0.61 smd: 1(-0.34,0) 2(0.34,0)
DIO_SMC
  rect 2.21x3.099 smd: 1(-3.5,0) 2(3.5,0)
DIO_SMC_2-7
  rect 2.21x3.099 smd: 1(-3.5,0) 2(3.5,0)
DIO_SOD123_1-4
  rect 1.016x0.813 smd: 1(-1.8,0) 2(1.8,0)
DIO_SOD123_1-5
  rect 1.016x0.813 smd: 1(-1.8,0) 2(1.8,0)
DIO_SOD123F_0-9
  rect 1.194x1.219 smd: 1(-1.56,0) 2(1.56,0)
DIO_SOD323
  rect 0.914x0.508 smd: 1(-1.25,0) 2(1.25,0)
DIO_SOD323_1-1
  rect 0.914x0.508 smd: 1(-1.25,0) 2(1.25,0)
DSBGA12_15-74_60X70_0-4
  round 0.279 smd: A1(-0.4,0.6) A2(0,0.6) A3(0.4,0.6) B1(-0.4,0.2) B2(0,0.2) B3(0.4,0.2) C1(-0.4,-0.2) C2(0,-0.2) C3(0.4,-0.2) D1(-0.4,-0.6) D2(0,-0.6) D3(0.4,-0.6)
EMIFIL_BLM15A_0402_0-6
  rect 0.609x0.609 smd: 1(-0.46,0) 2(0.46,0)
EMIFIL_BLM18A_0603
  rect 0.991x0.991 smd: 1(-0.75,0) 2(0.75,0)
EMIFIL_BLM18P_0603_0-8
  rect 0.991x0.991 smd: 1(-0.75,0) 2(0.75,0)
EMIFIL_BLM31KN_1206_1-8
  rect 1.6x1.905 smd: 1(-1.45,0) 2(1.45,0)
EMIFIL_NFM15CC_0402_0-5_TI
  rect 0.305x0.305 smd: 1(-0.5,0) 3(0.5,0)
  rect 0.254x0.254 smd: 2(0,-0.25) 4(0,0.25)
EMIFIL_NFM18C_0603_0-7_TI
  rect 0.61x0.61 smd: 1(-0.8,0) 3(0.8,0)
  rect 0.406x0.406 smd: 2(0,-0.4) 4(0,0.4)
EMIFIL_NFM21P_0805
  rect 0.609x0.609 smd: 1(-1,0) 3(1,0)
  rect 0.61x1.905 smd: 2(0,0)
FUSEH_154004_380X200_SMD_3-9
  rect 4.242x3.81 smd: 1(-3.19,0) 2(3.19,0)
HDR_1X2_68002-202_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0)
HDR_1X3_78-74_S_T
  rect 1.6x1.6 hole 0.914: 1(0,0)
  round 1.6 hole 0.914: 2(2,0) 3(4,0)
HDR_1X3_440054-3_S_T_6-4
  rect 1.499x1.499 hole 0.813: 1(0,0)
  round 1.499 hole 0.813: 2(-2,0) 3(-4,0)
HDR_1X4_61300411121_S_T_8-6
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
HDR_1X5_68002-205_S_T_8-6
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-10.16,0)
HDR_2X10_TSW_100_S_T
  rect 1.702x1.702 hole 1.016: 1(0,0)
  round 1.702 hole 1.016: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54) 11(-12.7,0) 12(-12.7,-2.54) 13(-15.24,0) 14(-15.24,-2.54) 15(-17.78,0) 16(-17.78,-2.54) 17(-20.32,0) 18(-20.32,-2.54) 19(-22.86,0) 20(-22.86,-2.54)
HDR_3X1_100_S_T
  rect 1.803x1.803 hole 1.118: 1(0,0)
  round 1.803 hole 1.118: 2(-2.54,0) 3(-5.08,0)
HDR_6X1_100_S_T
  rect 1.88x1.88 hole 1.168: 1(0,0)
  round 1.88 hole 1.168: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0) 5(-10.16,0) 6(-12.7,0)
HTQFP64_19-68_400X400_1-2_EP7-3X7
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
  rect 7.29x7.01 smd: 65(0,0)
HTQFP64_SN65DSI86_400X400_1-2
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
  rect 8.001x8.001 smd: 65(0,0)
HTQFP64_TUSB4041I_400X400_1-2
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
  rect 8.001x8.001 smd: 65(0,0)
IND4_DLW21H_90X60_SMD_1-4
  rect 0.889x0.356 smd: 1(-0.85,-0.425) 2(0.85,-0.425) 3(0.85,0.425) 4(-0.85,0.425)
IND0603_1
  rect 0.914x1.016 smd: 1(-0.8,0) 2(0.8,0)
IND0805_M
  rect 1.219x1.422 smd: 1(-0.9,0) 2(0.9,0)
IND1008_1-2
  rect 1.194x2.21 smd: 1(-1.1,0) 2(1.1,0)
IND_ASPI-0603LR_270X270_SMD_3
  rect 2.362x3.429 smd: 1(-3.025,0) 2(3.025,0)
IND_HLP5050CE-1R0-01_530X510_SMD_3-5
  rect 3.175x3.302 smd: 1(-5.715,0) 2(5.715,0)
IND_NLCV25T-EFR_110X80_SMD_1-9
  rect 0.991x1.499 smd: 1(-1.25,0) 2(1.25,0)
IND_SRP1250_550X530_SMD_5-2
  rect 4.013x4.496 smd: 1(-5.5,0) 2(5.5,0)
IND_XAL6060_260X270_SMD_6-1
  rect 1.422x5.512 smd: 1(-2.02,0) 2(2.02,0)
IND_XEL4030_170X170_SMD_3-2
  rect 0.991x3.404 smd: 1(-1.185,0) 2(1.185,0)
LED_0603_0-7
  rect 0.889x0.965 smd: 1(-0.8,0) 2(0.8,0)
LED_0603_0-8
  rect 0.889x0.965 smd: 1(-0.8,0) 2(0.8,0)
LED_0805
  rect 0.914x1.397 smd: 1(-1,0) 2(1,0)
LED_0805_0-7
  rect 0.914x1.397 smd: 1(-1,0) 2(1,0)
LGA14_19-68_120X100_0-9
  rect 0.61x0.305 smd: 1(-1.15,0.75) 2(-1.15,0.25) 3(-1.15,-0.25) 4(-1.15,-0.75) 8(1.15,-0.75) 9(1.15,-0.25) 10(1.15,0.25) 11(1.15,0.75)
  rect 0.305x0.61 smd: 5(-0.5,-0.9) 6(0,-0.9) 7(0.5,-0.9) 12(0.5,0.9) 13(0,0.9) 14(-0.5,0.9)
LQFP64_19-68_390X390_1-6
  rect 1.499x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.499 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
LQFP64_19-68_400X400_1-6
  rect 1.524x0.305 smd: 1(-5.7,3.75) 2(-5.7,3.25) 3(-5.7,2.75) 4(-5.7,2.25) 5(-5.7,1.75) 6(-5.7,1.25) 7(-5.7,0.75) 8(-5.7,0.25) 9(-5.7,-0.25) 10(-5.7,-0.75) 11(-5.7,-1.25) 12(-5.7,-1.75) 13(-5.7,-2.25) 14(-5.7,-2.75) 15(-5.7,-3.25) 16(-5.7,-3.75) 33(5.7,-3.75) 34(5.7,-3.25) 35(5.7,-2.75) 36(5.7,-2.25) 37(5.7,-1.75) 38(5.7,-1.25) 39(5.7,-0.75) 40(5.7,-0.25) 41(5.7,0.25) 42(5.7,0.75) 43(5.7,1.25) 44(5.7,1.75) 45(5.7,2.25) 46(5.7,2.75) 47(5.7,3.25) 48(5.7,3.75)
  rect 0.305x1.524 smd: 17(-3.75,-5.7) 18(-3.25,-5.7) 19(-2.75,-5.7) 20(-2.25,-5.7) 21(-1.75,-5.7) 22(-1.25,-5.7) 23(-0.75,-5.7) 24(-0.25,-5.7) 25(0.25,-5.7) 26(0.75,-5.7) 27(1.25,-5.7) 28(1.75,-5.7) 29(2.25,-5.7) 30(2.75,-5.7) 31(3.25,-5.7) 32(3.75,-5.7) 49(3.75,5.7) 50(3.25,5.7) 51(2.75,5.7) 52(2.25,5.7) 53(1.75,5.7) 54(1.25,5.7) 55(0.75,5.7) 56(0.25,5.7) 57(-0.25,5.7) 58(-0.75,5.7) 59(-1.25,5.7) 60(-1.75,5.7) 61(-2.25,5.7) 62(-2.75,5.7) 63(-3.25,5.7) 64(-3.75,5.7)
MSOP10_19-68_120X120_1-1
  rect 1.448x0.305 smd: 1(-2.2,1) 2(-2.2,0.5) 3(-2.2,0) 4(-2.2,-0.5) 5(-2.2,-1) 6(2.2,-1) 7(2.2,-0.5) 8(2.2,0) 9(2.2,0.5) 10(2.2,1)
OSC4_831056216_80X70_SMD_0-8
  rect 0.762x0.66 smd: 1(-0.65,-0.5) 2(0.65,-0.5) 3(0.65,0.5) 4(-0.65,0.5)
QFN16_19-68_120X120_0-8_EP1-8
  rect 0.762x0.305 smd: 1(-1.5,0.75) 2(-1.5,0.25) 3(-1.5,-0.25) 4(-1.5,-0.75) 9(1.5,-0.75) 10(1.5,-0.25) 11(1.5,0.25) 12(1.5,0.75)
  rect 0.305x0.762 smd: 5(-0.75,-1.5) 6(-0.25,-1.5) 7(0.25,-1.5) 8(0.75,-1.5) 13(0.75,1.5) 14(0.25,1.5) 15(-0.25,1.5) 16(-0.75,1.5)
  rect 1.803x1.803 smd: 17(0,0)
QFN16_19-68_120X120_1_EP1-6
  rect 0.838x0.254 smd: 1(-1.45,0.75) 2(-1.45,0.25) 3(-1.45,-0.25) 4(-1.45,-0.75) 9(1.45,-0.75) 10(1.45,-0.25) 11(1.45,0.25) 12(1.45,0.75)
  rect 0.254x0.838 smd: 5(-0.75,-1.45) 6(-0.25,-1.45) 7(0.25,-1.45) 8(0.75,-1.45) 13(0.75,1.45) 14(0.25,1.45) 15(-0.25,1.45) 16(-0.75,1.45)
  rect 1.6x1.6 smd: 17(0,0)
QFN20_19-68_185X145_1
  rect 0.864x0.279 smd: 1(-2.225,-0.75) 10(2.225,-0.75) 11(2.225,0.75) 20(-2.225,0.75)
  rect 0.279x0.864 smd: 2(-1.75,-1.725) 3(-1.25,-1.725) 4(-0.75,-1.725) 5(-0.25,-1.725) 6(0.25,-1.725) 7(0.75,-1.725) 8(1.25,-1.725) 9(1.75,-1.725) 12(1.75,1.725) 13(1.25,1.725) 14(0.75,1.725) 15(0.25,1.725) 16(-0.25,1.725) 17(-0.75,1.725) 18(-1.25,1.725) 19(-1.75,1.725)
  rect 3.15x2.159 smd: 21(0,0)
QFN24_19-68_160X160_1
  rect 0.711x0.305 smd: 1(-2.05,1.25) 2(-2.05,0.75) 3(-2.05,0.25) 4(-2.05,-0.25) 5(-2.05,-0.75) 6(-2.05,-1.25) 13(2.05,-1.25) 14(2.05,-0.75) 15(2.05,-0.25) 16(2.05,0.25) 17(2.05,0.75) 18(2.05,1.25)
  rect 0.305x0.711 smd: 7(-1.25,-2.05) 8(-0.75,-2.05) 9(-0.25,-2.05) 10(0.25,-2.05) 11(0.75,-2.05) 12(1.25,-2.05) 19(1.25,2.05) 20(0.75,2.05) 21(0.25,2.05) 22(-0.25,2.05) 23(-0.75,2.05) 24(-1.25,2.05)
  rect 2.896x2.896 smd: 25(0,0)
QFN24_19-68_220X140_1
  rect 0.838x0.279 smd: 1(-2.725,-0.75) 12(2.725,-0.75) 13(2.725,0.75) 24(-2.725,0.75)
  rect 0.279x0.838 smd: 2(-2.25,-1.725) 3(-1.75,-1.725) 4(-1.25,-1.725) 5(-0.75,-1.725) 6(-0.25,-1.725) 7(0.25,-1.725) 8(0.75,-1.725) 9(1.25,-1.725) 10(1.75,-1.725) 11(2.25,-1.725) 14(2.25,1.725) 15(1.75,1.725) 16(1.25,1.725) 17(0.75,1.725) 18(0.25,1.725) 19(-0.25,1.725) 20(-0.75,1.725) 21(-1.25,1.725) 22(-1.75,1.725) 23(-2.25,1.725)
  custom 0.508x0.508 smd: 25(0,0)
QFN32_19-68_200X200
  rect 0.838x0.305 smd: 1(-2.5,1.75) 2(-2.5,1.25) 3(-2.5,0.75) 4(-2.5,0.25) 5(-2.5,-0.25) 6(-2.5,-0.75) 7(-2.5,-1.25) 8(-2.5,-1.75) 17(2.5,-1.75) 18(2.5,-1.25) 19(2.5,-0.75) 20(2.5,-0.25) 21(2.5,0.25) 22(2.5,0.75) 23(2.5,1.25) 24(2.5,1.75)
  rect 0.305x0.838 smd: 9(-1.75,-2.5) 10(-1.25,-2.5) 11(-0.75,-2.5) 12(-0.25,-2.5) 13(0.25,-2.5) 14(0.75,-2.5) 15(1.25,-2.5) 16(1.75,-2.5) 25(1.75,2.5) 26(1.25,2.5) 27(0.75,2.5) 28(0.25,2.5) 29(-0.25,2.5) 30(-0.75,2.5) 31(-1.25,2.5) 32(-1.75,2.5)
  rect 3.556x3.556 smd: 33(0,0)
QFN40_19-68_240X240_0-9_EP3-4
  rect 0.787x0.305 smd: 1(-3,2.25) 2(-3,1.75) 3(-3,1.25) 4(-3,0.75) 5(-3,0.25) 6(-3,-0.25) 7(-3,-0.75) 8(-3,-1.25) 9(-3,-1.75) 10(-3,-2.25) 21(3,-2.25) 22(3,-1.75) 23(3,-1.25) 24(3,-0.75) 25(3,-0.25) 26(3,0.25) 27(3,0.75) 28(3,1.25) 29(3,1.75) 30(3,2.25)
  rect 0.305x0.787 smd: 11(-2.25,-3) 12(-1.75,-3) 13(-1.25,-3) 14(-0.75,-3) 15(-0.25,-3) 16(0.25,-3) 17(0.75,-3) 18(1.25,-3) 19(1.75,-3) 20(2.25,-3) 31(2.25,3) 32(1.75,3) 33(1.25,3) 34(0.75,3) 35(0.25,3) 36(-0.25,3) 37(-0.75,3) 38(-1.25,3) 39(-1.75,3) 40(-2.25,3)
  rect 3.404x3.404 smd: 41(0,0)
QFN40_19-68_240X240_1_EP3-4
  rect 0.787x0.305 smd: 1(-3,2.25) 2(-3,1.75) 3(-3,1.25) 4(-3,0.75) 5(-3,0.25) 6(-3,-0.25) 7(-3,-0.75) 8(-3,-1.25) 9(-3,-1.75) 10(-3,-2.25) 21(3,-2.25) 22(3,-1.75) 23(3,-1.25) 24(3,-0.75) 25(3,-0.25) 26(3,0.25) 27(3,0.75) 28(3,1.25) 29(3,1.75) 30(3,2.25)
  rect 0.305x0.787 smd: 11(-2.25,-3) 12(-1.75,-3) 13(-1.25,-3) 14(-0.75,-3) 15(-0.25,-3) 16(0.25,-3) 17(0.75,-3) 18(1.25,-3) 19(1.75,-3) 20(2.25,-3) 31(2.25,3) 32(1.75,3) 33(1.25,3) 34(0.75,3) 35(0.25,3) 36(-0.25,3) 37(-0.75,3) 38(-1.25,3) 39(-1.75,3) 40(-2.25,3)
  rect 3.404x3.404 smd: 41(0,0)
RES0201_0-5
  rect 0.457x0.432 smd: 1(-0.33,0) 2(0.33,0)
RES0402_0-5
  rect 0.508x0.508 smd: 1(-0.42,0) 2(0.42,0)
RES0402_0-5#2
  rect 0.559x0.635 smd: 1(-0.49,0) 2(0.49,0)
RES0603_0-75
  rect 0.711x0.889 smd: 1(-0.7,0) 2(0.7,0)
RES0805_0-75
  rect 1.194x1.448 smd: 1(-0.95,0) 2(0.95,0)
RES1206_0-75
  rect 1.067x1.753 smd: 1(-1.45,0) 2(1.45,0)
RES1206_W_0-75
  rect 1.041x3.404 smd: 1(-0.75,0) 2(0.75,0)
RES1210_0-75
  rect 1.143x2.692 smd: 1(-1.5,0) 2(1.5,0)
RES_FC4L16_0306-4_0-7
  rect 0.483x0.406 smd: 1(-0.363,0.75) 4(0.363,0.75)
  rect 0.483x1.194 smd: 2(-0.363,-0.35) 3(0.363,-0.35)
RES_FCSL90_3518-6_0-5_TI
  rect 1.194x4.089 smd: 1(-2.1,2.477) 3(-2.1,-2.477) 4(2.1,-2.477) 6(2.1,2.477)
  rect 1.194x0.254 smd: 2(-2.1,0) 5(2.1,0)
RES_KRL2012_0805-4_0-7_TI
  rect 0.889x0.356 smd: 1(-0.59,0.976) 4(0.59,0.976)
  rect 0.889x1.651 smd: 2(-0.59,-0.328) 3(0.59,-0.328)
RES_KRL3216_1206-6_0-7_TI
  rect 1.041x1.27 smd: 1(-0.75,1.067) 3(-0.75,-1.067) 4(0.75,-1.067) 6(0.75,1.067)
  rect 1.041x0.254 smd: 2(-0.75,0) 5(0.75,0)
SC70-3_1-1
  rect 0.838x0.457 smd: 1(-1.05,0.65) 2(-1.05,-0.65) 3(1.05,0)
SC70-5
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SC70-5_1-1
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0.65)
SC70-6
  rect 0.94x0.406 smd: 1(-1.1,0.65) 2(-1.1,0) 3(-1.1,-0.65) 4(1.1,-0.65) 5(1.1,0) 6(1.1,0.65)
SOIC8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SOIC8_1-8
  rect 1.549x0.61 smd: 1(-2.7,1.905) 2(-2.7,0.635) 3(-2.7,-0.635) 4(-2.7,-1.905) 5(2.7,-1.905) 6(2.7,-0.635) 7(2.7,0.635) 8(2.7,1.905)
SOIC14_1-8
  rect 1.549x0.61 smd: 1(-2.7,3.81) 2(-2.7,2.54) 3(-2.7,1.27) 4(-2.7,0) 5(-2.7,-1.27) 6(-2.7,-2.54) 7(-2.7,-3.81) 8(2.7,-3.81) 9(2.7,-2.54) 10(2.7,-1.27) 11(2.7,0) 12(2.7,1.27) 13(2.7,2.54) 14(2.7,3.81)
SON6_19-68_40X60_PB_0-6
  rect 0.356x0.305 smd: 1(-0.3,0.5) 2(-0.3,0) 3(-0.3,-0.5) 4(0.3,-0.5) 5(0.3,0) 6(0.3,0.5)
SON6_25-59_85X85
  rect 0.61x0.356 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_25-59_85X85_0-8
  rect 0.508x0.356 smd: 1(-1,0.65) 2(-1,0) 3(-1,-0.65) 4(1,-0.65) 5(1,0) 6(1,0.65)
  rect 1.092x1.702 smd: 7(0,0)
SON6_25-59_85X85_0-8#2
  rect 0.61x0.356 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
  rect 1.067x1.702 smd: 7(0,0)
SON8_25-59_130X130_1
  rect 0.838x0.356 smd: 1(-1.5,0.975) 2(-1.5,0.325) 3(-1.5,-0.325) 4(-1.5,-0.975) 5(1.5,-0.975) 6(1.5,-0.325) 7(1.5,0.325) 8(1.5,0.975)
  rect 1.753x2.515 smd: 9(0,0)
SOT23-5
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-5_1-1
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-5_1-5
  rect 1.092x0.61 smd: 1(-1.3,0.95) 2(-1.3,0) 3(-1.3,-0.95) 4(1.3,-0.95) 5(1.3,0.95)
SOT23-6
  rect 1.092x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-6_1-1
  rect 1.092x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-6_1-5
  rect 1.092x0.61 smd: 1(-1.35,0.95) 2(-1.35,0) 3(-1.35,-0.95) 4(1.35,-0.95) 5(1.35,0) 6(1.35,0.95)
SOT23-8_1-1
  rect 1.092x0.457 smd: 1(-1.3,0.975) 2(-1.3,0.325) 3(-1.3,-0.325) 4(-1.3,-0.975) 5(1.3,-0.975) 6(1.3,-0.325) 7(1.3,0.325) 8(1.3,0.975)
SOT23-123
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT23-123_1-1
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT23-123_1-2
  rect 1.016x0.61 smd: 1(-1.15,0.95) 2(-1.15,-0.95) 3(1.15,0)
SOT363-6_1-1
  rect 0.914x0.457 smd: 1(-1.05,0.65) 2(-1.05,0) 3(-1.05,-0.65) 4(1.05,-0.65) 5(1.05,0) 6(1.05,0.65)
SOT416F-6_0-9
  rect 0.813x0.305 smd: 1(-0.66,0.5) 2(-0.66,-0.5) 3(0.66,0)
SOT553-5
  rect 0.66x0.254 smd: 1(-0.74,0.5) 2(-0.74,0) 3(-0.74,-0.5) 4(0.74,-0.5) 5(0.74,0.5)
SOT553-5_0-6
  rect 0.66x0.254 smd: 1(-0.74,0.5) 2(-0.74,0) 3(-0.74,-0.5) 4(0.74,-0.5) 5(0.74,0.5)
SOT563-6_0-6
  rect 0.66x0.305 smd: 1(-0.74,0.5) 2(-0.74,0) 3(-0.74,-0.5) 4(0.74,-0.5) 5(0.74,0) 6(0.74,0.5)
SSOP8_25-59_120X110_1-3
  rect 1.092x0.406 smd: 1(-1.9,0.975) 2(-1.9,0.325) 3(-1.9,-0.325) 4(-1.9,-0.975) 5(1.9,-0.975) 6(1.9,-0.325) 7(1.9,0.325) 8(1.9,0.975)
SSOP20_25-59_295X220_2
  rect 1.854x0.457 smd: 1(-3.5,2.925) 2(-3.5,2.275) 3(-3.5,1.625) 4(-3.5,0.975) 5(-3.5,0.325) 6(-3.5,-0.325) 7(-3.5,-0.975) 8(-3.5,-1.625) 9(-3.5,-2.275) 10(-3.5,-2.925) 11(3.5,-2.925) 12(3.5,-2.275) 13(3.5,-1.625) 14(3.5,-0.975) 15(3.5,-0.325) 16(3.5,0.325) 17(3.5,0.975) 18(3.5,1.625) 19(3.5,2.275) 20(3.5,2.925)
SW3_185_500X260_TH_13
  rect 2.413x2.413 hole 1.727: 1(0,0)
  round 2.413 hole 1.727: 2(4.7,0) 3(9.4,0)
SW4_49-99_150X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-0.635,-3.81) 2(0.635,-3.81) 3(0.635,3.81) 4(-0.635,3.81)
SW4_100X216_200X200_SMD_4-2
  rect 1.27x1.27 smd: 1(-1.27,-2.75) 2(1.27,-2.75) 3(1.27,2.75) 4(-1.27,2.75)
SW8_218-4LPS_230X250_SMD_2-7
  rect 1.27x0.762 smd: 1(-3.81,1.905) 2(-3.81,0.635) 3(-3.81,-0.635) 4(-3.81,-1.905) 5(3.81,-1.905) 6(3.81,-0.635) 7(3.81,0.635) 8(3.81,1.905)
SW8_218-8LPST_450X230_SMD_2-7
  rect 0.762x1.27 smd: 1(-4.445,-3.81) 2(-3.175,-3.81) 3(-1.905,-3.81) 4(-0.635,-3.81) 5(0.635,-3.81) 6(1.905,-3.81) 7(3.175,-3.81) 8(4.445,-3.81) 9(4.445,3.81) 10(3.175,3.81) 11(1.905,3.81) 12(0.635,3.81) 13(-0.635,3.81) 14(-1.905,3.81) 15(-3.175,3.81) 16(-4.445,3.81)
SW10_50_550X230_SMD
  rect 0.762x1.27 smd: 1(-5.715,-3.81) 2(-4.445,-3.81) 3(-3.175,-3.81) 4(-1.905,-3.81) 5(-0.635,-3.81) 6(0.635,-3.81) 7(1.905,-3.81) 8(3.175,-3.81) 9(4.445,-3.81) 10(5.715,-3.81) 11(5.715,3.81) 12(4.445,3.81) 13(3.175,3.81) 14(1.905,3.81) 15(0.635,3.81) 16(-0.635,3.81) 17(-1.905,3.81) 18(-3.175,3.81) 19(-4.445,3.81) 20(-5.715,3.81)
TO_SOT323-123
  rect 0.406x1.168 smd: 1(-0.65,-1.05) 2(0.65,-1.05) 3(0,1.05)
TP18_SMD
  round 0.457 smd: 1(0,0)
TP20_SMD
  round 0.508 smd: 1(0,0)
TP30_SMD
  round 0.762 smd: 1(0,0)
TP40_SMD
  round 1.016 smd: 1(0,0)
TP_40X65
  round 1.651 hole 1.016: 1(0,0)
TP_CIR67D40_TH_4-6
  round 1.702 hole 1.016: 1(0,0)
TPBGA24_39-37_240X320_1-2
  round 0.356 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TQFN42_19-68_140X360_0-8
  rect 0.838x0.305 smd: 1(-1.7,4) 2(-1.7,3.5) 3(-1.7,3) 4(-1.7,2.5) 5(-1.7,2) 6(-1.7,1.5) 7(-1.7,1) 8(-1.7,0.5) 9(-1.7,0) 10(-1.7,-0.5) 11(-1.7,-1) 12(-1.7,-1.5) 13(-1.7,-2) 14(-1.7,-2.5) 15(-1.7,-3) 16(-1.7,-3.5) 17(-1.7,-4) 22(1.7,-4) 23(1.7,-3.5) 24(1.7,-3) 25(1.7,-2.5) 26(1.7,-2) 27(1.7,-1.5) 28(1.7,-1) 29(1.7,-0.5) 30(1.7,0) 31(1.7,0.5) 32(1.7,1) 33(1.7,1.5) 34(1.7,2) 35(1.7,2.5) 36(1.7,3) 37(1.7,3.5) 38(1.7,4)
  rect 0.305x0.838 smd: 18(-0.75,-4.45) 19(-0.25,-4.45) 20(0.25,-4.45) 21(0.75,-4.45) 39(0.75,4.45) 40(0.25,4.45) 41(-0.25,4.45) 42(-0.75,4.45)
  rect 2.159x7.645 smd: 43(0,0)
TQFP128_15-74_550X550_1-2
  rect 1.499x0.203 smd: 1(-7.7,6.2) 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 32(-7.7,-6.2) 65(7.7,-6.2) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8) 96(7.7,6.2)
  rect 0.203x1.499 smd: 33(-6.2,-7.7) 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 64(6.2,-7.7) 97(6.2,7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7) 128(-6.2,7.7)
TSSOP8_25-59_125X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,0.975) 2(-2.9,0.325) 3(-2.9,-0.325) 4(-2.9,-0.975) 5(2.9,-0.975) 6(2.9,-0.325) 7(2.9,0.325) 8(2.9,0.975)
TSSOP14_25-59_205X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,1.95) 2(-2.9,1.3) 3(-2.9,0.65) 4(-2.9,0) 5(-2.9,-0.65) 6(-2.9,-1.3) 7(-2.9,-1.95) 8(2.9,-1.95) 9(2.9,-1.3) 10(2.9,-0.65) 11(2.9,0) 12(2.9,0.65) 13(2.9,1.3) 14(2.9,1.95)
TSSOP16_25-59_205X180
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
TSSOP16_25-59_205X180_1-2
  rect 1.6x0.356 smd: 1(-2.8,2.275) 2(-2.8,1.625) 3(-2.8,0.975) 4(-2.8,0.325) 5(-2.8,-0.325) 6(-2.8,-0.975) 7(-2.8,-1.625) 8(-2.8,-2.275) 9(2.8,-2.275) 10(2.8,-1.625) 11(2.8,-0.975) 12(2.8,-0.325) 13(2.8,0.325) 14(2.8,0.975) 15(2.8,1.625) 16(2.8,2.275)
TSSOP20_25-59_260X180_1-2
  rect 1.499x0.457 smd: 1(-2.9,2.925) 2(-2.9,2.275) 3(-2.9,1.625) 4(-2.9,0.975) 5(-2.9,0.325) 6(-2.9,-0.325) 7(-2.9,-0.975) 8(-2.9,-1.625) 9(-2.9,-2.275) 10(-2.9,-2.925) 11(2.9,-2.925) 12(2.9,-2.275) 13(2.9,-1.625) 14(2.9,-0.975) 15(2.9,-0.325) 16(2.9,0.325) 17(2.9,0.975) 18(2.9,1.625) 19(2.9,2.275) 20(2.9,2.925)
TSSOP24_25-59_315X180_1-2
  rect 1.448x0.457 smd: 1(-2.9,3.575) 2(-2.9,2.925) 3(-2.9,2.275) 4(-2.9,1.625) 5(-2.9,0.975) 6(-2.9,0.325) 7(-2.9,-0.325) 8(-2.9,-0.975) 9(-2.9,-1.625) 10(-2.9,-2.275) 11(-2.9,-2.925) 12(-2.9,-3.575) 13(2.9,-3.575) 14(2.9,-2.925) 15(2.9,-2.275) 16(2.9,-1.625) 17(2.9,-0.975) 18(2.9,-0.325) 19(2.9,0.325) 20(2.9,0.975) 21(2.9,1.625) 22(2.9,2.275) 23(2.9,2.925) 24(2.9,3.575)
TSSOP56_19-68_560X240_1-2
  rect 1.499x0.305 smd: 1(-3.75,6.75) 2(-3.75,6.25) 3(-3.75,5.75) 4(-3.75,5.25) 5(-3.75,4.75) 6(-3.75,4.25) 7(-3.75,3.75) 8(-3.75,3.25) 9(-3.75,2.75) 10(-3.75,2.25) 11(-3.75,1.75) 12(-3.75,1.25) 13(-3.75,0.75) 14(-3.75,0.25) 15(-3.75,-0.25) 16(-3.75,-0.75) 17(-3.75,-1.25) 18(-3.75,-1.75) 19(-3.75,-2.25) 20(-3.75,-2.75) 21(-3.75,-3.25) 22(-3.75,-3.75) 23(-3.75,-4.25) 24(-3.75,-4.75) 25(-3.75,-5.25) 26(-3.75,-5.75) 27(-3.75,-6.25) 28(-3.75,-6.75) 29(3.75,-6.75) 30(3.75,-6.25) 31(3.75,-5.75) 32(3.75,-5.25) 33(3.75,-4.75) 34(3.75,-4.25) 35(3.75,-3.75) 36(3.75,-3.25) 37(3.75,-2.75) 38(3.75,-2.25) 39(3.75,-1.75) 40(3.75,-1.25) 41(3.75,-0.75) 42(3.75,-0.25) 43(3.75,0.25) 44(3.75,0.75) 45(3.75,1.25) 46(3.75,1.75) 47(3.75,2.25) 48(3.75,2.75) 49(3.75,3.25) 50(3.75,3.75) 51(3.75,4.25) 52(3.75,4.75) 53(3.75,5.25) 54(3.75,5.75) 55(3.75,6.25) 56(3.75,6.75)
TVSOP16_15-74_150X180
  rect 1.499x0.203 smd: 1(-2.9,1.4) 2(-2.9,1) 3(-2.9,0.6) 4(-2.9,0.2) 5(-2.9,-0.2) 6(-2.9,-0.6) 7(-2.9,-1) 8(-2.9,-1.4) 9(2.9,-1.4) 10(2.9,-1) 11(2.9,-0.6) 12(2.9,-0.2) 13(2.9,0.2) 14(2.9,0.6) 15(2.9,1) 16(2.9,1.4)
unnamed#2
  round 3.073 hole 3.2 unplated: (0,0)
unnamed#3
  round 1.549 hole 1.676 unplated: (-14.863,14.863) (-14.863,-14.863) (14.863,14.863) (14.863,-14.863)
  round 0.737 hole 0.864 unplated: (-14.863,-9.783) (14.863,12.323)
UQFN10_19-68_80X60
  rect 0.584x0.305 smd: 1(-0.635,0.75) 4(-0.635,-0.75) 6(0.635,-0.75) 9(0.635,0.75)
  rect 0.584x0.254 smd: 2(-0.637,0.25) 3(-0.637,-0.25) 7(0.637,-0.25) 8(0.637,0.25)
  rect 0.356x0.635 smd: 5(0,-0.86) 10(0,0.86)
VFBGA153_19-68_460X520_0-8
  round 0.254 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B1(-3.25,2.75) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C1(-3.25,2.25) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D1(-3.25,1.75) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M1(-3.25,-2.25) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N1(-3.25,-2.75) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P1(-3.25,-3.25) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
VFBGA153_19-68_460X520_0-9
  round 0.203 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) B1(-3.25,2.75) C1(-3.25,2.25) D1(-3.25,1.75) M1(-3.25,-2.25) N1(-3.25,-2.75) P1(-3.25,-3.25)
  round 0.254 smd: A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
VQFN16_TPS62872-Q1_100X140_1-1
  custom 0.15x0.15 smd: 1(-1,1.5) 13(1,1.5)
  rect 0.61x0.254 smd: 2(-1.175,1) 3(-1.175,0.5) 4(-1.175,0) 5(-1.175,-0.5) 9(1.175,-0.5) 10(1.175,0) 11(1.175,0.5) 12(1.175,1)
  custom 0.175x0.175 smd: 6(-1.175,-1.422) 8(1.175,-1.422)
  rect 1.346x0.686 smd: 7(0,-1.67)
  rect 0.254x0.61 smd: 14(0.5,1.675) 15(0,1.675) 16(-0.5,1.675)
  rect 1.245x2.261 smd: 17(0,0)
VQFN24_LM5141_160X160_1
  rect 0.61x0.254 smd: 1(-1.9,1.25) 2(-1.9,0.75) 3(-1.9,0.25) 4(-1.9,-0.25) 5(-1.9,-0.75) 6(-1.9,-1.25) 13(1.9,-1.25) 14(1.9,-0.75) 15(1.9,-0.25) 16(1.9,0.25) 17(1.9,0.75) 18(1.9,1.25)
  rect 0.254x0.61 smd: 7(-1.25,-1.9) 8(-0.75,-1.9) 9(-0.25,-1.9) 10(0.25,-1.9) 11(0.75,-1.9) 12(1.25,-1.9) 19(1.25,1.9) 20(0.75,1.9) 21(0.25,1.9) 22(-0.25,1.9) 23(-0.75,1.9) 24(-1.25,1.9)
  rect 2.794x2.794 smd: 25(0,0)
  custom 0.145x0.145 smd: A1(-1.72,1.72) A2(-1.72,-1.72) A3(1.72,-1.72) A4(1.72,1.72)
VQFN32_TPS25830-Q1_200X200_1
  rect 0.61x0.254 smd: 1(-2.4,1.75) 2(-2.4,1.25) 3(-2.4,0.75) 4(-2.4,0.25) 5(-2.4,-0.25) 6(-2.4,-0.75) 7(-2.4,-1.25) 8(-2.4,-1.75) 17(2.4,-1.75) 18(2.4,-1.25) 19(2.4,-0.75) 20(2.4,-0.25) 21(2.4,0.25) 22(2.4,0.75) 23(2.4,1.25) 24(2.4,1.75)
  rect 0.254x0.61 smd: 9(-1.75,-2.4) 10(-1.25,-2.4) 11(-0.75,-2.4) 12(-0.25,-2.4) 13(0.25,-2.4) 14(0.75,-2.4) 15(1.25,-2.4) 16(1.75,-2.4) 25(1.75,2.4) 26(1.25,2.4) 27(0.75,2.4) 28(0.25,2.4) 29(-0.25,2.4) 30(-0.75,2.4) 31(-1.25,2.4) 32(-1.75,2.4)
  rect 3.708x3.708 smd: 33(0,0)
  custom 0.144x0.144 smd: A1(-2.225,2.225) A2(-2.225,-2.225) A3(2.225,-2.225) A4(2.225,2.225)
VQFN48_19-68_285X285
  rect 0.864x0.305 smd: 1(-3.5,2.75) 2(-3.5,2.25) 3(-3.5,1.75) 4(-3.5,1.25) 5(-3.5,0.75) 6(-3.5,0.25) 7(-3.5,-0.25) 8(-3.5,-0.75) 9(-3.5,-1.25) 10(-3.5,-1.75) 11(-3.5,-2.25) 12(-3.5,-2.75) 25(3.5,-2.75) 26(3.5,-2.25) 27(3.5,-1.75) 28(3.5,-1.25) 29(3.5,-0.75) 30(3.5,-0.25) 31(3.5,0.25) 32(3.5,0.75) 33(3.5,1.25) 34(3.5,1.75) 35(3.5,2.25) 36(3.5,2.75)
  rect 0.305x0.864 smd: 13(-2.75,-3.5) 14(-2.25,-3.5) 15(-1.75,-3.5) 16(-1.25,-3.5) 17(-0.75,-3.5) 18(-0.25,-3.5) 19(0.25,-3.5) 20(0.75,-3.5) 21(1.25,-3.5) 22(1.75,-3.5) 23(2.25,-3.5) 24(2.75,-3.5) 37(2.75,3.5) 38(2.25,3.5) 39(1.75,3.5) 40(1.25,3.5) 41(0.75,3.5) 42(0.25,3.5) 43(-0.25,3.5) 44(-0.75,3.5) 45(-1.25,3.5) 46(-1.75,3.5) 47(-2.25,3.5) 48(-2.75,3.5)
  rect 4.166x4.166 smd: 49(0,0)
VQFN56_19-68_320X320_0-9_EP6
  rect 0.787x0.305 smd: 1(-4,3.25) 2(-4,2.75) 3(-4,2.25) 4(-4,1.75) 5(-4,1.25) 6(-4,0.75) 7(-4,0.25) 8(-4,-0.25) 9(-4,-0.75) 10(-4,-1.25) 11(-4,-1.75) 12(-4,-2.25) 13(-4,-2.75) 14(-4,-3.25) 29(4,-3.25) 30(4,-2.75) 31(4,-2.25) 32(4,-1.75) 33(4,-1.25) 34(4,-0.75) 35(4,-0.25) 36(4,0.25) 37(4,0.75) 38(4,1.25) 39(4,1.75) 40(4,2.25) 41(4,2.75) 42(4,3.25)
  rect 0.305x0.787 smd: 15(-3.25,-4) 16(-2.75,-4) 17(-2.25,-4) 18(-1.75,-4) 19(-1.25,-4) 20(-0.75,-4) 21(-0.25,-4) 22(0.25,-4) 23(0.75,-4) 24(1.25,-4) 25(1.75,-4) 26(2.25,-4) 27(2.75,-4) 28(3.25,-4) 43(3.25,4) 44(2.75,4) 45(2.25,4) 46(1.75,4) 47(1.25,4) 48(0.75,4) 49(0.25,4) 50(-0.25,4) 51(-0.75,4) 52(-1.25,4) 53(-1.75,4) 54(-2.25,4) 55(-2.75,4) 56(-3.25,4)
  rect 5.588x5.588 smd: 57(0,0)
VSON8_CSD1850_240X200_1-1
  rect 1.372x0.711 smd: 1(-2.77,1.905) 2(-2.77,0.635) 3(-2.77,-0.635) 4(-2.77,-1.905)
  custom 1.11x1.11 smd: 5(1.236,0)
VSON8_CSD16407Q5_240X200_1-1
  rect 0.787x0.711 smd: 1(-2.752,1.98) 2(-2.752,0.66) 3(-2.752,-0.66) 4(-2.752,-1.98)
  custom 1.159x1.159 smd: 5(0.653,0)
VSON8_CSD85312Q3E_130X130_1
  rect 0.66x2.388 smd: 1(-1.475,0)
  rect 0.66x0.432 smd: 5(1.475,-0.975)
  rect 0.66x1.753 smd: 8(1.475,0.325)
  custom 0.475x0.475 smd: 9(0,0)
VSON10_TPS74801-Q1_120X120_1
  rect 0.61x0.229 smd: 1(-1.4,1) 2(-1.4,0.5) 3(-1.4,0) 4(-1.4,-0.5) 5(-1.4,-1) 6(1.4,-1) 7(1.4,-0.5) 8(1.4,0) 9(1.4,0.5) 10(1.4,1)
  custom 0.412x0.412 smd: 11(0,0)
VSON14_25-59_120X180_0-9
  rect 0.787x0.356 smd: 1(-1.5,1.95) 2(-1.5,1.3) 3(-1.5,0.65) 4(-1.5,0) 5(-1.5,-0.65) 6(-1.5,-1.3) 7(-1.5,-1.95) 8(1.5,-1.95) 9(1.5,-1.3) 10(1.5,-0.65) 11(1.5,0) 12(1.5,0.65) 13(1.5,1.3) 14(1.5,1.95)
  rect 1.702x4.293 smd: 15(0,0)
VSONP8_CSD18543Q_120X130_0-9
  rect 0.711x0.406 smd: 1(-1.55,0.975) 2(-1.55,0.325) 3(-1.55,-0.325) 4(-1.55,-0.975)
  rect 2.515x2.54 smd: 5(0.645,0)
VSONP8_CSD19531_230X200_1-1
  rect 0.787x0.711 smd: 1(-2.752,1.905) 2(-2.752,0.635) 3(-2.752,-0.635) 4(-2.752,-1.905)
  custom 1.14x1.14 smd: 5(0.653,0)
VSSOP8_19-68_85X95
  rect 0.838x0.305 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
VSSOP8_19-68_85X95_0-9
  rect 0.838x0.305 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
VSSOP8_25-59_120X120_1-1
  rect 1.397x0.457 smd: 1(-2.2,0.975) 2(-2.2,0.325) 3(-2.2,-0.325) 4(-2.2,-0.975) 5(2.2,-0.975) 6(2.2,-0.325) 7(2.2,0.325) 8(2.2,0.975)
WFBGA200_MT53DDS_400X570_1-2
  round 0.356 smd: A1(-4.4,6.825) A2(-3.6,6.825) A3(-2.8,6.825) A4(-2,6.825) A5(-1.2,6.825) A8(1.2,6.825) A9(2,6.825) A10(2.8,6.825) A11(3.6,6.825) A12(4.4,6.825) AA1(-4.4,-6.175) AA2(-3.6,-6.175) AA3(-2.8,-6.175) AA4(-2,-6.175) AA5(-1.2,-6.175) AA8(1.2,-6.175) AA9(2,-6.175) AA10(2.8,-6.175) AA11(3.6,-6.175) AA12(4.4,-6.175) AB1(-4.4,-6.825) AB2(-3.6,-6.825) AB3(-2.8,-6.825) AB4(-2,-6.825) AB5(-1.2,-6.825) AB8(1.2,-6.825) AB9(2,-6.825) AB10(2.8,-6.825) AB11(3.6,-6.825) AB12(4.4,-6.825) B1(-4.4,6.175) B2(-3.6,6.175) B3(-2.8,6.175) B4(-2,6.175) B5(-1.2,6.175) B8(1.2,6.175) B9(2,6.175) B10(2.8,6.175) B11(3.6,6.175) B12(4.4,6.175) C1(-4.4,5.525) C2(-3.6,5.525) C3(-2.8,5.525) C4(-2,5.525) C5(-1.2,5.525) C8(1.2,5.525) C9(2,5.525) C10(2.8,5.525) C11(3.6,5.525) C12(4.4,5.525) D1(-4.4,4.875) D2(-3.6,4.875) D3(-2.8,4.875) D4(-2,4.875) D5(-1.2,4.875) D8(1.2,4.875) D9(2,4.875) D10(2.8,4.875) D11(3.6,4.875) D12(4.4,4.875) E1(-4.4,4.225) E2(-3.6,4.225) E3(-2.8,4.225) E4(-2,4.225) E5(-1.2,4.225) E8(1.2,4.225) E9(2,4.225) E10(2.8,4.225) E11(3.6,4.225) E12(4.4,4.225) F1(-4.4,3.575) F2(-3.6,3.575) F3(-2.8,3.575) F4(-2,3.575) F5(-1.2,3.575) F8(1.2,3.575) F9(2,3.575) F10(2.8,3.575) F11(3.6,3.575) F12(4.4,3.575) G1(-4.4,2.925) G2(-3.6,2.925) G3(-2.8,2.925) G4(-2,2.925) G5(-1.2,2.925) G8(1.2,2.925) G9(2,2.925) G10(2.8,2.925) G11(3.6,2.925) G12(4.4,2.925) H1(-4.4,2.275) H2(-3.6,2.275) H3(-2.8,2.275) H4(-2,2.275) H5(-1.2,2.275) H8(1.2,2.275) H9(2,2.275) H10(2.8,2.275) H11(3.6,2.275) H12(4.4,2.275) J1(-4.4,1.625) J2(-3.6,1.625) J3(-2.8,1.625) J4(-2,1.625) J5(-1.2,1.625) J8(1.2,1.625) J9(2,1.625) J10(2.8,1.625) J11(3.6,1.625) J12(4.4,1.625) K1(-4.4,0.975) K2(-3.6,0.975) K3(-2.8,0.975) K4(-2,0.975) K5(-1.2,0.975) K8(1.2,0.975) K9(2,0.975) K10(2.8,0.975) K11(3.6,0.975) K12(4.4,0.975) N1(-4.4,-0.975) N2(-3.6,-0.975) N3(-2.8,-0.975) N4(-2,-0.975) N5(-1.2,-0.975) N8(1.2,-0.975) N9(2,-0.975) N10(2.8,-0.975) N11(3.6,-0.975) N12(4.4,-0.975) P1(-4.4,-1.625) P2(-3.6,-1.625) P3(-2.8,-1.625) P4(-2,-1.625) P5(-1.2,-1.625) P8(1.2,-1.625) P9(2,-1.625) P10(2.8,-1.625) P11(3.6,-1.625) P12(4.4,-1.625) R1(-4.4,-2.275) R2(-3.6,-2.275) R3(-2.8,-2.275) R4(-2,-2.275) R5(-1.2,-2.275) R8(1.2,-2.275) R9(2,-2.275) R10(2.8,-2.275) R11(3.6,-2.275) R12(4.4,-2.275) T1(-4.4,-2.925) T2(-3.6,-2.925) T3(-2.8,-2.925) T4(-2,-2.925) T5(-1.2,-2.925) T8(1.2,-2.925) T9(2,-2.925) T10(2.8,-2.925) T11(3.6,-2.925) T12(4.4,-2.925) U1(-4.4,-3.575) U2(-3.6,-3.575) U3(-2.8,-3.575) U4(-2,-3.575) U5(-1.2,-3.575) U8(1.2,-3.575) U9(2,-3.575) U10(2.8,-3.575) U11(3.6,-3.575) U12(4.4,-3.575) V1(-4.4,-4.225) V2(-3.6,-4.225) V3(-2.8,-4.225) V4(-2,-4.225) V5(-1.2,-4.225) V8(1.2,-4.225) V9(2,-4.225) V10(2.8,-4.225) V11(3.6,-4.225) V12(4.4,-4.225) W1(-4.4,-4.875) W2(-3.6,-4.875) W3(-2.8,-4.875) W4(-2,-4.875) W5(-1.2,-4.875) W8(1.2,-4.875) W9(2,-4.875) W10(2.8,-4.875) W11(3.6,-4.875) W12(4.4,-4.875) Y1(-4.4,-5.525) Y2(-3.6,-5.525) Y3(-2.8,-5.525) Y4(-2,-5.525) Y5(-1.2,-5.525) Y8(1.2,-5.525) Y9(2,-5.525) Y10(2.8,-5.525) Y11(3.6,-5.525) Y12(4.4,-5.525)
WQFN24_19-68_160X160
  rect 0.813x0.305 smd: 1(-2,1.25) 2(-2,0.75) 3(-2,0.25) 4(-2,-0.25) 5(-2,-0.75) 6(-2,-1.25) 13(2,-1.25) 14(2,-0.75) 15(2,-0.25) 16(2,0.25) 17(2,0.75) 18(2,1.25)
  rect 0.305x0.813 smd: 7(-1.25,-2) 8(-0.75,-2) 9(-0.25,-2) 10(0.25,-2) 11(0.75,-2) 12(1.25,-2) 19(1.25,2) 20(0.75,2) 21(0.25,2) 22(-0.25,2) 23(-0.75,2) 24(-1.25,2)
  rect 2.692x2.692 smd: 25(0,0)
WSON6_19-68_60X60
  rect 0.965x0.305 smd: 1(-0.65,0.5) 2(-0.65,0) 3(-0.65,-0.5) 4(0.65,-0.5) 5(0.65,0) 6(0.65,0.5)
WSON8_19-68_80X80_0-8
  rect 0.711x0.305 smd: 1(-1.05,0.75) 2(-1.05,0.25) 3(-1.05,-0.25) 4(-1.05,-0.75) 5(1.05,-0.75) 6(1.05,-0.25) 7(1.05,0.25) 8(1.05,0.75)
  rect 0.991x1.702 smd: 9(0,0)
X2QFN12_TUSB322I_60X60_0-4
  rect 0.711x0.203 smd: 1(-0.65,0.2) 2(-0.65,-0.2) 7(0.65,-0.2) 8(0.65,0.2)
  rect 0.203x0.508 smd: 3(-0.6,-0.75) 4(-0.2,-0.75) 5(0.2,-0.75) 6(0.6,-0.75) 9(0.6,0.75) 10(0.2,0.75) 11(-0.2,0.75) 12(-0.6,0.75)
XTAL4_ABM10W_100X80_SMD_0-6
  rect 1.194x0.838 smd: 1(-0.812,-0.6) 2(0.812,-0.6) 3(0.812,0.6) 4(-0.812,0.6)
XTAL4_NX3225GA_130X100_SMD_0-9
  rect 1.422x1.219 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTAL_ABM3_205X130_SMD_1-4
  rect 1.803x2.413 smd: 1(-1.9,0) 2(1.9,0)
XTAL_ABS07_130X60_SMD_0-9
  rect 1.118x1.905 smd: 1(-1.25,0) 2(1.25,0)
XTAL_ECS-32_130X60_SMD_0-9
  rect 1.118x1.905 smd: 1(-1.25,0) 2(1.25,0)
XTAL_ECX-64AEN_240X150_SMD_1-1
  rect 1.905x2.388 smd: 1(-2.25,0) 2(2.25,0)

## Nets
