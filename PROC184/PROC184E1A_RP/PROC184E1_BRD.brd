# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE1/HYP0_RX1_P: length 153.8
  L3-SIGNAL1 w0.104: v3(123.12,92.63) v5(123.34,92.91)
  L4-GND2 w0.121: v5(123.34,92.91) v7(123.65,93.22)
  L13-GND5 w0.121: v9(123.94,92.93) 123.86,93 v7(123.65,93.22)
  L14-SIGNAL6 w0.104: v9(123.94,92.93) 124.17,93.16 arc(124.19,93.19) 124.2,93.23 124.2,94.28 arc(124.22,94.41) 124.3,94.52 124.46,94.68 arc(124.48,94.71) 124.49,94.75 124.49,95.25 arc(124.54,95.51) 124.69,95.73 126.22,97.26 arc(126.45,97.41) 126.71,97.46 127.19,97.46 arc(127.52,97.53) 127.8,97.71 129.13,99.04 arc(129.27,99.26) 129.32,99.51 129.32,101.29 arc(129.39,101.67) 129.61,101.99 132.19,104.57 arc(132.36,104.83) 132.42,105.13 132.42,105.9 arc(132.48,106.2) 132.65,106.45 133.2,107 arc(133.55,107.53) 133.67,108.15 133.67,136 arc(133.33,137.72) 132.36,139.18 122.79,148.75 arc(122.29,149.08) 121.71,149.19 62.78,149.19 arc(61.27,148.89) 59.99,148.04 55.52,143.57 arc(54.07,142.6) 52.37,142.26 45.53,142.26 arc(44.54,141.86) 44.14,140.87 44.14,138.5 44.14,138.5 arc(44.07,138.15) 43.87,137.86 43.6,137.59 arc(43.05,137.36) 42.49,137.59 arc(42.43,137.64) 42.35,137.65 arc(42.12,137.56) 42.02,137.33 J17.A21
  vias: v1(123.12,92.63)
PCIE1/HYP0_RX2_N: length 107.8
  L14-SIGNAL6 w0.104: J17.A26 47.02,137.9 arc(46.93,137.68) 46.71,137.59 46.46,137.59 arc(46.24,137.68) 46.15,137.9 46.15,139.92 arc(46.45,140.64) 47.18,140.95 52.76,140.95 arc(54.47,141.28) 55.92,142.25 60.81,147.14 arc(61.73,147.76) 62.82,147.97 121.02,147.97 arc(121.72,147.83) 122.32,147.44 131.32,138.43 arc(131.81,137.69) 131.99,136.82 131.99,127.7 arc(131.97,127.63) 131.93,127.56 v11(131.6,127.23)
PCIE1/HYP0_RX2_P: length 107.8
  L14-SIGNAL6 w0.104: v11(132.61,127.23) 132.29,127.55 arc(132.24,127.63) 132.22,127.72 132.22,136.82 arc(132.03,137.78) 131.48,138.6 122.48,147.6 arc(121.81,148.05) 121.02,148.2 62.82,148.2 arc(61.64,147.97) 60.64,147.31 55.75,142.41 arc(54.38,141.5) 52.76,141.18 47.18,141.18 arc(46.29,140.81) 45.92,139.92 45.92,136.9 arc(45.94,136.77) J17.A25
PCIE1/HYP0_RX3_N: length 97.7
  L14-SIGNAL6 w0.104: J17.A30 51.02,137.9 arc(50.93,137.68) 50.71,137.59 50.46,137.59 arc(50.24,137.68) 50.15,137.9 50.15,139.27 arc(50.31,139.66) 50.7,139.83 53.93,139.83 arc(55.12,140.06) 56.13,140.74 61.71,146.32 arc(62.19,146.64) 62.77,146.75 120.61,146.75 arc(121.18,146.64) 121.66,146.32 129.74,138.23 arc(130.16,137.62) 130.3,136.89 130.3,130.75 arc(130.28,130.65) 130.22,130.55 v11(129.91,130.24)
PCIE1/HYP0_RX3_P: length 97.7
  L14-SIGNAL6 w0.104: v11(130.93,130.24) 130.59,130.58 arc(130.55,130.64) 130.53,130.72 130.53,136.89 arc(130.37,137.71) 129.91,138.4 121.82,146.48 arc(121.27,146.85) 120.61,146.99 62.77,146.99 arc(62.1,146.85) 61.54,146.48 55.96,140.9 arc(55.03,140.28) 53.93,140.06 50.7,140.06 arc(50.15,139.83) 49.92,139.27 49.92,136.9 arc(49.94,136.77) J17.A29
PCIE1/HYP0_TX0_N: length 4.2
  BOTTOM w0.122: J17.B15 35.62,133.75 arc(35.53,133.54) 35.62,133.32 35.9,133.04 arc(36.08,132.77) 36.15,132.44 36.15,131.73 36.16,131.71 36.16,131.68
  BOTTOM w0.132: 36.16,131.68 36.16,130.77 arc(36.18,130.64) 36.26,130.53 C689.2
PCIE1/HYP0_TX0_P: length 4.2
  BOTTOM w0.122: 35.88,131.68 35.88,131.71 35.89,131.73 35.89,132.44 arc(35.85,132.67) 35.72,132.86 35.52,133.06 arc(35.35,133.14) 35.17,133.06 35.09,132.98 arc(35.04,132.9) 35.02,132.81 J17.B14
  BOTTOM w0.132: C690.2 35.78,130.53 arc(35.85,130.64) 35.88,130.77 35.88,131.68
PCIE1/HYP0_TX1_N: length 4.2
  BOTTOM w0.122: 40.16,131.68 40.16,131.71 40.15,131.73 40.15,132.44 arc(40.19,132.67) 40.32,132.86 40.52,133.06 arc(40.69,133.14) 40.87,133.06 40.95,132.98 arc(41,132.9) 41.02,132.81 J17.B20
  BOTTOM w0.132: C687.2 40.26,130.53 arc(40.18,130.64) 40.16,130.77 40.16,131.68
PCIE1/HYP0_TX1_P: length 4.2
  BOTTOM w0.122: 39.88,131.68 39.88,131.71 39.89,131.73 39.89,132.44 arc(39.96,132.77) 40.14,133.04 40.42,133.32 arc(40.51,133.54) 40.42,133.75 J17.B19
  BOTTOM w0.132: C688.2 39.78,130.53 arc(39.85,130.64) 39.88,130.77 39.88,131.68
PCIE1/HYP0_TX2_N: length 106.9
  L14-SIGNAL6 w0.104: v11(127.55,130.26) 127.23,130.59 arc(127.18,130.66) 127.16,130.76 127.16,131.51 arc(126.76,132.47) 125.79,132.87 125.18,132.87 arc(124.5,133.01) 123.93,133.39 122.39,134.92 arc(121.98,135.54) 121.83,136.27 121.83,139.17 arc(121.7,139.85) 121.32,140.42 117.89,143.85 arc(117.12,144.36) 116.2,144.55 66.23,144.55 arc(64.78,143.94) 64.17,142.48 64.17,136.52 arc(64.01,135.7) 63.54,135.01 59.1,130.57 arc(58.21,129.97) 57.15,129.76 44.9,129.76 arc(44.37,129.98) 44.14,130.52 44.14,132.6 arc(44.17,132.73) 44.24,132.84 44.34,132.93 arc(44.44,133) 44.56,133.03 44.62,133.03 arc(44.9,132.91) 45.02,132.63 J17.B24
PCIE1/HYP0_TX2_P: length 106.9
  L14-SIGNAL6 w0.104: v11(126.54,130.26) 126.86,130.59 arc(126.91,130.66) 126.93,130.76 126.93,131.51 arc(126.6,132.31) 125.79,132.64 125.18,132.64 arc(124.41,132.79) 123.76,133.23 122.23,134.76 arc(121.77,135.45) 121.6,136.27 121.6,139.17 arc(121.49,139.76) 121.15,140.26 117.73,143.68 arc(117.03,144.15) 116.2,144.32 66.23,144.32 arc(64.94,143.78) 64.4,142.48 64.4,136.52 arc(64.22,135.62) 63.71,134.85 59.27,130.4 arc(58.3,129.76) 57.15,129.53 44.9,129.53 arc(44.2,129.82) 43.91,130.52 43.91,132.6 arc(43.96,132.82) 44.08,133 44.2,133.12 arc(44.37,133.55) 44.2,133.97 J17.B23
PCIE1/HYP0_TX3_N: length 101.6
  L14-SIGNAL6 w0.104: J17.B28 49.02,132.63 arc(48.9,132.91) 48.62,133.03 48.56,133.03 arc(48.44,133) 48.34,132.93 48.24,132.84 arc(48.17,132.73) 48.14,132.6 48.14,131.53 arc(48.31,131.14) 48.7,130.98 55.37,130.98 arc(56.61,131.49) 57.12,132.73 57.12,137.72 arc(57.52,139.75) 58.67,141.47 61.52,144.32 arc(63.13,145.39) 65.02,145.77 116.64,145.77 arc(117.59,145.58) 118.41,145.03 122.01,141.43 arc(122.23,141.28) 122.49,141.23 123.38,141.23 arc(123.63,141.18) 123.84,141.04 126.44,138.44 arc(126.75,137.97) 126.86,137.42 126.86,135.22 arc(126.99,134.91) 127.3,134.78 128.33,134.78 arc(128.71,134.62) 128.87,134.24 128.87,133.82 arc(128.9,133.66) 128.99,133.53 v11(129.26,133.26)
PCIE1/HYP0_TX3_P: length 101.6
  L14-SIGNAL6 w0.104: v11(128.25,133.26) 128.52,133.53 arc(128.61,133.66) 128.64,133.82 128.64,134.24 arc(128.55,134.46) 128.33,134.55 127.3,134.55 arc(126.82,134.75) 126.63,135.22 126.63,137.42 arc(126.53,137.88) 126.27,138.28 123.68,140.87 arc(123.54,140.97) 123.38,141 122.49,141 arc(122.14,141.07) 121.85,141.26 118.24,144.87 arc(117.51,145.36) 116.64,145.53 65.02,145.53 arc(63.21,145.18) 61.69,144.16 58.83,141.3 arc(57.74,139.66) 57.35,137.72 57.35,132.73 arc(56.77,131.33) 55.37,130.75 48.7,130.75 arc(48.14,130.98) 47.91,131.53 47.91,132.6 arc(47.96,132.82) 48.08,133 48.2,133.12 arc(48.37,133.55) 48.2,133.97 J17.B27
PCIE1_2L_EP_RST_EN: length 15.7
  TOP w0.127: U43.4 45.38,116.66 v2(45.88,117.16) ; U33.2 50.2,123.28 50.46,123.53 R183.2 v2(49.27,125.34)
  L3-SIGNAL1 w0.089: v2(49.27,125.34) 48.85,124.92 48.85,121.63 46.56,119.35 46.56,117.84 v2(45.88,117.16)
PCIE1_2L_MODE_SEL: length 137.9
  TOP w0.127: U43.1 46.88,115.41 v2(46.88,116.25) ; SW2.6 v2(147.81,170.25) ; U33.1 v2(49.37,121.81) 49.37,120.82 U38.1
  L3-SIGNAL1 w0.089: v2(46.88,116.25) 47.82,117.19 47.82,120.26 v2(49.37,121.81) 49.37,124.44 51.2,126.27 56.86,126.27 80.69,150.09 86.23,150.09 103.98,167.84 103.98,168.67 104.6,169.29 109,169.29 110.03,168.25 110.03,165.51 111.47,164.07 116.95,164.07 117.21,163.81 123.11,163.81 123.77,164.48 130.47,164.48 133.88,167.88 138.31,167.88 140.11,169.68 147.24,169.68 v2(147.81,170.25)
PCIE1_2L_RC_RSTZ: length 10.8
  TOP w0.127: v2(45.88,116.25) 45.88,115.41 U43.3
  L7-SIGNAL3 w0.109: v2(44.46,121.93) 44.46,121.78 44.78,121.45 44.78,119.29 45.78,118.29 45.78,117.68 45.44,117.34 45.44,116.68 v2(45.88,116.25)
  BOTTOM w0.127: v2(44.46,121.93) R902.2 R901.1 U190.1
PCIE1_2L_SCL: length 9.3
  TOP w0.127: R158.2 v2(21.85,140.67)
  L14-SIGNAL6 w0.089: J17.B5 23.03,135.14 23.03,137.07 22.03,138.07 22.03,140.5 v2(21.85,140.67)
  BOTTOM w0.127: U181.10 v2(21.85,140.67)
PCIE1_2L_SDA: length 11.6
  TOP w0.127: R159.2 23,140.9 v2(22.77,140.67)
  L14-SIGNAL6 w0.089: v2(22.77,140.67) 24.09,139.35 24.09,138.07 25.02,137.14 J17.B6
  BOTTOM w0.127: U181.9 22.5,140.94 v2(22.77,140.67)
PCIE1_4L_PERSTZ: length 37.8
  TOP w0.127: U43.2 46.38,115.41 46.38,116.66 v2(46.88,117.16) 47.47,117.76 U38.4 47.47,119.42 47.23,119.67 46.41,119.67 v2(46.13,119.95)
  L12-SIGNAL5 w0.102: v2(46.88,117.16) 46.88,119.2 v2(46.13,119.95) 45.03,121.05 45.03,123.54 38.62,129.95 33.44,129.95 31.67,131.72 31.67,131.73 30.64,132.76 29.92,132.76 29.07,133.61 29.07,135.7 J17.A11
  BOTTOM w0.127: U196.2 v2(46.13,119.95)
PCIE1_4L_PRSNT#: length 24.6
  TOP w0.127: v2(41.87,113.66) 42.37,113.16 U43.10
  L3-SIGNAL1 w0.089: v2(41.87,113.66) 42.29,114.08 46.99,114.08 48.88,115.97 48.88,120.21 50.65,121.98 51.33,121.98 52.62,123.28 v2(52.62,125.08)
  BOTTOM w0.127: R878.2 51.93,125.77 v2(52.62,125.08)
PCIE1_AND_OUT: length 4.7
  TOP w0.127: U38.2 v2(48.42,121.81)
  BOTTOM w0.127: U190.4 48.98,124.53 48.77,124.31 48.77,122.16 v2(48.42,121.81)
PCIE1_CLKREQ#: length 1.9
  BOTTOM w0.127: R871.2 J17.B12
PCIE1_INT#: length 13.3
  TOP w0.127: R160.1 24.14,140.8 24.01,140.67 v2(23.68,140.67)
  L3-SIGNAL1 w0.089: J17.B11 28.79,135.38 27.67,135.38 27.01,136.04 27.01,137.28 26.01,138.28 26.01,139.75 25.09,140.67 v2(23.68,140.67)
  BOTTOM w0.127: U181.8 23.15,140.92 23.4,140.67 v2(23.68,140.67)
PCIE1_NAND_OUT: length 10.4
  TOP w0.127: v2(46.13,119) 45.55,119.58 45.55,121.24 45.07,121.72 45.07,124.72 45.37,125.03 46.9,125.03 47.17,124.75 U33.4
  BOTTOM w0.127: U196.1 v2(46.13,119)
PCIE1_PORZ: length 100.9
  L5-SIGNAL2 w0.102: v2(25.04,108.78) 26.85,108.78 29.91,111.85 29.91,113.78 31.25,115.11 31.57,115.11 32.51,116.05 39.19,116.05 41.99,118.85 44.43,118.85 45.96,120.38 49.34,120.38 49.44,120.28 v2(49.44,119.84)
  L14-SIGNAL6 w0.089: v2(20.84,45.15) 20.84,47.76 21.95,48.88 21.95,50.78 21.41,51.32 21.41,55.3 21.35,55.36 21.35,70.03 24.29,72.97 24.29,86.31 25,87.03 25,102.85 25.97,103.81 25.97,107.85 v2(25.04,108.78)
  BOTTOM w0.127: U251.6 v2(20.84,45.15) ; v2(49.44,119.84) 49.77,120.18 U196.4 50.46,120.9 50.7,121.13 v2(51.21,121.13)
PCIE1_PRSNT1#: length 4.4
  BOTTOM w0.127: J17.A1 19.14,136.65 18.76,137.03 R848.2 R853.2 R854.2
PCIE1_PRSNT2_1#: length 5.3
  BOTTOM w0.127: J17.B17 38.02,128.82 R882.2
PCIE1_PRSNT2_2#: length 5.9
  BOTTOM w0.127: J17.B31 52.02,129.39 R878.1 51.93,129.29 R879.2
PCIE1_TCK: length 5.2
  TOP w0.127: J17.A5 24.02,139.46 25.28,140.73 R161.2
PCIE1_TDI: length 3.3
  TOP w0.127: R162.1 26.43,140.06 J17.A6
PCIE1_TDO: length 5.3
  TOP w0.127: R163.1 27.57,140.7 26.02,139.15 J17.A7
PCIE1_TMS: length 3.4
  TOP w0.127: J17.A8 28.71,140.34 R164.1
PCIE1_TRST#: length 5.2
  BOTTOM w0.127: J17.B9 27.02,133.15 26.42,133.15 26.04,132.77 26.04,131.45 25.65,131.06 R873.1
PCIE_REFCLK0_OUT_N: length 45.3
  L3-SIGNAL1 w0.079: v3(123.12,90.23) v5(123.34,90.51)
  L4-GND2 w0.089: v5(123.34,90.51) v7(123.65,90.82)
  L13-GND5 w0.089: v9(123.94,91.11) 123.86,91.03 v7(123.65,90.82)
  L14-SIGNAL6 w0.079: v11(138.17,121.92) 137.85,121.92 arc(137.76,121.88) 137.72,121.79 137.72,111.44 arc(137.68,111.22) 137.55,111.02 arc(137.51,110.97) 137.5,110.9 137.5,104.96 arc(137.42,104.58) 137.21,104.25 136.33,103.38 arc(135.98,103.14) 135.56,103.06 134.11,103.06 arc(133.78,102.99) 133.5,102.8 131.5,100.81 arc(131.41,100.67) 131.38,100.51 131.38,97.17 arc(131.28,96.69) 131,96.27 130.63,95.9 arc(130.23,95.63) 129.76,95.54 127.23,95.54 arc(127.01,95.5) 126.83,95.37 126.36,94.9 arc(126.21,94.69) 126.16,94.43 126.16,93.7 arc(126.11,93.43) 125.96,93.21 125.03,92.28 arc(124.79,92.12) 124.5,92.06 123.93,92.06 arc(123.75,92.02) 123.59,91.92 123.28,91.61 arc(123.21,91.51) 123.19,91.38 123.19,90.66 arc(123.2,90.61) 123.23,90.57 123.32,90.47 arc(123.35,90.46) 123.38,90.45 123.98,90.45 arc(124.05,90.46) 124.11,90.5 124.17,90.56 arc(124.22,90.64) 124.24,90.73 124.24,91.25 arc(124.21,91.33) 124.13,91.36 124.04,91.36 arc(123.97,91.33) 123.94,91.26 v9(123.94,91.11)
  BOTTOM w0.094: v11(138.17,121.92) R905.2
PCIE_REFCLK0_OUT_P: length 45.2
  L3-SIGNAL1 w0.079: v3(123.92,90.23) v5(124.14,90.51)
  L4-GND2 w0.089: v5(124.14,90.51) v7(124.45,90.82)
  L13-GND5 w0.089: v9(124.74,91.11) 124.66,91.03 v7(124.45,90.82)
  L14-SIGNAL6 w0.079: v11(137.03,121.92) 137.37,121.58 arc(137.45,121.46) 137.48,121.31 137.48,111.44 arc(137.45,111.31) 137.38,111.2 arc(137.29,111.06) 137.26,110.9 137.26,104.96 arc(137.2,104.67) 137.03,104.43 136.16,103.55 arc(135.88,103.37) 135.56,103.3 134.11,103.3 arc(133.68,103.22) 133.32,102.98 131.33,100.98 arc(131.18,100.77) 131.13,100.51 131.13,97.17 arc(131.06,96.78) 130.83,96.45 130.46,96.07 arc(130.14,95.86) 129.76,95.78 127.23,95.78 arc(126.92,95.72) 126.65,95.54 126.18,95.07 arc(125.99,94.78) 125.92,94.43 125.92,93.7 arc(125.88,93.53) 125.79,93.38 124.85,92.45 arc(124.69,92.34) 124.5,92.3 123.93,92.3 arc(123.65,92.25) 123.42,92.09 123.11,91.79 arc(122.99,91.6) 122.94,91.38 122.94,90.66 arc(122.97,90.52) 123.05,90.4 123.15,90.3 arc(123.25,90.23) 123.38,90.21 123.98,90.21 arc(124.14,90.24) 124.28,90.33 124.34,90.39 arc(124.45,90.55) 124.48,90.73 124.48,90.86 arc(124.56,91.03) v9(124.74,91.11)
  BOTTOM w0.094: v11(137.03,121.92) R906.2
PCIE_REFCLK1_OUT_N: length 60.9
  L3-SIGNAL1 w0.079: v3(123.92,91.03) v5(124.14,91.31)
  L4-GND2 w0.089: v5(124.14,91.31) v7(124.45,91.62)
  L10-SIGNAL4 w0.089: v2(138.93,134.19) 138.73,134.4 138.24,134.4 138.06,134.21 138.06,133.66 141.23,130.48 141.23,122.13 138.82,119.72 138.82,101.84 132.94,95.96 127.14,90.16 127.14,89.69 126.88,89.43 124.98,89.43 124.72,89.69 124.72,90.25 124.93,90.45 124.93,91.14 v7(124.45,91.62)
  BOTTOM w0.094: v2(138.93,134.19) 138.72,134.41 138.15,134.41 137.93,134.19 137.93,133.29 R859.2
PCIE_REFCLK1_OUT_P: length 60.9
  L3-SIGNAL1 w0.079: v3(124.72,91.03) v5(124.94,91.31)
  L4-GND2 w0.089: v5(124.94,91.31) v7(125.25,91.62)
  L10-SIGNAL4 w0.089: v2(138.93,134.9) 138.73,134.7 138.12,134.7 137.76,134.34 137.76,133.53 140.93,130.36 140.93,122.26 138.52,119.84 138.52,101.97 132.81,96.26 132.68,96.26 132.52,96.42 132.37,96.42 132.28,96.33 132.28,96.21 132.46,96.03 132.46,95.9 132.36,95.81 132.23,95.81 132.07,95.97 131.92,95.97 131.83,95.89 131.83,95.76 132.01,95.59 132.01,95.45 131.91,95.36 131.78,95.36 131.62,95.53 131.47,95.53 131.38,95.44 131.38,95.31 131.56,95.14 131.56,95 126.97,90.41 125.62,90.41 125.25,90.79 v7(125.25,91.62)
  BOTTOM w0.094: v2(138.93,134.9) 138.72,134.69 138.04,134.69 137.65,134.3 137.65,133.29 R860.2
PCIE_REFCLK2_OUT_N: length 32.3
  L3-SIGNAL1 w0.079: v3(125.52,90.23) v5(125.74,90.51)
  L4-GND2 w0.089: v5(125.74,90.51) v7(126.05,90.82)
  L10-SIGNAL4 w0.089: v4(136.18,117.15) 136.18,117.13 136.18,116.93 136.07,116.81 135.57,116.81 135.16,116.41 135.16,113.78 135.97,112.97 135.97,105.43 131.43,100.89 131.43,99.57 129.19,97.33 129.19,94.96 126.17,91.94 126.17,90.94 v7(126.05,90.82)
  vias: v1(125.52,90.23)
PCIE_REFCLK2_OUT_P: length 32.2
  L3-SIGNAL1 w0.079: v3(126.32,90.23) v5(126.54,90.51)
  L4-GND2 w0.089: v5(126.54,90.51) v7(126.85,90.82)
  L10-SIGNAL4 w0.089: v4(136.18,116) 136.18,116.4 136.07,116.51 135.69,116.51 135.46,116.29 135.46,113.91 136.27,113.1 136.27,105.3 131.73,100.76 131.73,99.45 129.49,97.21 129.49,94.84 126.47,91.82 126.47,90.91 126.56,90.82 v7(126.85,90.82)
  vias: v1(126.32,90.23)
PCIE_REFCLK3_OUT_N: length 38.5
  L3-SIGNAL1 w0.079: v3(121.52,91.03) v5(121.74,91.31)
  L4-GND2 w0.089: v5(121.74,91.31) v7(122.05,91.62)
  L10-SIGNAL4 w0.089: v7(122.05,91.62) 122.53,91.14 123.39,91.14 127.26,95 127.26,96.88 129.73,99.35 129.73,100.43 133.97,104.67 133.97,110.55 134.53,111.11 134.53,120.63 134.93,121.04 135.71,121.04 v2(136.18,120.57)
  vias: v1(121.52,91.03)
PCIE_REFCLK3_OUT_P: length 38.5
  L3-SIGNAL1 w0.079: v3(122.32,91.03) v5(122.54,91.31)
  L4-GND2 w0.089: v5(122.54,91.31) v7(122.85,91.62)
  L10-SIGNAL4 w0.089: v2(136.18,121.83) 135.69,121.34 134.81,121.34 134.23,120.76 134.23,111.23 133.67,110.68 133.67,104.8 129.43,100.56 129.43,99.47 126.96,97.01 126.96,96.52 126.87,96.43 126.72,96.43 126.63,96.34 126.63,96.21 126.72,96.11 126.87,96.11 126.96,96.02 126.96,95.89 126.87,95.8 126.72,95.8 126.63,95.7 126.63,95.57 126.72,95.48 126.87,95.48 126.96,95.38 126.96,95.13 123.27,91.44 123.03,91.44 v7(122.85,91.62)
  vias: v1(122.32,91.03)
PERIPH_RSTZ: length 436.6
  TOP w0.127: U132.1 53.84,24.45 53.7,24.32 v2(53.15,24.32) ; U43.24 48.16,114.66 48.29,114.79 48.29,115.48 v2(48.04,115.73) ; v2(133.52,159.32) 133.6,159.4 U18.1 ; v2(195.08,64.68) 195.08,65.21 194.92,65.37 U76.1
  L3-SIGNAL1 w0.089: v2(48.04,115.73) 48.04,119.88 50.55,122.39 50.55,125.32 51.29,126.05 57.89,126.05 81.72,149.88 86.32,149.88 104.19,167.75 104.19,168.58 104.69,169.07 108.91,169.07 109.75,168.23 109.75,165.49 111.42,163.81 116.73,163.81 116.94,163.6 123.2,163.6 123.86,164.26 130.56,164.26 133.97,167.66 138.4,167.66 139.95,169.22 147.11,169.22 147.45,168.87 154.63,168.87 156.39,170.63 156.39,171.73 v2(156.93,172.27)
  L12-SIGNAL5 w0.102: v2(195.08,64.68) 194.17,65.59 194.17,80.67 186.47,88.37 186.47,91.6 v2(181.95,96.12) 181.26,96.81 181.26,104.63 176.53,109.36 162.46,109.36 159.49,112.33 159.49,122.21 156.83,124.87 156.83,139.24 155.48,140.59 155.48,156.76 156.33,157.61 157.09,157.61 160.62,161.14 162.09,161.14 163.42,162.46 163.42,163.07 162.97,163.51 162.97,165.77 162.59,166.15 160.89,166.15 160.05,166.99 160.05,169.5 158.78,170.77 157.69,170.77 157.31,171.15 157.32,171.16 157.32,171.88 v2(156.93,172.27) ; v2(53.15,24.32) 52.24,24.32 49.13,27.43 49.13,32.16 44.52,36.77 44.52,39.66 v2(41.55,42.63) 38.09,46.1 38.09,77.89 38.54,78.34 38.54,79.46 37.78,80.22 37.78,104.83 45.09,112.15 45.09,114.64 45.55,115.09 47.4,115.09 v2(48.04,115.73)
  L14-SIGNAL6 w0.089: v2(133.52,159.32) 133.27,159.57 133.27,165.25 135.98,167.96 145.69,167.96 147.65,166 148.09,166 148.67,166.58 148.67,169.9 150.79,172.02 156.55,172.02 156.8,172.27 v2(156.93,172.27)
  BOTTOM w0.127: J56.28 v2(41.55,42.63) ; U173.28 157.41,171.79 v2(156.93,172.27) ; v2(181.95,96.12) R964.2 U213.2
PG_MCU_V2V5: length 12.2
  TOP w0.127: v2(119.32,23.2) 118.86,23.2 118.73,23.07 U138.3 ; v2(118.33,32.15) 118.33,31.8 118.05,31.51 U125.5
  L14-SIGNAL6 w0.089: v2(118.33,32.15) 118.33,25.01 119.32,24.02 v2(119.32,23.2)
PG_V1V2: length 2.1
  BOTTOM w0.127: U186.3 84.72,129.19 84.36,129.55 R875.2
PG_V2V5: length 2.1
  BOTTOM w0.127: U260.3 85.3,30.03 85.66,30.39 R1207.2
PHYIO_1V8_IN+: length 4.8
  BOTTOM w0.127: U192.D3 87.96,121.6 U193.10 89.92,121.6 89.95,121.57 C710.2 91.08,121.57 91.37,121.28 R910.1
PHYIO_1V8_IN-: length 6.4
  BOTTOM w0.127: R909.1 91.32,122.42 91.25,122.49 C710.1 90.43,122.31 90.13,122.31 ; U192.D1 87.56,122.8 ; 87.56,122.8 87.78,122.8 87.98,122.6 U193.8 89.84,122.6 90.13,122.31 ; 87.56,122.8 U192.D2 ; U193.9 89.92,122.1 90.13,122.31
PLL_1V8_IN+: length 4.8
  BOTTOM w0.127: R1036.1 68.62,77.86 68.51,77.97 C951.2 67.48,77.97 67.27,78.18 U226.10 65.3,78.18 U225.D3
PLL_1V8_IN-: length 6.3
  BOTTOM w0.127: 67.48,78.89 67.27,78.68 U226.9 ; 67.48,78.89 67.19,79.18 U226.8 65.32,79.18 65.12,79.38 64.9,79.38 ; 67.48,78.89 C951.1 68.55,78.89 68.66,79 R1031.1 ; 64.9,79.38 U225.D2 ; 64.9,79.38 U225.D1
PM1_SCL: length 531.5
  TOP w0.127: U114.A1 193.68,35.36 U115.5 195.6,35.36 v2(195.88,35.65) ; v2(199.47,76.66) 199.18,76.37 U65.5 197.26,76.37 U64.A1 ; v2(199.47,80.69) 199.18,80.4 U60.5 197.26,80.4 U61.A1 ; v2(14.28,165.3) 13.75,164.77 U19.2 ; U105.A1 193.68,39.55 U106.5 195.6,39.55 195.76,39.71 v2(195.88,39.71) 196.05,39.55 R1312.1 ; v2(195.88,33.86) U115.2 193.62,33.86 193.27,33.51 192.87,33.51 192.68,33.7 U114.B3 ; U119.A1 175.9,32.58 U118.5 175.9,30.66 v2(176.19,30.37)
  L3-SIGNAL1 w0.089: v2(195.88,33.86) 193.16,31.13 176.95,31.13 v2(176.19,30.37) ; v2(16.33,152.1) 16.33,151.02 v2(22,145.35) 21.4,144.74 21.4,142.77 20.76,142.14 12.53,142.14 11.08,140.69 11.08,139.17 10.55,138.63 8.72,138.63 8.12,139.23 v3(8.12,140.68) ; v2(69.28,111.38) 69.71,111.38 71.41,109.68 73.57,109.68 74.37,110.48 74.37,110.81 79.82,116.26 79.82,118.5 82.21,120.89 82.21,122 83.07,122.86 84.16,122.86 86.32,125.02 94.78,125.02 97.13,127.37 111.32,127.37 112.37,128.42 120.4,128.42 130.34,138.35 143.82,138.35 149,133.17 v2(159.04,133.17)
  L7-SIGNAL3 w0.109: v2(60.75,68.59) v2(60.75,70.5)
  L12-SIGNAL5 w0.102: v2(195.88,33.86) 195.31,34.43 195.31,35.08 195.88,35.65 v2(195.88,35.65) 195.45,36.08 195.45,39.41 195.76,39.71 v2(195.88,39.71) 195.88,39.84 195.45,40.27 195.45,42.11 196.6,43.27 196.6,53.39 199.5,56.29 199.5,61.57 200.15,62.21 200.15,72.68 198.76,74.07 198.76,75.96 v2(199.47,76.66) 198.92,77.21 198.92,80.14 v2(199.47,80.69) ; v2(198.97,104.75) 198.66,104.75 197.77,105.64 187.33,105.64 181.57,111.4 169.58,111.4 166.53,114.45 165.98,114.45 163.71,116.71 163.71,120.19 158.13,125.77 158.13,132.26 v2(159.04,133.17) ; v2(60.75,70.5) 60.75,73.38 60.13,74 60.13,76.27 63.4,79.54 63.4,83.4 62.96,83.83 62.96,93.18 68.68,98.9 68.68,110.78 v2(69.28,111.38)
  L14-SIGNAL6 w0.089: v2(232.95,21.06) 232.62,21.39 229.86,21.39 226.75,18.29 223.96,18.29 221.95,20.3 221.95,28.35 218.09,32.21 198.24,32.21 196.6,33.86 v2(195.88,33.86) ; v2(69.28,111.38) 69.4,111.5 69.4,117.45 67.93,118.92 67.93,122.91 64.7,126.14 63.28,126.14 62.89,125.75 56.41,125.75 56.19,125.53 v2(55.78,125.53) 54.39,125.53 52.01,123.15 49.04,123.15 48.72,123.46 48.49,123.7 47.81,123.7 47.48,124.03 47.48,124.8 46.95,125.33 46.68,125.6 36.15,125.6 33.24,128.52 22.83,128.52 17.28,134.07 17.28,140.3 18.71,141.73 21.1,141.73 22.28,142.91 22.28,145.07 v2(22,145.35) ; v2(14.28,165.3) 15.19,164.38 15.2,164.38 15.52,164.06 15.52,155.22 16.76,153.98 16.76,152.52 v2(16.33,152.1) ; v2(198.97,104.75) 202.42,101.3 202.42,84.02 201.82,83.42 201.82,83.05 199.47,80.69 v2(199.47,80.69)
  BOTTOM w0.127: v2(16.33,152.1) 15.83,151.6 J50.36 ; U207.A1 198.88,101.27 U208.5 198.88,102.85 199.47,103.44 199.47,104.25 v2(198.97,104.75) ; U231.A1 62.9,70.09 U232.5 61.16,70.09 v2(60.75,70.5) ; v2(60.75,68.59) U232.2 62.98,68.59 63.32,68.25 63.7,68.25 63.9,68.45 U231.B3 ; v2(55.78,125.53) 55.78,125.24 55.91,125.11 U189.5 57.94,125.11 U188.A1 ; U269.2 v2(232.95,21.06)
PM1_SCL_1: length 369.8
  TOP w0.127: v2(199.17,42.57) 198.66,42.57 197.28,41.19 R1312.2 ; 194.68,52.69 U83.5 194.68,52.69 ; 194.68,52.69 v3(195.88,52.69) ; 194.68,52.69 193.68,52.69 193.08,52.09 U84.A1
  L3-SIGNAL1 w0.089: v2(198.36,52.45) 198.12,52.69 v3(195.88,52.69) ; v2(83.86,124.15) 83.88,124.15 86.45,126.72 90.18,126.72 90.66,126.24 94.45,126.24 97.57,129.36 120.12,129.36 130,139.24 144.16,139.24 148.04,135.36 v2(151.09,135.36)
  L12-SIGNAL5 w0.102: v2(83.86,124.15) 83.88,124.15 83.88,124.13 82.86,124.13 82.66,123.93 82.66,123.39 83.93,122.12 83.93,119.74 83.73,119.53 v2(83.73,119) 82.38,117.65 80.86,117.65 79.36,116.15 77.66,116.15 76.23,114.73 71.79,114.73 71.28,114.22 69.81,114.22 68.11,112.52 68.11,99.09 62.52,93.5 62.52,83.64 62.95,83.21 62.95,81.53 61.91,80.49 v2(60.79,80.49) 60.28,79.98 60.28,78.33 v2(60.79,77.83) 59.57,76.6 59.57,71.42 59.11,70.97 59.11,69.82 60.1,68.83 60.1,66.17 v2(60.77,65.51) 61.07,65.21 61.07,63.85 v2(60.69,63.47) ; v2(161.84,121.15) 162.49,120.51 162.49,112.01 163.79,110.72 181.19,110.72 201.51,90.4 201.51,81.81 202.73,80.59 202.73,55.24 199.93,52.45 v2(198.36,52.45) 198.36,50.74 198.81,50.28 202.3,50.28 205.14,47.45 205.14,43.89 202.93,41.68 199.53,41.68 199.17,42.04 v2(199.17,42.57)
  BOTTOM w0.127: U225.C3 64.3,78.26 63.93,77.89 63.09,77.89 62.79,78.18 U226.1 61.15,78.18 v2(60.79,77.83) 60.79,75.92 61.11,75.6 U229.5 62.9,75.6 U230.A1 ; 83.88,124.13 83.88,123.83 84.11,123.6 U193.5 85.56,123.6 U192.A1 ; 83.88,124.13 83.02,124.13 82.58,123.7 82.58,122.1 83.08,121.6 U193.1 85.42,121.6 85.99,121.03 86.57,121.03 86.96,121.42 U192.C3 ; 83.88,124.13 83.88,124.15 v2(83.86,124.15) ; 83.73,118.87 83.4,118.54 83.4,118.29 83.35,118.24 83.35,117.57 83.85,117.07 U199.2 85.9,117.07 86.22,116.75 86.61,116.75 86.82,116.95 U198.B3 ; 83.73,118.87 84.03,118.57 U199.5 85.82,118.57 U198.A1 ; 83.73,118.87 v2(83.73,119) ; U194.A1 150.98,122.14 150.52,122.14 ; v2(151.09,135.36) 151.09,135.71 151.25,135.87 152.99,135.87 153.19,135.67 U184.5 153.19,133.19 U185.A1 ; v2(151.09,135.36) 151.19,135.26 U184.1 151.19,133.3 150.89,133.01 150.89,132.16 151.26,131.79 U185.C3 ; v2(151.09,135.36) 149.74,134.01 149.74,131.09 148.95,130.3 148.95,122.35 149.17,122.14 U195.5 150.52,122.14 ; v2(161.84,121.15) 161.84,121.24 161.41,121.67 161.41,121.71 159.44,123.67 152.05,123.67 150.52,122.14 ; U235.C3 64.3,63.34 63.93,62.97 63.09,62.97 62.79,63.27 U236.1 60.9,63.27 v2(60.69,63.47) 60.98,63.77 U236.2 62.98,63.77 63.29,63.46 63.71,63.46 63.9,63.65 U235.B3 ; v2(60.79,80.49) 61.1,80.18 U226.5 62.9,80.18 U225.A1 ; U235.A1 62.9,65.27 U236.5 61.01,65.27 v2(60.77,65.51)
PM1_SDA: length 537.8
  TOP w0.127: v2(175.4,30.37) U118.4 175.4,32.42 174.9,32.92 U119.A2 ; U119.B3 174.26,33.58 174.08,33.4 174.08,32.95 174.4,32.63 U118.2 v2(174.4,30.37) ; U114.A2 193.34,34.36 193.84,34.86 U115.4 v2(195.88,34.86) ; U61.A2 196.92,79.4 197.42,79.9 U60.4 v2(199.47,79.9) ; U19.5 11.8,164.66 11.99,164.85 v2(11.99,165.3) ; U105.A2 193.34,38.55 193.84,39.05 U106.4 195.76,39.05 v2(195.88,38.92) ; v2(199.47,75.87) U65.4 197.42,75.87 196.92,75.37 U64.A2
  L3-SIGNAL1 w0.089: v2(159.94,133.54) 159.72,133.76 148.73,133.76 143.91,138.57 130.25,138.57 120.32,128.64 97.96,128.64 94.56,125.23 86.13,125.23 83.98,123.08 82.95,123.08 82,122.12 82,120.98 79.6,118.58 79.6,116.35 74.16,110.9 74.16,110.57 73.48,109.89 71.6,109.89 v2(68.94,112.55) ; v2(16.33,153.1) 15.95,152.72 15.91,152.67 15.91,151.1 20.71,146.3 v2(20.71,145.22) 21.14,144.79 21.14,142.98 20.66,142.49 11.89,142.49 v3(10.07,140.68) ; v2(174.4,30.37) v2(175.4,30.37) 176.37,31.35 192.37,31.35 v2(195.88,34.86)
  L12-SIGNAL5 w0.102: v2(68.94,112.55) 68.33,111.93 68.33,98.99 62.74,93.4 62.74,83.73 63.17,83.3 63.17,79.63 59.79,76.25 59.79,73.77 60.38,73.18 60.38,71.35 v2(59.6,70.56) ; v2(198.87,106.15) 187.28,106.15 181.67,111.76 169.88,111.76 166.86,114.78 166.1,114.78 164.14,116.74 164.14,120.14 158.35,125.93 158.35,131.5 159.94,133.08 v2(159.94,133.54) ; v2(195.88,34.86) 196.3,35.27 196.3,38.45 195.88,38.87 v2(195.88,38.92) 195.88,39.05 196.83,40 196.83,53.11 199.75,56.03 199.75,61.26 201.05,62.56 201.05,74.4 199.58,75.87 v2(199.47,75.87) 199.96,76.36 199.96,79.41 v2(199.47,79.9)
  L14-SIGNAL6 w0.089: v2(198.87,106.15) 200.03,106.15 203.31,102.87 203.31,82.96 200.26,79.9 v2(199.47,79.9) ; v2(234.6,21.04) 234.05,21.59 229.44,21.59 226.43,18.58 224.94,18.58 223.51,20.01 223.15,20.01 222.28,20.88 222.28,28.32 218.19,32.42 198.32,32.42 196.68,34.06 v2(195.88,34.86) ; v2(16.33,153.1) 16.33,154.12 15.44,155.02 15.32,155.13 15.32,162.06 13.85,163.53 13.85,165.19 13.2,165.85 12.54,165.85 v2(11.99,165.3) ; v2(20.71,145.22) 21.34,144.58 21.34,142.99 20.39,142.04 18.73,142.04 16.37,139.67 16.37,134.7 22.89,128.18 33.22,128.18 36.03,125.37 46.63,125.37 46.75,125.25 47.28,124.72 47.28,123.5 47.91,122.87 50.17,122.87 50.83,122.2 51.58,122.2 53.99,124.61 v2(55.78,124.61) 56.45,124.61 57.08,125.25 63.08,125.25 63.71,125.88 64.6,125.88 67.67,122.81 67.67,118.69 68.94,117.42 v2(68.94,112.55)
  BOTTOM w0.127: v2(59.6,70.56) 59.84,70.32 R1311.1 59.86,69.59 U232.4 62.77,69.59 63.27,69.09 U231.A2 ; U188.A2 58.31,124.11 57.81,124.61 U189.4 v2(55.78,124.61) ; U207.B3 197.25,100.27 197.05,100.47 197.05,100.85 197.38,101.19 U208.2 197.38,103.65 197.9,104.17 197.9,105.56 198.48,106.15 v2(198.87,106.15) 198.38,105.67 U208.4 198.38,101.41 197.88,100.91 U207.A2 ; v2(234.6,21.04) 234.9,21.33 U269.5 ; J50.38 15.83,152.6 v2(16.33,153.1)
PM1_SDA_1: length 347.8
  TOP w0.127: v3(196.1,52.04) 195.95,52.19 194.68,52.19 ; v3(196.17,50.8) 196.06,50.69 U83.1 193.76,50.69 193.6,50.53 192.5,50.53 192.28,50.75 192.28,50.93 ; 192.28,50.93 192.36,50.84 192.57,50.84 192.68,50.94 U84.B3 ; 192.28,50.93 U84.C3 ; 194.68,52.19 U83.4 194.68,52.19 ; 194.68,52.19 193.84,52.19 193.34,51.69 U84.A2
  L3-SIGNAL1 w0.089: v2(152.48,135.41) 151.93,134.85 148.24,134.85 144.09,139 130.07,139 120.17,129.11 97.7,129.11 94.26,125.67 85.95,125.67 83.98,123.7 v2(83.19,123.7) ; v2(83.68,116.38) 83.77,116.47 v2(83.77,118.07) ; v3(196.1,52.04) 196.1,50.88 v3(196.17,50.8) 198.87,50.8 v2(198.98,50.69)
  L12-SIGNAL5 w0.102: v2(83.19,123.7) 83.19,123.37 84.29,122.28 84.29,118.59 v2(83.77,118.07) 81.14,115.44 77.98,115.44 75.16,112.62 71.31,112.62 68.99,110.31 68.99,98.83 63.2,93.04 63.2,84.02 63.66,83.57 63.66,78.43 v2(60.61,75.39) ; v2(163.23,119.96) 163.44,119.76 163.44,111.73 164.09,111.07 181.29,111.07 201.81,90.55 201.81,82.09 202.98,80.92 202.98,54.69 v2(198.98,50.69)
  L14-SIGNAL6 w0.089: v2(152.48,135.41) 152.74,135.15 152.74,124.51 151,122.77 149.34,122.77 v2(148.45,121.88)
  BOTTOM w0.127: U225.A2 63.27,79.18 62.77,79.68 U226.4 60.36,79.68 60.05,79.38 60.05,75.95 v2(60.61,75.39) ; U185.B3 151.56,132.19 151.34,132.41 151.34,132.76 151.69,133.11 U184.2 151.69,135.25 151.85,135.41 v2(152.48,135.41) 152.69,135.2 U184.4 152.69,133.33 152.19,132.83 U185.A2 ; U230.A2 63.26,74.6 62.76,75.1 U229.4 60.9,75.1 v2(60.61,75.39) ; U198.C3 87.22,116.64 86.85,116.27 86,116.27 85.7,116.57 U199.1 83.86,116.57 v2(83.68,116.38) ; v2(83.19,123.7) 83.19,123.37 83.46,123.1 U193.4 85.43,123.1 85.93,122.6 U192.A2 ; 148.22,120.37 148.22,121.65 v2(148.45,121.88) 148.45,121.89 148.55,121.89 148.8,121.64 U195.4 150.85,121.64 151.35,121.14 U194.A2 ; 148.22,120.37 148.45,120.14 U195.1 150.87,120.14 151.17,119.84 152.01,119.84 152.38,120.21 U194.C3 ; 148.22,120.37 148.22,120.02 149.51,118.72 160.38,118.72 161.55,119.89 163.15,119.89 v2(163.23,119.96) ; v2(83.77,118.07) U199.4 85.68,118.07 86.18,117.57 U198.A2 ; v2(60.61,75.39) 60.13,74.9 60.13,73.86 60.39,73.6 U229.1 62.79,73.6 63.08,73.3 63.93,73.3 64.3,73.67 U230.C3 ; v2(60.61,75.39) 59.93,75.39 58.59,74.05 58.59,69.98 R1311.2 59.98,68.59 59.98,65.45 60.66,64.77 U236.4 62.77,64.77 63.27,64.27 U235.A2
PM2_SCL: length 556.8
  TOP w0.127: U93.A1 193.68,47.93 U94.5 195.72,47.93 v2(195.88,48.09) ; U57.A1 197.26,84.43 197.36,84.43 ; v2(180.5,30.37) 180.21,30.66 U120.5 180.21,32.58 U121.A1 ; v2(156.13,24.71) 155.84,25 U128.5 155.84,26.92 U129.A1 ; v2(171.87,30.37) 171.58,30.66 U117.5 171.58,32.58 U116.A1 ; U116.B3 169.92,33.58 169.73,33.39 169.73,32.98 170.08,32.63 U117.2 v2(170.08,30.37) ; U19.3 13.1,165.26 v2(13.13,165.3) ; U129.B3 154.2,27.92 154.02,27.74 154.02,27.29 154.34,26.97 U128.2 v2(154.34,24.71) ; 197.36,84.43 v2(196.43,85.37) ; 197.36,84.43 U56.5
  L3-SIGNAL1 w0.089: v2(180.5,30.37) 180.04,30.83 177.25,30.83 176.24,29.82 172.42,29.82 v2(171.87,30.37) 171.39,30.85 170.55,30.85 v2(170.08,30.37) ; v2(19.8,144.13) 13.07,144.13 v3(10.72,146.48) 11.54,147.3 11.54,148.74 14.9,152.1 v2(15.42,152.1)
  L5-SIGNAL2 w0.102: v2(170.08,30.37) 170.08,29.83 169.11,28.87 169.11,27.29 166.54,24.71 v2(156.13,24.71) 155.51,25.33 155.02,25.33 154.41,24.71 v2(154.34,24.71)
  L12-SIGNAL5 w0.102: v2(64.2,107.63) 60.75,104.18 v2(60.75,95.74) 60.75,95.63 61.37,95 61.37,91.32 v2(60.75,90.69) ; v2(56.02,57.2) 56.02,53.33 58.02,51.33 59.11,51.33 62.43,48.02 62.43,44.62 64.83,42.21 68.31,42.21 75.36,35.16 75.36,33.94 78.74,30.55 78.74,29.65 79.97,28.42 80.44,28.42 82.09,26.78 82.09,25.45 83.46,24.08 84.23,24.08 95.16,13.15 112.27,13.15 116.17,9.25 171.56,9.25 178.35,16.04 183.12,16.04 183.31,15.85 197.83,15.85 198.8,16.81 203.89,16.81 205.39,18.31 v2(205.39,19.41) ; v2(196.43,85.37) 197.8,84 197.8,74.04 199.5,72.34 199.5,64.11 198.15,62.76 198.15,55.66 195.88,53.39 v2(195.88,48.09) 193.25,45.46 193.25,34.65 189.95,31.34 179.56,31.34 179.23,31.01 179.23,30.02 179.56,29.69 180.17,29.69 180.5,30.02 v2(180.5,30.37)
  L14-SIGNAL6 w0.089: v2(56.02,57.2) 56.6,57.77 57.18,57.77 57.71,58.3 59.31,58.3 61.2,60.19 61.2,71.42 59.91,72.71 59.91,89.86 v2(60.75,90.69) ; v2(15.42,152.1) 15.85,152.52 15.85,153.27 15.59,153.53 15.31,153.53 13.94,154.9 13.94,162.78 13.14,163.58 13.14,165.29 v2(13.13,165.3) ; v2(64.2,107.63) 64.2,109.79 61.63,112.36 61.63,119.51 60.4,120.74 53.29,120.74 52.23,121.8 50.67,121.8 50.03,122.44 47.58,122.44 46.87,123.14 46.87,124.55 46.46,124.96 35.86,124.96 33.09,127.74 22.65,127.74 15.96,134.43 15.96,140.29 v2(19.8,144.13) ; v2(233.6,17.64) 233.6,18.73 232.06,20.27 229.65,20.27 227.37,17.99 223.64,17.99 223.43,17.78 207.73,17.78 206.1,19.41 v2(205.39,19.41) 204.39,19.41 194.95,28.84 194.95,46.38 195.4,46.83 196.05,46.83 196.38,47.16 196.38,47.73 196.01,48.09 v2(195.88,48.09)
  BOTTOM w0.127: U219.A1 62.9,90.28 U218.5 60.88,90.28 60.75,90.41 v2(60.75,90.69) ; U243.29 v2(56.02,57.2) ; J50.37 v2(15.42,152.1) ; R1314.1 v2(196.43,85.37) ; U204.A1 64.62,109.79 U203.5 64.62,107.76 64.49,107.63 v2(64.2,107.63) ; v2(60.75,95.74) 60.75,95.45 60.88,95.33 U215.5 62.9,95.33 U214.A1 ; U269.12 v2(233.6,17.64)
PM2_SCL_1: length 480.5
  TOP w0.127: U32.2 203.67,139.15 v2(204.12,139.6) 204.17,139.55 U32.1 204.17,136.32 203.99,136.14 203.77,136.14 ; v2(195.66,44.42) 194.98,44.42 194.68,44.12 U100.5 193.68,43.74 U99.A1 ; v2(201.74,139.52) 202.17,139.08 U32.5 202.17,137.34 U31.A1 ; 203.77,136.14 U31.C3 ; 203.77,136.14 U31.B3 ; U99.C3 192.28,41.8 192.59,41.49 193.51,41.49 193.76,41.74 U100.1 v2(195.94,41.74)
  L3-SIGNAL1 w0.089: v2(163.84,134.16) 148.62,134.16 144,138.79 130.16,138.79 120.23,128.85 97.87,128.85 94.47,125.45 86.05,125.45 83.89,123.29 82.86,123.29 81.78,122.21 81.78,121.1 79.38,118.69 79.38,116.46 73.94,111.02 73.94,110.66 73.59,110.31 71.74,110.31 70.16,111.89 70.16,112.01 69.12,113.06 67.95,113.06 67.39,112.5 v2(67.39,111.71) ; v2(204.12,139.6) 204.05,139.52 v2(201.74,139.52)
  L12-SIGNAL5 w0.102: v2(195.66,44.42) 196.35,45.11 196.35,53.45 199.09,56.2 199.09,63.09 199.83,63.83 199.83,72.52 198.38,73.96 198.38,81.05 199.28,81.95 v2(199.42,81.95) 198.27,83.11 v2(198.27,86.09) ; v2(60.84,85.45) 60.84,88.34 62.19,89.68 62.19,93.57 67.72,99.11 67.72,111.38 v2(67.39,111.71) ; v2(191.09,173.63) 191.09,169.19 197.11,163.17 197.11,153.03 197.09,153.01 197.09,146.63 v2(204.12,139.6) 205.72,138 205.72,124.64 200.92,119.84 200.92,105.13 199.7,103.91 198.13,103.91 v2(197.32,104.72) ; v2(201.74,139.52) 200.21,139.52 192.01,131.32 171.33,131.32 169.1,133.55 164.45,133.55 v2(163.84,134.16)
  L14-SIGNAL6 w0.089: v2(198.27,86.09) 197.04,87.32 197.04,104.45 v2(197.32,104.72) 197.32,105.61 198.33,106.63 200.82,106.63 212.68,94.77 223.18,94.77 v2(237.09,80.85) v2(237.09,79.5) 236.1,80.49 229.98,80.49 229.04,79.55 229.04,74.22 237.4,65.86 v2(237.4,60.27) ; v2(195.94,41.74) 195.94,44.15 v2(195.66,44.42)
  BOTTOM w0.127: v2(60.84,85.45) 61.06,85.23 U221.5 62.9,85.23 U222.A1 ; U223.A1 234.97,79.5 U224.5 v2(237.09,79.5) ; U210.A1 194.05,101.02 U209.5 194.05,103.85 194.93,104.72 v2(197.32,104.72) ; U171.C3 188.57,169.85 188.2,170.22 188.2,171.06 188.5,171.36 U172.1 188.5,173.78 188.78,174.07 190.66,174.07 v2(191.09,173.63) 190.5,173.04 U172.5 190.5,171.25 U171.A1 ; v2(199.42,81.95) 199.42,81.95 U212.5 197.26,81.95 U211.A1 ; v2(237.4,60.27) 237.8,60.68 U239.5 237.8,62.45 U238.A1 ; U211.C3 195.74,83.47 195.74,84.73 195.96,84.95 196.87,84.95 197.87,83.95 U212.1 198.89,83.95 199.04,84.1 199.04,85.24 198.92,85.37 R1314.2 v2(198.27,86.09) ; U223.B3 233.95,81.12 234.15,81.31 234.68,81.31 234.99,81 U224.2 236.94,81 v2(237.09,80.85)
PM2_SDA: length 583.9
  TOP w0.127: v2(10.85,165.3) 11.15,164.99 U19.6 ; v2(178.71,30.37) U120.2 178.71,32.63 178.37,32.98 178.37,33.39 178.55,33.58 U121.B3 ; U93.A2 193.34,46.93 193.84,47.43 U94.4 194.8,47.3 v2(195.88,47.3) ; U129.A2 154.84,27.26 155.34,26.76 U128.4 v2(155.34,24.71) ; U57.A2 196.87,83.43 197.37,83.93 U56.4 v2(199.44,83.93) ; v2(179.71,30.37) U120.4 179.71,32.42 179.21,32.92 U121.A2 ; v2(171.08,30.37) U117.4 171.08,32.42 170.58,32.92 U116.A2
  L3-SIGNAL1 w0.089: v2(15.42,153.1) 11.18,148.86 11.18,148.36 9.97,147.14 9.43,147.14 v3(8.77,146.48) 11.55,143.7 20.26,143.7 v2(20.68,144.13) ; v2(195.88,47.3) 195.73,47.3 195.39,47.65 195.39,49.48 196.02,50.11 206.63,50.11 206.73,50.02 207.31,50.02 207.68,50.39 207.68,51.54 206.08,53.14 206.08,59.41 205.42,60.07 205.42,64.54 204.43,65.53 200.95,65.53 198.94,67.54 198.94,71.53 197.7,72.77 194.45,72.77 191.42,75.79 191.42,78.77 191.91,79.25 194.75,79.25 198.38,82.88 v2(199.44,83.93) ; v2(171.08,30.37) 171.85,29.6 177.95,29.6 v2(178.71,30.37) v2(179.71,30.37)
  L5-SIGNAL2 w0.102: v2(171.08,30.37) 171.08,28.83 166.53,24.28 155.77,24.28 v2(155.34,24.71)
  L12-SIGNAL5 w0.102: v2(57.04,57.2) 57.04,52.7 58.18,51.56 59.32,51.56 62.75,48.13 62.75,44.73 64.98,42.49 68.95,42.49 76.65,34.79 76.65,34.08 80.71,30.02 80.71,28.99 82.66,27.04 82.66,26.14 93.34,15.46 110.28,15.46 116.27,9.47 171.47,9.47 178.31,16.31 182.05,16.31 182.74,17 188.15,17 188.34,17.19 202.94,17.19 v2(204.68,18.93) ; v2(60.75,94.83) 60.28,95.29 60.28,105.41 62.98,108.1 64.65,108.1 v2(65.12,107.63) ; v2(179.71,30.37) 180.26,30.91 190.86,30.91 194.01,34.06 194.01,45.43 v2(195.88,47.3)
  L14-SIGNAL6 w0.089: v2(235.55,15.25) 233.94,15.25 231.73,17.45 231.73,19.3 231.19,19.85 229.99,19.85 227.24,17.09 223.38,17.09 223.15,17.32 219.24,17.32 218.73,16.81 215.1,16.81 214.51,17.4 207.53,17.4 206,18.93 v2(204.68,18.93) 204.59,19.02 204.46,19.02 194.5,28.99 194.5,46.56 195.24,47.3 v2(195.88,47.3) ; v2(20.68,144.13) 20.98,143.83 20.98,142.91 20.4,142.33 18.69,142.33 16.16,139.8 16.16,134.61 22.8,127.97 33.14,127.97 35.95,125.17 46.54,125.17 46.81,124.9 47.08,124.63 47.08,123.41 47.2,123.29 47.84,122.65 50.1,122.65 50.75,122 52.32,122 53.2,121.12 53.37,120.94 60.73,120.94 61.94,119.73 61.94,113.93 62.52,113.36 62.52,112.67 65.12,110.08 v2(65.12,107.63) ; v2(10.85,165.3) 13.65,162.5 13.65,154.87 v2(15.42,153.1) ; v2(57.04,57.2) 57.85,58.01 59.42,58.01 61.4,59.98 61.4,71.5 60.21,72.7 60.21,82.12 61.27,83.18 61.27,89.25 v2(60.75,89.78)
  BOTTOM w0.127: v2(65.12,107.63) U203.4 65.12,109.66 65.62,110.16 U204.A2 ; v2(60.75,94.83) U215.4 62.77,94.83 63.27,94.33 U214.A2 ; v2(60.75,94.83) 60.07,94.15 R1313.1 60.68,89.71 v2(60.75,89.78) U218.4 62.77,89.78 63.27,89.28 U219.A2 ; v2(60.75,94.83) 60.75,94.1 61.02,93.83 U215.2 62.88,93.83 63.23,93.48 63.7,93.48 63.9,93.68 U214.B3 ; J50.39 v2(15.42,153.1) ; U269.9 v2(235.55,15.25) ; U243.30 56.22,56.7 56.72,57.2 v2(57.04,57.2)
PM2_SDA_1: length 489.4
  TOP w0.127: U99.B3 192.68,42.08 192.86,41.89 193.28,41.89 193.62,42.24 U100.2 196.15,42.24 196.32,42.41 v3(196.32,42.5) ; v2(202.67,139.93) U32.4 202.67,137.5 203.17,137 U31.A2 ; v3(196.32,43.24) U100.4 193.84,43.24 193.34,42.74 U99.A2
  L3-SIGNAL1 w0.089: v3(196.32,42.5) v3(196.32,43.24) v2(198.66,43.24) ; v2(168.95,132.83) 159.46,132.83 159.27,132.64 149.03,132.64 143.57,138.1 130.41,138.1 120.52,128.21 112.49,128.21 111.44,127.15 97.29,127.15 94.93,124.79 86.47,124.79 84.31,122.63 83.24,122.63 82.53,121.92 82.53,120.85 80.12,118.44 80.12,116.26 77.2,113.34 77.2,109.17 76.33,108.31 69.2,108.31 67.83,109.68 v2(67.29,109.68)
  L12-SIGNAL5 w0.102: 202.67,139.88 193.53,130.73 171.2,130.73 169.11,132.83 v2(168.95,132.83) ; 202.67,139.88 v2(202.67,139.93) 196.33,146.28 196.33,163.47 190.2,169.6 v2(190.2,173.61) ; 202.67,139.88 205.27,137.29 205.27,124.82 200.49,120.04 200.49,105.31 199.5,104.32 198.48,104.32 197.62,105.18 193.58,105.18 v2(191.6,103.2) 191.6,101.24 202.22,90.63 v2(202.22,82.88) 221.62,82.88 222.98,81.53 v2(237.49,81.53) 237.73,81.29 237.73,78.44 239.8,76.36 v2(239.8,60.18) ; v2(59.23,90.46) 59.23,92.32 60.03,93.12 60.03,106.67 63.04,109.68 67.29,109.68 v2(67.29,109.68)
  L14-SIGNAL6 w0.089: v2(239.8,60.18) 230.16,50.54 230.16,39.45 224.87,34.16 205.49,34.16 199.49,40.16 199.49,41.21 198.66,42.04 v2(198.66,43.24)
  BOTTOM w0.127: U222.C3 64.3,83.31 63.93,82.93 63.09,82.93 62.79,83.23 U221.1 60.52,83.23 60.21,83.54 60.21,84 60.94,84.73 ; U238.B3 239.44,63.45 239.64,63.24 239.64,62.86 239.3,62.53 U239.2 239.3,60.68 239.71,60.27 ; 60.94,84.73 60,85.67 60,88.42 59.23,89.19 R1313.2 v2(59.23,90.46) ; 60.94,84.73 U221.4 62.77,84.73 63.27,84.23 U222.A2 ; U171.A2 189.5,170.88 190,171.38 U172.4 190,173.4 v2(190.2,173.61) ; 237.48,81.53 237.47,81.53 237.47,81.5 237.51,81.5 237.51,80.36 237.16,80 U224.4 235.15,80 234.64,80.52 U223.A2 ; 237.48,81.53 237.48,81.54 237.46,81.54 237.46,81.5 U224.1 234.95,81.5 234.81,81.64 233.92,81.64 233.55,81.28 U223.C3 ; 237.48,81.53 v2(237.49,81.53) ; 239.71,60.27 238.49,60.27 238.3,60.46 U239.4 238.3,62.31 238.8,62.81 U238.A2 ; 239.71,60.27 v2(239.8,60.18) U239.1 239.8,62.33 240.1,62.63 240.1,63.47 239.73,63.85 U238.C3 ; U210.A2 193.05,100.65 193.55,101.15 U209.4 193.55,103.51 193.38,103.68 192.08,103.68 v2(191.6,103.2) 191.88,103.2 192.05,103.03 U209.1 192.05,101.13 191.75,100.83 191.75,99.99 192.12,99.62 U210.C3 ; U211.A2 196.89,82.95 197.39,82.45 U212.4 201.79,82.45 v2(202.22,82.88)
PM_I2C_OE#: length 4.6
  TOP w0.127: U19.15 13.75,156.71 R116.2 11.33,156.24 11.08,155.99 Q1.3
PM_I2C_SEL: length 235.7
  TOP w0.127: R64.2 15.42,165.23 14.4,164.21 U19.1
  L3-SIGNAL1 w0.089: v2(108.82,40.72) 98.71,40.72 93.87,45.56 78.73,45.56 74.74,49.56 70.67,49.56 67.24,52.98 64.85,52.98 v2(64.56,52.69) ; v2(109.43,47.35) 110.85,47.35 120.72,57.21 v3(120.72,68.63)
  L7-SIGNAL3 w0.109: v2(109.43,47.35) 109.43,41.33 v2(108.82,40.72)
  L12-SIGNAL5 w0.102: v2(64.56,52.69) 62.36,54.89 60.93,54.89 55.38,60.44 52.44,60.44 49.28,63.6 49.28,69.68 48.87,70.08 48.87,83.74 49.26,84.13 49.26,108.1 49.77,108.61 49.77,110.64 49.31,111.1 49.31,111.65 49.55,111.89 49.73,111.89 51.15,113.31 51.15,117.31 48.92,119.54 48.92,121.99 47.46,123.45 47.46,125.64 42.04,131.06 42.04,132.56 41.02,133.58 41.02,137.07 40.01,138.08 40.01,139.44 39.21,140.24 20.64,140.24 16.92,143.96 16.92,145.91 18.96,147.94 18.96,161.77 v2(15.44,165.29)
  vias: v1(120.72,68.63)
PM_OE#: length 28.2
  TOP w0.127: v2(230.53,34.75) Q2.3
  L14-SIGNAL6 w0.089: v2(230.53,34.75) 232.3,32.98 v2(232.3,23.48)
  BOTTOM w0.127: U269.4 234.25,23.22 233.99,23.48 v2(232.3,23.48) U269.1 232.3,18.16 232.95,17.51 U269.13 232.95,15.46 233.13,15.27 234.7,15.27 234.9,15.47 U269.10
PMIC_ENABLE: length 81
  L3-SIGNAL1 w0.089: v3(175.33,70.07) 180.87,70.07 184.69,66.25 v2(185.61,66.25)
  L14-SIGNAL6 w0.089: v2(185.61,66.25) 186.35,65.51 186.35,62.96 189.09,60.22 189.09,54.64 189.95,53.77 191.55,53.77 197.34,47.98 197.34,40.84 198.16,40.03 198.87,40.03 206.05,32.84 218.5,32.84 224.82,26.52 224.82,24.43 v2(225.65,23.6)
  BOTTOM w0.127: U268.9 v2(225.65,23.6)
PMIC_GPIO3: length 1.5
  TOP w0.127: U68.46 v2(177.83,77.3)
  BOTTOM w0.127: R1035.2 v2(177.83,77.3)
PMIC_GPIO4: length 1.2
  TOP w0.127: v2(177.79,79.13) 177.33,78.67 U68.47
PMIC_GPIO7: length 1.5
  TOP w0.127: v2(174.43,69.25) 174.33,69.35 U68.18
  BOTTOM w0.127: R1081.2 v2(174.43,69.25)
PMIC_GPIO8: length 5.1
  TOP w0.127: R398.2 182.87,78.57 181.44,77.13 180.84,77.13 180.53,76.82 U68.41
PMIC_POWER_EN1: length 173.7
  L3-SIGNAL1 w0.089: v2(108.67,46.56) 110.75,46.56 121.42,57.23 121.42,68.28 121.21,68.48 121.21,69.13 v3(121.52,69.43)
  L12-SIGNAL5 w0.102: v2(197.54,71.66) 197.54,68.23 196.3,66.98 196.3,65.18 192.74,61.62 191.3,61.62 188.53,58.85 188.53,58.17 183.83,53.47 183.83,43.71 178.62,38.51 178.62,37.59 172.55,31.52 172.55,30.35 171.79,29.59 166.28,29.59 164.8,28.11 157.79,28.11 155.74,26.06 149.69,26.06 146.85,23.22 131.81,23.22 131.45,23.57 120.56,23.57 120.4,23.72 118.98,23.72 118.52,24.18 117.79,24.18 117.13,23.52 113.27,23.52 111.82,24.97 111.82,26.62 v2(111.69,26.75)
  L14-SIGNAL6 w0.089: v2(111.69,26.75) 111.41,27.03 111.41,31.9 109.99,33.33 109.2,33.33 108.75,33.78 108.75,34.11 107.27,35.59 107.27,45.16 v2(108.67,46.56)
  BOTTOM w0.127: v2(197.54,71.66) 198.81,71.66 199.08,71.39 R1061.2
  vias: v1(121.52,69.43)
PMIC_WDOG_DISABLE: length 113.8
  TOP w0.127: v2(186.17,78.39) 185.98,78.57 R398.1 ; SW16.4 228.13,18.52 225.79,18.52 v2(225.31,19.01)
  L3-SIGNAL1 w0.089: v2(186.17,78.39) 187.8,80.03 190.26,80.03 190.74,79.55 190.74,75.34 195.17,70.9 v2(198.24,70.9)
  L14-SIGNAL6 w0.089: v2(198.24,70.9) 196.17,68.83 191.67,68.83 190.65,67.82 186.24,67.82 185.17,66.75 185.17,63.45 188.73,59.89 188.73,54.56 189.8,53.49 191.35,53.49 197.11,47.73 197.11,40.12 198.74,38.49 200.02,38.49 205.87,32.64 218.34,32.64 224.61,26.38 224.61,20.34 225.31,19.64 v2(225.31,19.01)
  BOTTOM w0.127: v2(198.24,70.9) R1079.2 R1089.2
PORZ: length 142
  TOP w0.127: v2(85,36.63) 84.53,37.11 83.72,37.11 83.52,36.91 U110.3
  L3-SIGNAL1 w0.089: v2(16.57,45.15) 16.57,44.26 22.63,38.2 45.04,38.2 46.34,39.5 48.78,39.5 51.43,36.85 62.43,36.85 63.79,38.22 75.35,38.22 77.36,36.21 84.57,36.21 v2(85,36.63) ; v3(115.12,71.03) v5(114.89,70.75)
  L4-GND2 w0.102: v5(114.89,70.75) v6(114.58,70.45)
  L5-SIGNAL2 w0.102: v6(114.58,70.45) 114.58,70.03 112.53,67.98 112.53,66.14 108.85,62.46 v2(108.39,62.46) ; v2(109.99,36.96) 109.13,37.82 86.18,37.82 v2(85,36.63)
  L14-SIGNAL6 w0.089: v2(109.99,36.96) 110.37,37.34 110.37,58.32 109.25,59.44 109.25,61.6 v2(108.39,62.46)
  BOTTOM w0.127: U252.4 v2(16.57,45.15)
  vias: v1(115.12,71.03)
PORZ_3V3: length 3.6
  TOP w0.127: v2(81.23,37.96) 80.88,37.96 80.76,37.83 80.76,37.07 80.92,36.91 U110.4
  BOTTOM w0.127: U254.1 v2(81.23,37.96)
PORZ_OE: length 1.4
  TOP w0.127: R584.2 80.59,36.41 U110.5
R_CAN_STB: length 5.2
  BOTTOM w0.127: R788.2 164.09,167.32 164.09,166.18 R794.2 163.55,166.18 163.42,166.31 R792.2 162.22,166.31 162.06,166.15 U173.8
R_CAN_WKUP: length 2.6
  TOP w0.127: R658.1 R659.2 U137.1
R_CSI2_RSTZ_DV: length 2.2
  TOP w0.127: U80.7 196.75,59.7 R471.2
R_DP1_HPD: length 46.5
  L7-SIGNAL3 w0.109: v2(102.11,133.28) 100.75,134.64 100.75,140.29 104.58,144.12 104.58,151.99 105.65,153.06 105.65,163.57 99.78,169.44 v2(97.77,169.44)
  BOTTOM w0.127: R776.1 97.77,170.42 v2(97.77,169.44) ; v2(102.11,133.28) 101.57,132.74 U187.32
R_GPIO_RGMII1_RST#: length 3.1
  BOTTOM w0.127: R777.2 R778.2 160.68,169.65 U173.1
R_MCAN3_RX: length 1.7
  TOP w0.127: U148.4 R677.2
R_MCAN3_WAKE: length 2.3
  TOP w0.127: U148.9 116.52,8.68 115.5,7.66 R723.2
R_MCAN4_RX: length 24.2
  TOP w0.127: v2(45.77,104.33) 45.52,104.08 U50.37
  L5-SIGNAL2 w0.102: v2(45.77,104.33) 46.2,103.9 46.2,103.15 45.95,102.9 45.59,102.9 44.2,104.29 44.2,106.05 43.49,106.76 40.88,106.76 39.85,105.73 36.5,105.73 30.75,99.98 v2(30.75,99.45)
R_MCAN4_RXD: length 1.8
  TOP w0.127: U152.4 R682.2
R_MCAN4_TX: length 19.6
  TOP w0.127: U50.40 43.56,102.58 v2(43.31,102.33)
  L5-SIGNAL2 w0.102: v2(30.75,97.92) 31.16,97.92 36.87,103.64 41.77,103.64 42.89,104.76 43.49,104.76 43.74,104.51 43.74,102.76 v2(43.31,102.33)
R_MCAN5_RXD: length 1.8
  TOP w0.127: U151.4 R681.2
R_MCAN16_RXD: length 1.8
  TOP w0.127: U153.4 R683.2
R_MCU_ADC0_REF_N: length 115.2
  L3-SIGNAL1 w0.089: v2(114.08,55.86) 114.08,55.52 111.27,52.72 105.8,52.72 103.26,55.26 73.36,55.26 72.54,56.08 58.54,56.08 55.93,53.47 50.17,53.47 49.55,52.84 37.17,52.84 34.61,50.28 18.39,50.28 16.78,51.89 16.78,52.76 17.52,53.5 19,53.5 J27.12
  BOTTOM w0.127: R1039.2 113.77,61.32 113.77,56.62 114.08,56.31 v2(114.08,55.86)
R_MCU_ADC0_REF_P: length 115.7
  L3-SIGNAL1 w0.089: J27.10 16.57,53.6 16.57,51.8 18.3,50.07 34.73,50.07 37.09,52.43 55.43,52.43 58.87,55.87 72.41,55.87 73.26,55.02 103.16,55.02 105.67,52.5 111.43,52.5 114.69,55.76 v2(114.69,56.21)
  BOTTOM w0.127: R1049.2 115.36,62.41 114.16,61.21 114.16,56.74 v2(114.69,56.21)
R_MCU_ADC1_AIN5: length 50.1
  TOP w0.127: R385.1 72.11,80.05 v3(72.11,80.04)
  L3-SIGNAL1 w0.089: v3(72.11,80.04) 72.9,80.04 74.89,78.06 74.89,77.65 75.78,76.76 75.78,74.99 78,72.76 78.89,72.76 81.52,70.13 84.63,70.13 90.98,63.78 108.1,63.78 108.62,64.3 108.62,68.54 v3(108.72,68.63)
  vias: v1(108.72,68.63)
R_MCU_ADC1_AIN6: length 51.1
  TOP w0.127: R392.1 74.55,78.68 74.55,78.67 74.55,78.09 v3(74.3,77.85)
  L3-SIGNAL1 w0.089: v3(110.32,68.63) 110.32,68.19 109.08,66.95 109.08,64.15 108.27,63.35 90.8,63.35 87.43,66.73 83.66,66.73 82.21,68.17 81.84,68.17 81.29,68.72 81.29,69.13 78.09,72.33 75.19,72.33 74.3,73.22 v3(74.3,77.85)
  vias: v1(110.32,68.63)
R_MCU_ADC1_AIN7: length 63
  TOP w0.127: R379.1 70.07,81.06 v3(70.07,81.06)
  L3-SIGNAL1 w0.089: v5(111.64,66.5) 111.92,66.77 v3(111.92,70.23) ; v3(70.07,81.06) v5(70.38,81.37)
  L4-GND2 w0.102: v5(70.38,81.37) v7(70.65,81.05) ; v5(111.64,66.5) v7(111.34,66.19)
  L10-SIGNAL4 w0.109: v7(70.65,81.05) 70.65,72.34 74.41,68.58 74.42,68.58 74.53,68.47 74.53,65.41 75.85,64.08 83.09,64.08 84.77,62.41 107.55,62.41 v7(111.34,66.19)
  vias: v1(111.92,70.23)
R_MCU_ADC_EXT_TRIGGER: length 127.1
  L3-SIGNAL1 w0.089: v5(94.7,54.25) 94.94,54.49 100.48,54.49 105.49,49.48 108.82,49.48 109.09,49.21 111.29,49.21 119.57,57.48 119.57,69.08 v3(119.92,69.43) ; v2(31.03,65.88) 31.03,66.87 31.17,67 31.17,71.13 34.88,74.84 38.97,74.84 v2(39.28,75.14)
  L4-GND2 w0.102: v5(94.7,54.25) v6(94.34,54.25)
  L5-SIGNAL2 w0.102: v6(94.34,54.25) 94.34,55.14 83.11,66.38 74.35,66.38 72.22,68.5 63.74,68.5 61.15,71.1 58.1,71.1 57.51,71.68 57.51,72.76 56.61,73.66 42.67,73.66 41.39,72.38 39.34,72.38 38.71,73.01 38.71,74.57 v2(39.28,75.14)
  BOTTOM w0.127: R1098.1 v2(31.03,65.88)
  vias: v1(119.92,69.43)
R_MCU_MCAN0_RX: length 1.8
  TOP w0.127: U149.4 R679.2
R_MCU_MCAN1_RX: length 1.8
  TOP w0.127: U150.4 R680.2
R_MCU_ONAND_DS: length 1.9
  TOP w0.127: U245.C3 v2(119.85,37.4)
  BOTTOM w0.127: R532.1 120.03,37.23 v2(119.85,37.4)
R_MUX_USB0_DATA_N: length 5.8
  BOTTOM w0.114: R796.1 138.06,166.37 arc(138.14,166.4) 138.18,166.48 138.18,168.81 arc(138.29,169.35) 138.59,169.81 arc(138.66,169.91) 138.68,170.03 138.68,171.12 arc(138.65,171.2) 138.57,171.24 R775.1
R_MUX_USB0_DATA_P: length 5.8
  BOTTOM w0.114: R774.1 139.06,171.24 arc(138.98,171.2) 138.95,171.12 138.95,170.03 arc(138.9,169.8) 138.78,169.62 arc(138.53,169.25) 138.44,168.81 138.44,166.48 arc(138.48,166.4) 138.56,166.37 R795.1
R_RGMII1_INT#: length 4.5
  TOP w0.127: v2(47.25,98.27) 46.75,98.76 45.5,98.76 45.32,98.58 U50.48
  BOTTOM w0.127: R957.1 v2(47.25,98.27) 47.25,97.48 ; 47.25,97.48 R962.1 47.25,97.48 ; 47.25,97.48 47.25,96.74 R963.1
R_RGMII1_RD0: length 38.5
  TOP w0.127: TP109.1 v2(78.49,85.9)
  L3-SIGNAL1 w0.089: v2(78.49,85.9) 78.49,88.29 79.41,89.21 84.39,89.21 84.59,89.41 89.47,89.41 89.72,89.15 93.1,89.15 98.89,83.36 98.89,82.55 100.77,80.67 106.54,80.67 107.12,81.26 108.17,81.26 108.35,81.43 v3(108.72,81.43)
  BOTTOM w0.127: TP109.1 78.5,85.9 v2(78.49,85.9)
  vias: v1(108.72,81.43)
R_RGMII1_RD1: length 38.9
  TOP w0.127: R363.1 v2(80.01,85.9)
  L3-SIGNAL1 w0.089: v2(80.01,85.9) 80.01,85.53 80.63,84.91 83.54,84.91 83.68,84.77 83.68,84.29 83.81,84.15 84.01,84.15 84.15,84.29 84.15,84.77 84.28,84.91 87.41,84.91 87.96,85.46 89.68,85.46 89.84,85.3 98.53,76.61 98.8,76.61 99.67,75.74 101.16,75.74 101.54,75.36 102.49,75.36 103.75,76.62 104.09,76.62 104.23,76.48 104.23,76.22 104.36,76.09 104.56,76.09 104.7,76.22 104.7,76.48 104.83,76.62 105.03,76.62 105.17,76.48 105.17,76.22 105.3,76.09 105.5,76.09 105.64,76.22 105.64,76.48 105.77,76.62 106.04,76.62 106.18,76.48 106.18,76.26 106.32,76.12 106.51,76.12 106.65,76.26 106.65,76.48 107.18,77.01 107.98,77.01 108.4,77.43 v3(108.72,77.43)
  vias: v1(108.72,77.43)
