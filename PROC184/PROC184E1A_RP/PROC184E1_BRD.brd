# Allegro board PROC184E1_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L3-SIGNAL1 (solid shape): 159.44,29.7 159.46,29.69 159.48,29.68 159.53,29.6 159.54,29.58 159.53,29.57 159.86,29.13 160.19,29.57 160.19,29.58 160.19,29.6 160.25,29.68 160.27,29.69 160.29,29.7 160.31,29.69 160.33,29.68 160.39,29.61 160.39,29.58 160.39,29.57 160.4,29.37 160.52,29.21 160.53,29.2 160.54,29.18 160.55,29.09 160.55,29.07 160.54,29.05 159.28,27.8 159.27,27.79 159.25,27.79 158.47,27.79 158.11,27.43 158.47,27.07 159.35,27.07 159.37,27.07 159.38,27.06 159.44,26.99 159.45,26.97 159.45,26.96 159.96,26.61 159.92,27.23 159.9,27.23 159.89,27.25 159.87,27.35 159.87,27.37 159.88,27.39 161.38,28.89 161.4,28.9 161.43,28.9 161.53,28.87 161.54,28.85 161.55,28.84 161.66,28.65 161.86,28.57 161.88,28.56 163.96,26.49 163.97,26.48 163.99,26.47 170.02,26.47 170.05,26.46 170.07,26.44 170.07,26.43 170.07,26.4 169.72,26.05 169.7,26.04 169.68,26.03 145.11,26.03 145.09,26.04 145.08,26.05 143.68,27.44 143.67,27.46 143.67,27.49 143.68,27.51 143.71,27.53 154.84,27.53 154.86,27.53 154.88,27.54 157.02,29.68 157.04,29.7 157.06,29.7
DGND on L3-SIGNAL1 (solid shape): outline of 165 points within 126.92,36.19 145.53,47.4
DGND on L3-SIGNAL1 (solid shape): 17.04,55.82 17.07,55.81 17.09,55.78 17.13,55.68 17.13,55.65 17.11,55.64 16.81,55.14 16.82,54.55 16.82,54.53 16.78,54.3 16.7,54.09 16.69,54.08 16.33,53.72 16.32,53.7 16.32,53.68 16.32,51.72 16.32,51.7 16.33,51.68 17.86,50.16 17.87,50.13 17.87,50.1 17.86,50.09 17.84,50.07 12.82,50.07 12.8,50.08 12.79,50.09 11.54,51.33 11.53,51.35 11.53,51.37 11.53,52.75 11.54,52.78 11.58,52.8 11.68,52.81 11.71,52.8 11.73,52.77 11.74,52.71 11.74,52.64 13.49,51.58 12.43,53.33 12.41,53.33 12.19,53.37 11.98,53.45 11.95,53.48 11.95,53.5 11.95,53.94 11.95,53.97 11.98,53.99 12.07,54.04 12.1,54.03 12.11,54.02 13.35,54 13.75,55.18 13.75,55.2 13.79,55.42 13.87,55.64 13.88,55.65 14.03,55.8 14.05,55.81 14.07,55.82
DGND on L3-SIGNAL1 (solid shape): 165.08,34.17 165.1,34.18 165.13,34.18 165.15,34.18 165.17,34.15 165.17,31.98 165.16,31.96 165.15,31.94 164.34,31.13 164.32,31.12 164.3,31.12 164.2,31.13 164.18,31.15 164.18,31.16 164.06,31.3 163.89,31.36 163.86,31.37 163.7,31.53 163.69,31.55 163.69,31.57 163.69,31.66 163.7,31.68 163.71,31.69 163.61,32.29 163.18,31.85 163.19,31.84 163.18,31.82 163.13,31.74 163.11,31.72 163.09,31.72 157.04,31.72 157.01,31.72 157,31.74 156.94,31.81 156.94,31.84 156.94,31.85 156.61,32.29 156.28,31.85 156.28,31.84 156.28,31.81 156.22,31.74 156.21,31.72 156.18,31.72 155.37,31.72 155.36,31.71 155.34,31.7 154.3,30.67 154.29,30.66 154.27,30.65 135.77,30.65 135.75,30.66 135.73,30.67 133.59,32.81 133.57,32.84 133.57,32.87 133.58,32.88 133.61,32.9 149.5,32.9 149.53,32.89 149.55,32.87 149.59,32.77 149.59,32.74 149.58,32.73 150.43,30.76 151.28,32.73 151.27,32.74 151.26,32.77 151.31,32.87 151.33,32.89 151.35,32.9 161.28,32.9 161.3,32.9 161.31,32.91 162.33,33.93 162.34,33.94 162.36,33.94 164.83,33.94 164.85,33.94 164.86,33.96
DGND on L3-SIGNAL1 (solid shape): outline of 183 points within 81.37,34.61 95.45,38.62
DGND on L3-SIGNAL1 (solid shape): outline of 112 points within 11.95,55.69 49.96,74.17
DGND on L3-SIGNAL1 (solid shape): outline of 193 points within 113.33,15.8 125.05,18.9
DGND on L3-SIGNAL1 (solid shape): outline of 264 points within 105.81,27.76 125.05,34.45
DGND on L3-SIGNAL1 (solid shape): outline of 313 points within 56.9,66.25 66.91,72.62
DGND on L3-SIGNAL1 (solid shape): outline of 290 points within 28.55,92.07 42.53,111.41
DGND on L3-SIGNAL1 (solid shape): outline of 339 points within 164.61,29.37 177.65,41.92
DGND on L3-SIGNAL1 (solid shape): outline of 347 points within 52.08,62.25 69.59,71.87
DGND on L3-SIGNAL1 (solid shape): outline of 444 points within 105.82,108.58 113.25,119.27
DGND on L3-SIGNAL1 (solid shape): outline of 496 points within 27.73,37.33 63.25,43.89
DGND on L3-SIGNAL1 (solid shape): outline of 712 points within 27.23,85.93 52.95,101.28
DGND on L3-SIGNAL1 (solid shape): outline of 1113 points within 172.6,57.4 186.54,70.57
DGND on L5-SIGNAL2 (solid shape): 82.64,33.2 82.66,33.19 82.68,33.18 82.98,32.87 83,32.85 82.99,32.82 82.99,32.8 82.96,32.79 66.53,32.79 66.51,32.79 66.5,32.8 66.19,33.11 66.18,33.13 66.18,33.16 66.18,33.18 66.21,33.2
DGND on L5-SIGNAL2 (solid shape): 106.15,28.25 106.17,28.25 106.18,28.24 107,27.42 107.02,27.39 107.02,27.36 107.01,27.35 106.98,27.33 105.44,27.33 105.42,27.33 105.41,27.35 104.59,28.17 104.57,28.19 104.58,28.22 104.58,28.24 104.61,28.25
DGND on L5-SIGNAL2 (solid shape): 61.08,53.83 61.11,53.84 61.14,53.84 61.15,53.83 61.17,53.81 61.17,51.16 61.17,51.13 61.15,51.12 61.08,51.06 61.06,51.05 61.05,51.06 60.94,51.06 60.83,51.03 60.82,51.02 60.8,51.03 60.71,51.08 60.7,51.1 60.69,51.12 60.69,53.41 60.69,53.43 60.7,53.45
DGND on L5-SIGNAL2 (solid shape): 128.12,47.72 128.14,47.74 128.17,47.73 128.18,47.73 128.2,47.7 128.2,46.9 128.2,46.89 128.19,46.87 127.56,46.24 127.55,46.23 127.53,46.23 122.78,46.23 122.76,46.23 122.75,46.24 122.54,46.45 122.53,46.47 122.53,46.5 122.54,46.52 122.56,46.53 126.91,46.53 126.93,46.54 126.94,46.55
DGND on L5-SIGNAL2 (solid shape): 63.06,36.57 63.08,36.56 63.1,36.55 63.55,36.1 63.57,36.07 63.56,36.04 63.56,36.03 63.53,36.01 60.26,36.01 60.23,36.01 60.22,36.03 60.16,36.1 60.15,36.13 60.16,36.14 60.17,36.28 60.12,36.41 60.11,36.42 60.11,36.45 60.16,36.54 60.18,36.56 60.21,36.57
DGND on L5-SIGNAL2 (solid shape): 126.16,36.58 126.18,36.58 126.2,36.56 126.26,36.5 126.26,36.47 126.26,36.46 126.26,36.37 126.28,36.28 126.29,36.27 126.28,36.24 126.23,36.16 126.21,36.15 126.19,36.14 122.27,36.14 122.24,36.15 122.23,36.16 122.17,36.24 122.17,36.27 122.17,36.28 122.2,36.37 122.19,36.46 122.19,36.47 122.2,36.5 122.25,36.56 122.27,36.58 122.29,36.58
DGND on L5-SIGNAL2 (solid shape): 126.18,38.66 126.21,38.65 126.22,38.64 126.28,38.56 126.28,38.53 126.28,38.52 126.26,38.39 126.29,38.27 126.29,38.26 126.29,38.23 126.23,38.15 126.22,38.13 126.19,38.13 122.26,38.13 122.24,38.13 122.22,38.15 122.17,38.23 122.16,38.26 122.17,38.27 122.2,38.39 122.18,38.52 122.17,38.53 122.17,38.56 122.23,38.64 122.25,38.65 122.27,38.66
DGND on L5-SIGNAL2 (solid shape): 106.97,26.82 106.99,26.82 107,26.81 107.82,26 107.83,25.98 107.83,25.96 107.83,22.5 107.82,22.48 107.8,22.46 107.79,22.45 107.76,22.46 106.83,23.38 106.82,23.4 106.82,23.42 106.82,25.15 106.81,25.17 106.8,25.19 105.83,26.16 105.82,26.18 105.82,26.2 105.84,26.29 105.85,26.31 105.86,26.32 106.02,26.48 106.05,26.7 106.04,26.71 106.05,26.73 106.1,26.8 106.12,26.82 106.14,26.82
DGND on L5-SIGNAL2 (solid shape): 61.16,29.81 61.18,29.8 61.2,29.78 61.25,29.7 61.26,29.68 61.25,29.66 61.42,29.22 61.87,29.37 61.87,29.38 61.89,29.39 61.99,29.4 62.01,29.4 62.03,29.39 64.81,26.61 64.82,26.59 64.82,26.56 64.81,26.54 64.79,26.53 63.23,26.53 63.21,26.53 63.19,26.54 60.01,29.72 60,29.74 60,29.77 60.01,29.79 60.03,29.81
DGND on L5-SIGNAL2 (solid shape): 103.62,27.41 103.65,27.41 103.67,27.38 103.71,27.28 103.71,27.25 103.7,27.24 103.74,26.73 104.25,26.84 104.25,26.85 104.27,26.87 104.36,26.88 104.39,26.88 104.41,26.87 104.62,26.65 104.64,26.62 104.63,26.59 104.63,26.58 104.6,26.56 95.54,26.56 95.51,26.57 95.49,26.59 95.48,26.61 95.49,26.64 96.25,27.4 96.27,27.41 96.29,27.41
DGND on L5-SIGNAL2 (solid shape): 173.44,42.82 173.47,42.82 173.49,42.79 173.5,42.78 173.49,42.75 173.33,42.59 173.31,42.57 173.29,42.57 157.79,42.57 157.77,42.57 157.75,42.56 156.41,41.21 156.39,41.2 156.37,41.2 131.42,41.2 131.4,41.19 131.38,41.18 131.08,40.88 131.07,40.87 131.05,40.87 130.26,40.87 130.24,40.87 130.22,40.88 129.7,41.4 129.69,41.42 129.69,41.45 129.71,41.54 129.73,41.56 129.74,41.57 129.89,41.69 129.97,41.87 129.97,41.89 129.99,41.91 130.09,41.94 130.11,41.95 130.14,41.93 130.29,41.78 130.31,41.77 130.33,41.76 156.31,41.76 156.33,41.77 156.35,41.78 157.38,42.81 157.39,42.82 157.41,42.82
DGND on L5-SIGNAL2 (solid shape): 48.22,41.63 53.27,36.58 53.28,36.57 53.3,36.57 55.32,36.57 55.35,36.56 55.36,36.54 55.41,36.45 55.41,36.42 55.41,36.41 55.36,36.28 55.36,36.14 55.37,36.13 55.36,36.1 55.3,36.03 55.29,36.01 55.26,36.01 53.39,36.01 53.37,36.01 53.35,36.03 53.3,36.1 53.29,36.13 53.29,36.14 53.07,36.55 52.64,36.35 52.64,36.34 52.62,36.32 52.52,36.3 52.5,36.3 52.48,36.32 48.16,40.64 48.15,40.65 48.14,40.67 48.14,41.58 48.15,41.61 48.17,41.63 48.19,41.64
DGND on L5-SIGNAL2 (solid shape): 214.85,17.68 214.87,17.67 214.89,17.65 214.94,17.56 214.94,17.54 214.94,17.52 215.23,17 215.52,17.52 215.51,17.54 215.51,17.56 215.56,17.65 215.58,17.67 215.61,17.68 217.71,17.68 217.74,17.67 217.76,17.65 217.77,17.63 217.76,17.6 216.58,16.42 216.56,16.41 216.54,16.41 212.06,16.41 212.05,16.4 212.03,16.39 209.65,14.01 209.63,14 209.58,14 209.56,14.03 209.56,14.04 209.56,14.07 213.15,17.66 213.17,17.67 213.19,17.68
DGND on L5-SIGNAL2 (solid shape): 174.17,39.48 174.2,39.47 174.22,39.45 174.22,39.43 174.22,39.4 174.08,39.27 174.06,39.26 174.04,39.25 132.88,39.25 132.86,39.25 132.84,39.24 132.11,38.5 132.09,38.49 132.06,38.49 131.97,38.5 131.95,38.51 131.95,38.52 131.49,38.68 131.27,38.25 131.28,38.24 131.27,38.22 131.21,38.15 131.2,38.13 131.17,38.13 128.01,38.13 127.99,38.13 127.97,38.15 127.92,38.22 127.91,38.25 127.92,38.26 127.93,38.39 127.9,38.52 127.9,38.53 127.9,38.55 127.95,38.64 127.97,38.65 128,38.66 131.18,38.66 131.2,38.66 131.22,38.67 132.01,39.47 132.03,39.48 132.04,39.48
DGND on L5-SIGNAL2 (solid shape): 63.78,55.19 63.8,55.19 63.82,55.18 63.87,55.11 63.88,55.08 64.22,54.7 64.56,55.08 64.57,55.11 64.62,55.18 64.64,55.19 64.66,55.19 67.93,55.19 67.95,55.19 67.96,55.18 69.61,53.53 69.63,53.52 69.65,53.52 70.49,53.52 70.51,53.51 70.53,53.5 70.59,53.43 70.59,53.41 70.59,53.4 70.59,53.26 70.63,53.14 70.64,53.13 70.64,53.1 70.59,53.01 70.57,52.99 70.55,52.98 69.76,52.98 69.74,52.99 69.72,53 68.44,54.28 68.43,54.29 68.41,54.29 62.66,54.29 62.6,54.32 62.59,54.34 62.59,54.37 63.4,55.18 63.42,55.19 63.44,55.19
DGND on L5-SIGNAL2 (solid shape): 187.66,15.51 187.94,15.23 187.98,15.21 196.38,15.21 196.41,15.2 196.88,14.73 196.89,14.6 196.88,14.58 196.84,14.56 196.8,14.52 196.77,14.48 196.74,14.43 196.72,14.38 196.71,14.33 196.71,14.27 196.71,14.22 196.73,14.16 196.74,14.13 196.74,14.1 196.65,14 187.92,14 187.88,14.01 187.6,14.29 187.59,14.33 187.59,14.67 194.15,14.67 194.16,14.62 194.17,14.57 194.19,14.52 194.22,14.47 194.25,14.43 194.29,14.4 194.33,14.37 194.38,14.35 194.43,14.33 194.48,14.33 194.54,14.33 194.59,14.34 194.64,14.36 194.68,14.38 194.72,14.41 194.76,14.45 194.79,14.5 194.81,14.54 194.83,14.59 194.84,14.64 194.84,14.7 194.83,14.75 194.81,14.8 194.79,14.85 194.76,14.89 194.72,14.93 194.68,14.96 194.64,14.98 194.59,15 194.54,15.01 194.48,15.01 194.43,15.01 194.38,14.99 194.33,14.97 194.29,14.94 194.25,14.91 194.22,14.87 194.19,14.82 194.17,14.77 194.16,14.72 194.15,14.67 187.59,14.67 187.59,15.46 187.6,15.49 187.63,15.51
DGND on L5-SIGNAL2 (solid shape): outline of 81 points within 125.04,15.7 132.19,22.62
DGND on L5-SIGNAL2 (solid shape): 152.94,35.53 152.96,35.53 152.98,35.52 153.04,35.45 153.04,35.42 153.38,35.03 153.72,35.42 153.73,35.45 153.78,35.52 153.8,35.53 153.82,35.53 154.35,35.53 154.37,35.53 154.39,35.52 154.45,35.45 154.45,35.42 154.79,35.03 155.13,35.42 155.14,35.45 155.2,35.52 155.21,35.53 155.23,35.53 160.13,35.53 160.15,35.53 160.17,35.52 161.39,34.3 161.4,34.27 161.4,34.25 161.39,34.23 161.37,34.21 160.42,34.21 160.39,34.22 160.37,34.24 160.32,34.31 160.31,34.33 160.32,34.35 159.99,34.79 159.66,34.35 159.67,34.33 159.66,34.31 159.61,34.24 159.59,34.22 159.57,34.21 159.5,34.21 159.46,34.23 159.45,34.27 159.45,34.29 159.18,34.79 158.82,34.35 158.83,34.33 158.82,34.31 158.77,34.24 158.75,34.22 158.73,34.21 131.79,34.21 131.76,34.22 131.74,34.25 131.73,34.26 131.74,34.29 132.97,35.52 132.99,35.53 133.01,35.53
DGND on L5-SIGNAL2 (solid shape): 194.03,34.48 194.05,34.46 194.06,34.43 194.06,24.3 194.63,22.92 196.01,22.35 197.78,22.35 197.81,22.33 197.81,22.32 198.14,22.08 198.46,22.32 198.47,22.33 198.5,22.35 204.09,22.35 204.38,22.38 204.66,22.45 204.68,22.46 204.7,22.45 204.79,22.38 204.8,22.35 204.8,22.34 204.77,22.15 204.76,21.96 204.76,21.51 204.74,21.48 204.71,21.46 203.51,21.46 203.49,21.47 203.47,21.49 203.41,21.56 203.41,21.59 203.42,21.6 203.09,22.07 202.77,21.6 202.78,21.59 202.78,21.56 202.72,21.49 202.7,21.47 202.68,21.46 194.05,21.46 193.16,21.83 192.79,22.72 192.79,24.95 192.81,25.04 192.86,25.11 193.19,25.44 193.48,25.88 193.58,26.39 193.58,28.83 193.45,29.39 193.09,29.84 193.08,29.85 193.07,29.87 193.07,29.98 193.08,30 193.09,30 193.58,31.02 193.09,32.03 193.08,32.03 193.07,32.06 193.07,32.16 193.08,32.18 193.09,32.19 193.45,32.64 193.58,33.2 193.58,34.17 193.59,34.19 193.6,34.21 193.85,34.46 193.9,34.51 193.93,34.52
DGND on L5-SIGNAL2 (solid shape): outline of 241 points within 45.38,34.71 52.69,44.69
DGND on L5-SIGNAL2 (solid shape): outline of 115 points within 115.76,40.13 129.52,41.22
DGND on L5-SIGNAL2 (solid shape): outline of 533 points within 189.21,18.42 206.16,32.26
DGND on L12-SIGNAL5 (solid shape): 13.38,101.54 13.41,101.55 13.44,101.55 13.45,101.54 13.47,101.52 13.47,76.31 13.46,76.29 13.44,76.27 13.42,76.26 13.39,76.27 13.12,76.54 13.11,76.56 13.1,76.58 13.1,101.24 13.11,101.26 13.12,101.28
DGND on L12-SIGNAL5 (solid shape): 44.26,87.58 44.28,87.59 44.31,87.59 44.33,87.58 44.34,87.55 44.34,87.01 44.34,86.99 44.33,86.97 42.55,85.19 42.52,85.17 42.49,85.18 42.48,85.18 42.46,85.21 42.46,85.76 42.46,85.77 42.47,85.79
DGND on L12-SIGNAL5 (solid shape): 57.34,122.96 57.37,122.98 57.4,122.97 57.41,122.97 57.43,122.94 57.43,120.8 57.43,120.78 57.42,120.77 56.82,120.17 56.79,120.15 56.76,120.16 56.75,120.16 56.73,120.19 56.73,122.33 56.73,122.35 56.75,122.36
DGND on L12-SIGNAL5 (solid shape): 69.83,58.72 70.17,58.38 70.18,58.36 70.19,58.34 70.19,52.76 70.18,52.73 70.16,52.71 70.14,52.7 70.11,52.71 69.77,53.05 69.76,53.07 69.76,53.09 69.76,58.68 69.77,58.7 69.79,58.72 69.8,58.73
DGND on L12-SIGNAL5 (solid shape): 81.04,29.65 82.61,28.08 82.63,28.06 82.63,28.04 82.63,27.55 82.62,27.53 82.6,27.51 82.58,27.5 82.55,27.51 80.98,29.08 80.97,29.1 80.96,29.12 80.96,29.61 80.97,29.63 80.99,29.65 81.01,29.66
DGND on L12-SIGNAL5 (solid shape): 86.78,24.14 86.8,24.13 86.82,24.12 92.23,18.71 92.24,18.68 92.24,18.65 92.23,18.64 92.21,18.62 91.91,18.62 91.89,18.63 91.87,18.64 86.46,24.05 86.44,24.08 86.45,24.11 86.45,24.12 86.48,24.14
DGND on L12-SIGNAL5 (solid shape): 91.25,26.75 91.27,26.75 91.29,26.74 93.45,24.57 93.46,24.56 93.47,24.54 93.47,24.04 93.46,24.01 93.44,23.99 93.42,23.99 93.39,23.99 90.72,26.67 90.7,26.69 90.71,26.72 90.71,26.74 90.74,26.75
DGND on L12-SIGNAL5 (solid shape): 199.16,65.73 199.19,65.74 199.21,65.74 199.23,65.74 199.25,65.71 199.25,64.24 199.24,64.22 199.23,64.2 198.06,63.03 198.04,63.02 198.01,63.02 197.99,63.03 197.98,63.05 197.98,64.53 197.98,64.55 197.99,64.56
DGND on L12-SIGNAL5 (solid shape): 200.76,61.13 200.79,61.14 200.82,61.14 200.83,61.13 200.85,61.11 200.85,56.36 200.85,56.34 200.84,56.32 200.58,56.06 200.55,56.05 200.52,56.05 200.51,56.06 200.49,56.08 200.49,60.83 200.49,60.85 200.51,60.87
DGND on L12-SIGNAL5 (solid shape): 212.59,20.35 212.61,20.34 212.62,20.33 213.14,19.81 213.15,19.78 213.16,19.69 213.19,19.61 213.2,19.59 213.2,19.57 213.14,19.48 213.13,19.46 213.1,19.46 211.82,19.46 211.8,19.46 211.78,19.47 211,20.26 210.98,20.28 210.98,20.31 210.99,20.33 211.02,20.35
DGND on L12-SIGNAL5 (solid shape): 58.37,119.17 58.39,119.18 58.42,119.18 58.44,119.17 58.45,119.15 58.45,116.18 58.45,116.16 58.44,116.14 58.11,115.81 58.1,115.8 58.09,115.78 58.09,115.17 58.09,115.14 58.06,115.12 58.05,115.11 58.02,115.12 57.96,115.17 57.95,115.19 57.95,115.21 57.95,118.73 57.95,118.75 57.96,118.77
DGND on L12-SIGNAL5 (solid shape): 109.76,21.18 109.78,21.18 109.8,21.17 110.15,20.81 110.17,20.79 110.16,20.76 110.16,20.74 110.13,20.73 103.44,20.73 103.42,20.73 103.4,20.74 103.3,20.84 103.29,20.87 103.29,20.9 103.29,20.91 103.32,20.93 105.02,20.93 105.04,20.93 105.06,20.94 105.28,21.17 105.3,21.18 105.32,21.18
DGND on L12-SIGNAL5 (solid shape): 123.93,36.4 123.96,36.41 123.99,36.41 124,36.4 124.02,36.38 124.02,36.35 124.01,36.33 124,36.31 122.99,35.3 122.97,35.28 122.95,35.28 122.3,35.28 122.28,35.28 122.26,35.3 122.06,35.5 122.05,35.53 122.05,35.55 122.06,35.57 122.08,35.59 123.1,35.59 123.12,35.59 123.13,35.6
DGND on L12-SIGNAL5 (solid shape): 182.07,19.8 182.1,19.79 182.12,19.77 182.12,19.76 182.12,19.73 182.1,19.7 182.09,19.68 182.09,19.34 182.09,19.33 182.08,19.31 180.65,17.88 180.63,17.87 180.61,17.87 180.18,17.87 180.15,17.87 180.13,17.9 180.12,17.91 180.13,17.94 181.98,19.79 181.99,19.8 182.01,19.8
DGND on L12-SIGNAL5 (solid shape): 182.18,15.78 182.2,15.78 182.22,15.77 182.28,15.7 182.28,15.67 182.29,15.55 182.34,15.45 182.34,15.43 182.34,15.41 182.3,15.32 182.28,15.3 182.25,15.29 178.09,15.29 178.06,15.3 178.04,15.32 178.03,15.33 178.04,15.36 178.44,15.77 178.46,15.78 178.48,15.78
DGND on L12-SIGNAL5 (solid shape): 182.99,21.87 183.02,21.86 183.04,21.84 183.04,21.82 183.04,21.79 182.17,20.92 182.15,20.91 182.13,20.91 181.77,20.91 181.75,20.9 181.73,20.89 179.39,18.55 179.37,18.54 179.35,18.54 178.97,18.54 178.94,18.54 178.92,18.57 178.92,18.58 178.92,18.61 182.17,21.85 182.18,21.87 182.2,21.87
DGND on L12-SIGNAL5 (solid shape): 88.12,35.89 88.14,35.89 88.16,35.88 88.51,35.52 88.52,35.5 88.53,35.48 88.53,33.4 88.52,33.37 88.5,33.35 88.48,33.35 88.45,33.35 86.42,35.38 86.42,35.41 86.42,35.43 86.44,35.58 86.39,35.74 86.39,35.75 86.39,35.77 86.44,35.86 86.46,35.88 86.48,35.89
DGND on L12-SIGNAL5 (solid shape): 118.88,124.17 118.97,124.15 119.06,124.16 119.07,124.16 119.09,124.15 119.16,124.1 119.17,124.08 119.18,124.06 119.18,109.32 119.17,109.3 119.16,109.28 119.08,109.22 119.06,109.22 119.05,109.22 118.96,109.24 118.87,109.23 118.86,109.23 118.83,109.24 118.77,109.3 118.75,109.31 118.75,109.33 118.75,124.07 118.75,124.09 118.77,124.11 118.84,124.17 118.87,124.17
DGND on L12-SIGNAL5 (solid shape): 78.36,82.42 78.45,82.41 78.51,82.35 78.52,82.33 78.52,82.31 78.52,81.74 78.52,81.72 78.53,81.7 79.22,81.02 79.23,81 79.23,80.99 79.23,80.91 79.22,80.88 79.2,80.86 79.19,80.85 79.16,80.86 78.18,81.83 78.17,81.85 78.16,81.87 78.16,82.34 78.17,82.37 78.19,82.39 78.27,82.44 78.29,82.44
DGND on L12-SIGNAL5 (solid shape): 84.31,31.95 84.33,31.95 84.35,31.94 85.85,30.44 85.86,30.42 85.86,30.4 85.86,30.31 85.85,30.29 85.79,30.25 85.75,30.19 85.73,30.18 85.64,30.18 85.62,30.18 85.6,30.19 84.97,30.83 84.95,30.84 84.93,30.84 83.24,30.84 83.22,30.85 83.2,30.86 82.19,31.87 82.18,31.89 82.18,31.92 82.19,31.94 82.21,31.95
DGND on L12-SIGNAL5 (solid shape): 59.49,122.49 59.57,122.43 59.59,122.42 59.6,122.39 59.6,116.03 59.59,116.01 59.58,115.99 58.95,115.36 58.92,115.34 58.89,115.35 58.88,115.35 58.86,115.38 58.86,115.51 58.86,115.53 58.88,115.55 59.17,115.84 59.18,115.86 59.18,115.87 59.18,122.37 59.19,122.39 59.2,122.41 59.27,122.46 59.3,122.47 59.38,122.47 59.46,122.49 59.47,122.49
DGND on L12-SIGNAL5 (solid shape): 102.04,24.82 102.06,24.81 102.08,24.8 103.63,23.25 103.64,23.23 103.65,23.2 103.63,23.11 103.61,23.09 103.6,23.08 103.53,23.04 103.47,22.97 103.46,22.96 103.44,22.95 103.35,22.95 103.33,22.95 103.31,22.96 102.19,24.09 102.17,24.1 102.15,24.1 97.04,24.1 97.02,24.11 97,24.12 96.39,24.73 96.38,24.76 96.38,24.78 96.39,24.8 96.41,24.82
DGND on L12-SIGNAL5 (solid shape): 43.55,114.47 43.58,114.49 43.61,114.48 43.62,114.48 43.64,114.45 43.64,114.07 43.64,114.05 43.63,114.03 43.02,113.43 43.01,113.42 42.99,113.41 42.29,113.41 42.27,113.42 42.25,113.43 42.2,113.51 42.19,113.53 42.2,113.55 42.22,113.68 42.18,113.81 42.18,113.82 42.18,113.84 42.23,113.93 42.25,113.95 42.28,113.95 43.01,113.95 43.03,113.96 43.05,113.97
DGND on L12-SIGNAL5 (solid shape): 96.41,17.52 96.44,17.51 96.45,17.49 96.5,17.4 96.5,17.37 96.49,17.36 96.3,16.77 96.49,16.18 96.5,16.17 96.5,16.14 96.45,16.05 96.44,16.03 96.41,16.02 93.56,16.02 93.54,16.02 93.52,16.03 92.13,17.43 92.11,17.46 92.12,17.49 92.12,17.5 92.15,17.52
DGND on L12-SIGNAL5 (solid shape): 110.25,20.22 110.26,20.21 110.28,20.2 118.48,12 118.5,11.99 118.52,11.99 118.64,11.99 118.66,11.98 118.69,11.97 125.28,11.97 125.3,11.96 125.32,11.95 125.41,11.85 125.43,11.84 125.45,11.84 133.13,11.84 133.16,11.83 133.17,11.81 133.18,11.79 133.17,11.76 132.91,11.5 132.89,11.48 132.87,11.48 116.92,11.48 116.9,11.48 116.89,11.5 108.25,20.13 108.24,20.16 108.24,20.19 108.25,20.2 108.27,20.22
DGND on L12-SIGNAL5 (solid shape): 57.38,120.02 57.4,120.03 57.42,120.03 57.51,120.02 57.53,120.01 57.54,120 57.68,119.89 57.86,119.86 57.89,119.85 57.95,119.8 57.97,119.78 57.97,119.76 57.97,119.51 57.97,119.49 57.96,119.48 57.46,118.98 57.45,118.96 57.44,118.94 57.44,115.36 57.43,115.33 57.41,115.32 57.4,115.31 57.37,115.32 56.97,115.71 56.96,115.73 56.95,115.75 56.95,119.57 56.96,119.58 56.97,119.6
DGND on L12-SIGNAL5 (solid shape): 70.1,49.33 70.13,49.34 70.16,49.34 70.17,49.33 70.19,49.31 70.19,48.76 70.19,48.74 70.2,48.72 70.33,48.6 70.34,48.58 70.34,48.57 70.34,48.12 70.34,48.11 70.36,48.09 71.87,46.57 71.88,46.55 71.89,46.53 71.87,46.44 71.86,46.42 71.82,46.4 71.77,46.37 71.73,46.36 71.71,46.37 71.69,46.38 69.87,48.2 69.86,48.21 69.86,48.23 69.86,49.06 69.86,49.08 69.87,49.1
DGND on L12-SIGNAL5 (solid shape): 198.93,19.99 198.95,19.98 198.97,19.96 198.98,19.94 198.97,19.91 197.56,18.5 197.54,18.49 197.52,18.48 193.9,18.48 193.88,18.48 193.86,18.47 193.39,18 193.37,17.98 193.35,17.98 192.08,17.98 192.06,17.99 192.04,18 191.98,18.06 191.98,18.09 191.98,18.18 191.95,18.27 191.95,18.28 191.95,18.31 192,18.39 192.02,18.41 192.04,18.41 192.5,18.41 192.52,18.42 192.53,18.43 194.08,19.97 194.1,19.99 194.11,19.99
DGND on L12-SIGNAL5 (solid shape): 71.26,46.03 71.29,46.04 71.34,46.01 71.34,45.99 71.34,45.78 71.35,45.76 71.36,45.74 71.72,45.38 71.74,45.37 71.76,45.36 72.54,45.36 72.55,45.36 72.57,45.35 73.21,44.71 73.22,44.69 73.22,44.66 73.21,44.64 73.19,44.63 72.24,44.63 72.22,44.63 72.2,44.64 71.13,45.71 71.12,45.73 71.11,45.75 71.12,45.84 71.14,45.87 71.2,45.93 71.24,46.01
DGND on L12-SIGNAL5 (solid shape): 20.7,107.06 21.84,105.92 21.85,105.91 21.85,105.89 21.85,103.64 21.86,103.62 21.87,103.61 22.69,102.79 22.7,102.76 22.7,102.73 22.69,102.72 22.67,102.7 21.44,102.7 21.42,102.7 21.4,102.72 21.34,102.79 21.34,102.81 21.34,102.82 21.33,102.97 21.27,103.1 21.26,103.11 21.26,103.13 21.26,104.39 21.25,104.41 21.24,104.43 20.64,105.03 20.62,105.05 20.62,105.07 20.62,107.02 20.63,107.04 20.65,107.06 20.67,107.07
DGND on L12-SIGNAL5 (solid shape): 194.17,65.23 194.73,64.67 194.74,64.64 194.8,64.48 194.94,64.36 194.95,64.36 194.96,64.34 194.98,64.25 194.98,64.22 194.96,64.2 192.65,61.89 192.64,61.88 192.62,61.87 191.51,61.87 191.48,61.88 191.47,61.91 191.46,61.92 191.47,61.95 192.19,62.67 192.2,62.68 192.22,62.69 193.21,62.69 193.23,62.69 193.24,62.7 194.08,63.53 194.09,63.55 194.09,63.57 194.09,65.18 194.1,65.21 194.12,65.23 194.14,65.24
DGND on L12-SIGNAL5 (solid shape): 62.83,81.06 62.86,81.07 62.89,81.07 62.9,81.06 62.92,81.04 62.92,79.76 62.92,79.74 62.9,79.72 61.21,78.03 61.19,78.02 61.17,78.02 61.09,78.02 61.06,78.04 60.96,78.13 60.82,78.17 60.8,78.18 60.55,78.42 60.54,78.44 60.54,78.46 60.54,79.86 60.54,79.88 60.55,79.89 60.8,80.14 60.82,80.15 60.92,80.18 61.02,80.24 61.04,80.24 61.99,80.24 62.01,80.24 62.03,80.25
DGND on L12-SIGNAL5 (solid shape): 28.95,68.47 28.98,68.46 29,68.44 29,68.42 29,68.39 27.8,67.2 27.78,67.19 27.76,67.18 26.52,67.18 26.49,67.19 26.47,67.2 26.42,67.28 26.42,67.31 26.42,67.32 26.1,67.79 25.78,67.32 25.79,67.31 25.78,67.28 25.73,67.2 25.71,67.19 25.69,67.18 23.98,67.18 23.96,67.19 23.89,67.23 23.81,67.26 23.79,67.28 23.77,67.38 23.77,67.4 23.78,67.43 24.81,68.46 24.82,68.47 24.84,68.47
DGND on L12-SIGNAL5 (solid shape): 23.51,68.69 23.53,68.69 23.55,68.68 23.61,68.61 23.61,68.58 23.64,68.41 23.74,68.27 23.76,68.24 23.76,68.15 23.76,68.13 23.75,68.12 23.44,67.81 23.41,67.79 23.39,67.8 23.29,67.84 23.27,67.86 23.27,67.88 22.84,68.2 22.62,67.72 22.62,67.71 22.62,67.68 22.57,67.6 22.55,67.58 22.52,67.57 20.72,67.57 20.69,67.58 20.67,67.6 20.67,67.62 20.67,67.65 21.7,68.68 21.72,68.69 21.74,68.69
DGND on L12-SIGNAL5 (solid shape): 192.99,21.25 193.01,21.24 193.03,21.22 193.04,21.2 193.03,21.17 191.77,19.91 191.76,19.9 191.74,19.9 188.85,19.9 188.83,19.9 188.81,19.91 188.76,19.98 188.75,20.01 188.75,20.02 188.42,20.43 188.08,20.02 188.08,20.01 188.08,19.98 188.02,19.91 188,19.9 187.98,19.9 183.49,19.9 183.47,19.89 183.46,19.88 183.19,19.61 183.17,19.6 183.15,19.6 183.06,19.6 183.04,19.62 183,19.66 182.95,19.72 182.94,19.81 182.94,19.83 182.96,19.85 184.34,21.23 184.36,21.24 184.38,21.25
DGND on L12-SIGNAL5 (solid shape): 123.8,107.86 123.86,107.8 123.87,107.79 123.87,107.77 123.87,104.06 123.84,103.89 123.74,103.75 123.29,103.29 122.86,102.65 122.71,101.91 122.71,100.05 122.71,100.03 122.69,100.01 122.62,99.95 122.59,99.95 122.53,99.96 122.44,99.97 122.38,100.03 122.37,100.05 122.37,100.07 122.37,102.56 122.41,102.77 122.53,102.95 122.93,103.35 123.44,104.11 123.61,105 123.61,107.77 123.62,107.79 123.63,107.81 123.69,107.86
DGND on L12-SIGNAL5 (solid shape): 129.66,118.66 129.7,118.66 129.81,118.64 129.81,117.05 129.78,116.9 129.7,116.77 127.79,114.86 127.53,114.48 127.44,114.03 127.44,109.34 127.44,109.32 127.43,109.3 127.37,109.25 127.36,109.24 127.29,109.25 127.23,109.31 127.22,109.32 127.21,109.34 127.21,115.04 127.32,115.56 127.61,116 128.97,117.36 129.35,117.91 129.5,118.57 129.51,118.59 129.52,118.61 129.58,118.66 129.6,118.66 129.63,118.66
DGND on L12-SIGNAL5 (solid shape): 119.08,107.89 119.16,107.83 119.17,107.81 119.18,107.79 119.18,103.96 119.17,103.91 119.13,103.86 118.45,103.17 118.1,102.64 117.97,102.02 117.97,95.11 117.97,95.1 117.92,95.07 117.9,95.06 117.87,95.06 117.82,95.08 117.75,95.1 117.7,95.15 117.69,95.16 117.69,95.18 117.69,98.46 117.63,98.73 117.48,98.95 117.4,99.03 117.39,99.05 117.39,99.07 117.39,102.28 117.45,102.6 117.63,102.87 118.41,103.65 118.66,104.02 118.75,104.47 118.75,107.77 118.75,107.8 118.77,107.81 118.83,107.87 118.86,107.88 118.87,107.87 118.96,107.87 119.05,107.89 119.06,107.89
DGND on L12-SIGNAL5 (solid shape): 127.37,107.86 127.43,107.8 127.44,107.79 127.44,107.77 127.44,103.79 127.34,103.28 127.05,102.85 126.01,101.8 125.42,100.92 125.21,99.87 125.21,95.29 125.2,95.23 125.16,95.17 125.1,95.11 125.06,95.1 125.04,95.1 125.01,95.12 124.99,95.14 124.99,95.17 124.99,95.21 124.99,100.73 125.06,101.12 125.28,101.45 126.71,102.87 127.08,103.44 127.21,104.1 127.21,107.77 127.22,107.79 127.23,107.8 127.29,107.86
DGND on L12-SIGNAL5 (solid shape): 89.11,33.45 89.19,33.37 89.19,33.36 94.29,28.26 94.3,28.24 94.3,28.21 94.28,28.11 94.27,28.1 94.25,28.09 94.13,27.53 94.69,27.65 94.7,27.66 94.72,27.68 94.81,27.7 94.84,27.7 94.86,27.69 96.63,25.92 96.64,25.91 96.66,25.91 101.5,25.91 101.52,25.9 101.53,25.89 102.02,25.41 102.03,25.38 102.03,25.36 102.02,25.34 102,25.32 96.4,25.32 96.38,25.33 96.36,25.34 94.58,27.13 94.56,27.14 94.54,27.14 93.89,27.14 93.87,27.14 93.85,27.15 91.92,29.09 91.91,29.1 91.91,29.12 91.91,30.41 91.9,30.43 91.89,30.45 89.05,33.29 89.04,33.3 89.04,33.32 89.04,33.4 89.04,33.43 89.07,33.45 89.08,33.45
DGND on L12-SIGNAL5 (solid shape): 65.79,90.65 65.82,90.66 65.86,90.65 65.88,90.63 65.88,62.26 65.9,62.23 69.23,58.89 69.25,58.85 69.25,52.88 69.29,52.81 69.29,52.79 69.15,52.72 69.12,52.72 69.03,52.78 69.02,52.8 69.02,52.82 69.02,57.59 69.01,57.63 66.13,60.5 66.62,60.5 66.62,60.45 66.64,60.4 66.65,60.35 66.68,60.31 66.72,60.27 66.75,60.23 66.8,60.2 66.85,60.18 66.9,60.17 66.95,60.16 67,60.16 67.05,60.17 67.1,60.19 67.15,60.21 67.19,60.25 67.23,60.28 67.26,60.33 67.28,60.37 67.3,60.42 67.31,60.48 67.31,60.53 67.3,60.58 67.28,60.63 67.26,60.68 67.23,60.72 67.19,60.76 67.15,60.79 67.1,60.82 67.05,60.83 67,60.84 66.95,60.85 66.9,60.84 66.85,60.83 66.8,60.8 66.75,60.78 66.72,60.74 66.68,60.7 66.65,60.66 66.64,60.61 66.62,60.56 66.62,60.5 66.13,60.5 65.42,61.21 65.4,61.25 65.4,90.24 65.42,90.27
DGND on L12-SIGNAL5 (solid shape): 201.82,61.35 201.95,61.35 201.97,61.34 201.99,61.31 202.03,61.27 202.07,61.24 202.11,61.22 202.16,61.2 202.21,61.19 202.27,61.18 202.32,61.19 202.36,61.2 202.38,61.19 202.46,61.13 202.47,61.11 202.47,61.1 202.47,55.37 202.46,55.34 199.84,52.72 199.81,52.71 198.61,52.71 198.55,52.74 198.53,52.76 198.54,52.89 201.01,55.35 201.43,55.35 201.43,55.3 201.44,55.25 201.46,55.2 201.49,55.16 201.52,55.12 201.56,55.08 201.61,55.05 201.66,55.03 201.71,55.02 201.76,55.01 201.81,55.01 201.86,55.02 201.91,55.04 201.96,55.07 202,55.1 202.04,55.14 202.07,55.18 202.09,55.23 202.11,55.28 202.11,55.33 202.11,55.38 202.11,55.43 202.09,55.48 202.07,55.53 202.04,55.57 202,55.61 201.96,55.64 201.91,55.67 201.86,55.69 201.81,55.7 201.76,55.7 201.71,55.69 201.66,55.68 201.61,55.66 201.56,55.63 201.52,55.59 201.49,55.55 201.46,55.51 201.44,55.46 201.43,55.41 201.43,55.35 201.01,55.35 201.57,55.91 201.58,55.95 201.58,61.09 201.6,61.12
DGND on L12-SIGNAL5 (solid shape): 147.33,24.18 147.36,24.17 147.38,24.15 147.38,24.14 147.38,24.11 146.76,23.48 146.74,23.47 146.72,23.47 141.56,23.47 141.54,23.48 141.52,23.49 141.47,23.56 141.46,23.59 141.47,23.6 141.13,24.02 140.8,23.6 140.8,23.59 140.8,23.56 140.74,23.49 140.72,23.48 140.7,23.47 140.65,23.47 140.63,23.48 140.61,23.49 140.55,23.56 140.55,23.59 140.55,23.6 140.22,24.02 139.89,23.6 139.89,23.59 139.88,23.56 139.83,23.49 139.81,23.48 139.79,23.47 138.44,23.47 138.41,23.48 138.39,23.5 138.38,23.52 138.39,23.55 139.01,24.17 139.03,24.18 139.05,24.18
DGND on L12-SIGNAL5 (solid shape): 197.7,22.58 197.72,22.58 197.74,22.56 197.79,22.5 197.8,22.47 198.14,22.08 198.48,22.47 198.48,22.5 198.54,22.56 198.56,22.58 198.58,22.58 203.45,22.58 203.46,22.58 203.48,22.57 204.52,21.52 204.54,21.5 204.53,21.47 204.53,21.45 204.5,21.44 203.5,21.44 203.48,21.44 203.46,21.46 203.4,21.54 203.4,21.57 203.41,21.58 203.09,22.07 202.78,21.58 202.79,21.57 202.79,21.54 202.73,21.46 202.71,21.44 202.69,21.44 193.69,21.44 193.66,21.45 193.64,21.47 193.63,21.48 193.64,21.51 194.69,22.57 194.71,22.58 194.73,22.58
DGND on L12-SIGNAL5 (solid shape): 199.06,75.89 199.08,75.89 199.13,75.81 199.14,75.76 199.16,75.72 199.18,75.67 199.22,75.63 199.26,75.6 199.3,75.57 199.35,75.55 199.4,75.53 199.45,75.53 199.5,75.53 199.54,75.53 199.56,75.53 200.78,74.31 200.8,74.27 200.8,68.7 200.79,68.69 200.78,68.67 200.7,68.6 200.67,68.6 200.64,68.61 200.59,68.62 200.54,68.62 200.48,68.63 200.4,68.72 200.4,72.77 200.38,72.8 199.03,74.16 199.02,74.19 199.02,74.87 199.12,74.87 199.13,74.82 199.14,74.77 199.16,74.72 199.18,74.67 199.22,74.63 199.26,74.6 199.3,74.57 199.35,74.55 199.4,74.53 199.45,74.53 199.5,74.53 199.56,74.54 199.61,74.56 199.65,74.58 199.69,74.61 199.73,74.65 199.76,74.69 199.78,74.74 199.8,74.79 199.81,74.84 199.81,74.9 199.8,74.95 199.78,75 199.76,75.05 199.73,75.09 199.69,75.13 199.65,75.16 199.61,75.18 199.56,75.2 199.5,75.21 199.45,75.21 199.4,75.21 199.35,75.19 199.3,75.17 199.26,75.14 199.22,75.11 199.18,75.07 199.16,75.02 199.14,74.97 199.13,74.92 199.12,74.87 199.02,74.87 199.02,75.83
DGND on L12-SIGNAL5 (solid shape): 131.87,40.08 131.89,40.08 131.91,40.07 132.05,39.92 132.06,39.91 132.06,39.89 132.06,38.67 132.05,38.64 132.03,38.62 131.93,38.58 131.9,38.59 131.89,38.6 131.47,38.67 131.27,38.29 131.26,38.26 131.2,38.19 131.19,38.18 131.16,38.18 130.18,38.18 130.16,38.18 130.15,38.19 129.99,38.35 129.97,38.38 129.97,38.41 129.98,38.42 130.01,38.44 130.07,38.44 130.09,38.44 130.1,38.45 130.38,38.73 130.39,38.75 130.4,38.77 130.4,38.94 130.4,38.97 130.42,38.98 130.49,39.04 130.51,39.05 130.52,39.04 130.97,39.4 130.52,39.76 130.51,39.76 130.49,39.77 130.42,39.82 130.4,39.84 130.4,39.86 130.4,39.92 130.4,39.94 130.41,39.96 130.52,40.07 130.54,40.08 130.56,40.08
DGND on L12-SIGNAL5 (solid shape): 134.38,97.98 134.39,97.97 134.4,97.93 134.39,97.9 134.28,97.79 134.25,97.79 134.23,97.79 133.7,97.71 133.62,97.18 133.62,97.16 133.62,97.13 133.43,96.94 133.41,96.92 133.39,96.92 133.08,96.92 132.97,96.92 132.9,96.98 132.89,97.01 132.39,97.28 132.31,96.72 132.32,96.7 132.32,96.61 132.32,96.59 132.31,96.58 131.97,96.24 131.94,96.22 131.91,96.23 131.9,96.23 131.88,96.26 131.88,97.08 131.91,97.25 132.01,97.39 132.42,97.8 132.6,97.92 132.8,97.96 134.15,97.96 134.25,97.97 134.35,97.98
DGND on L12-SIGNAL5 (solid shape): 92.46,93.79 92.5,93.78 92.55,93.76 92.6,93.76 92.65,93.76 92.69,93.77 92.71,93.76 92.79,93.67 92.79,92.3 92.78,92.27 89.81,89.3 89.77,89.28 89.33,89.28 89.3,89.27 88.39,88.36 88.38,88.35 88.36,88.34 88.26,88.35 88.24,88.37 88.21,88.4 88.18,88.44 88.14,88.48 88.09,88.5 88.04,88.52 87.98,88.54 87.93,88.54 87.87,88.54 87.79,88.64 87.79,89.05 87.8,89.08 90.87,92.15 91.64,92.15 91.64,92.1 91.65,92.05 91.67,92 91.7,91.95 91.73,91.91 91.77,91.88 91.82,91.85 91.87,91.83 91.92,91.81 91.97,91.81 92.02,91.81 92.07,91.82 92.12,91.84 92.17,91.86 92.21,91.89 92.25,91.93 92.28,91.98 92.3,92.02 92.32,92.07 92.32,92.12 92.32,92.18 92.32,92.23 92.3,92.28 92.28,92.33 92.25,92.37 92.21,92.41 92.17,92.44 92.12,92.46 92.07,92.48 92.02,92.49 91.97,92.49 91.92,92.49 91.87,92.47 91.82,92.45 91.77,92.42 91.73,92.39 91.7,92.35 91.67,92.3 91.65,92.25 91.64,92.2 91.64,92.15 90.87,92.15 92.27,93.56 92.29,93.74 92.4,93.81 92.42,93.81
DGND on L12-SIGNAL5 (solid shape): 90.75,36.76 90.78,36.76 90.8,36.75 91.73,35.83 91.74,35.81 91.74,35.79 91.74,34.53 91.74,34.51 91.76,34.49 92.36,33.89 92.37,33.87 92.38,33.85 92.38,32.75 92.38,32.73 92.39,32.72 93.73,31.37 93.74,31.36 93.75,31.34 93.75,30.62 93.75,30.6 93.76,30.58 94.54,29.81 94.55,29.78 94.55,29.75 94.54,29.74 94.52,29.72 94.27,29.72 94.25,29.72 94.23,29.73 91.71,32.25 91.7,32.27 91.7,32.29 91.7,33.67 91.7,33.69 91.71,33.7 91.44,34.26 91.18,33.7 91.18,33.69 91.19,33.67 91.19,32.52 91.18,32.49 91.16,32.47 91.14,32.47 91.11,32.47 89.94,33.64 89.93,33.66 89.92,33.68 89.92,36.05 89.93,36.07 89.94,36.09 90.32,36.46 90.34,36.47 90.52,36.55 90.63,36.71 90.64,36.72 90.66,36.74
DGND on L12-SIGNAL5 (solid shape): 83.29,85.56 83.31,85.54 83.32,85.52 83.32,85.29 83.32,85.27 83.33,85.25 83.86,84.72 83.88,84.7 83.88,84.68 83.88,84.09 83.88,84.07 83.89,84.06 85.02,82.93 85.03,82.92 85.03,82.9 85.03,82.37 85.04,82.35 85.05,82.33 86.95,80.43 86.96,80.42 86.98,80.42 88.59,80.42 88.61,80.41 88.63,80.39 88.64,80.37 88.63,80.34 88.44,80.15 88.43,80.14 88.41,80.14 84.45,80.14 84.43,80.14 84.42,80.15 84.36,80.21 84.34,80.29 84.32,80.36 84.32,80.39 84.37,80.47 84.39,80.49 84.42,80.49 84.51,80.49 84.53,80.5 84.55,80.51 85.01,80.97 85.02,80.99 85.03,81.01 85.03,81.43 85.02,81.45 85.01,81.46 82.68,83.8 82.66,83.83 82.68,83.87 82.78,83.97 82.81,83.98 82.83,83.97 83.32,84.19 82.99,84.61 82.96,84.62 82.9,84.68 82.89,84.7 82.89,84.72 82.89,85.45 82.89,85.47 82.9,85.49 82.96,85.55 82.99,85.55 83.08,85.57 83.16,85.6 83.17,85.61 83.2,85.61
DGND on L12-SIGNAL5 (solid shape): outline of 85 points within 50.38,117.14 52.79,120.94
DGND on L12-SIGNAL5 (solid shape): 124.92,41.72 124.94,41.73 124.97,41.73 124.98,41.72 125,41.7 125,41.54 125.01,41.52 125.02,41.5 125.77,40.75 125.78,40.73 125.79,40.71 125.79,40.29 125.77,40.26 125.74,40.24 124.55,40.24 124.53,40.24 124.51,40.23 124.13,39.84 124.12,39.83 124.11,39.81 124.11,38.22 124.11,38.2 124.1,38.18 123.36,37.44 123.33,37.43 123.31,37.43 123.21,37.45 123.19,37.47 123.19,37.49 123.05,37.68 122.83,37.75 122.8,37.75 122.73,37.81 122.72,37.83 122.72,37.85 122.72,38.96 122.72,38.98 122.73,39 122.8,39.06 122.83,39.06 123.11,39.18 123.19,39.48 123.19,39.49 123.19,39.51 123.25,39.58 123.27,39.6 123.29,39.6 123.41,39.6 123.43,39.61 123.45,39.62 123.68,39.85 123.76,39.97 123.78,40.1 123.78,40.3 123.76,40.44 123.68,40.56 123.54,40.7 123.42,40.78 123.28,40.8 122.77,40.8 122.73,40.82 122.72,40.85 122.72,41.13 122.72,41.15 122.73,41.17 123.18,41.62 123.2,41.63 123.22,41.63 124.81,41.63 124.83,41.64 124.85,41.65
DGND on L12-SIGNAL5 (solid shape): 208.4,22.89 208.42,22.88 208.44,22.86 208.46,22.83 208.47,22.81 208.46,22.79 208.75,22.29 209.09,22.75 209.09,22.76 209.09,22.79 209.15,22.86 209.17,22.88 209.19,22.89 210.74,22.89 210.76,22.88 210.77,22.87 211.09,22.55 211.11,22.54 211.13,22.54 212.05,22.54 212.07,22.53 212.08,22.53 212.22,22.46 212.38,22.46 212.39,22.46 212.41,22.45 212.49,22.4 212.5,22.38 212.5,22.36 212.5,21.94 212.5,21.91 212.48,21.9 212.41,21.84 212.39,21.83 212.38,21.84 211.95,21.44 212.5,21.23 212.51,21.25 212.55,21.24 212.85,20.94 212.87,20.91 212.86,20.88 212.86,20.87 212.83,20.85 211.11,20.85 211.09,20.86 211.07,20.87 210.16,21.78 210.15,21.79 210.13,21.79 207.7,21.79 207.67,21.8 207.66,21.81 207.6,21.88 207.6,21.99 207.58,22.06 207.57,22.08 207.58,22.1 208.35,22.87 208.36,22.88
DGND on L12-SIGNAL5 (solid shape): 210.44,24.14 210.46,24.14 210.48,24.12 210.53,24.06 210.54,24.04 210.54,24.03 210.88,23.64 211.22,24.03 211.22,24.04 211.22,24.06 211.28,24.12 211.3,24.14 211.32,24.14 212.62,24.14 212.64,24.14 212.65,24.13 213.28,23.5 213.29,23.49 213.29,23.47 213.29,21.64 213.29,21.63 213.25,21.56 213.22,21.49 213.2,21.47 213.1,21.45 213.07,21.45 213.05,21.46 213.03,21.48 213.02,21.5 213.01,21.52 213.01,23.13 213.01,23.15 213,23.17 212.68,23.49 212.67,23.51 212.17,23.78 212.1,23.22 212.11,23.21 212.12,23.19 212.11,23.09 212.1,23.07 212.07,23.05 212.05,23.05 211.34,23.05 211.32,23.05 211.3,23.06 210.99,23.38 210.97,23.39 210.95,23.39 208.17,23.39 208.15,23.39 208.14,23.38 207.4,22.64 207.38,22.63 207.36,22.62 205.17,22.62 205.15,22.63 205.14,22.64 204.59,23.18 204.58,23.21 204.58,23.23 204.59,23.25 204.61,23.27 204.94,23.27 204.96,23.27 204.98,23.28 205.83,24.13 205.84,24.14 205.86,24.14
DGND on L12-SIGNAL5 (solid shape): outline of 115 points within 43.22,62.9 46.72,81.64
DGND on L12-SIGNAL5 (solid shape): 151.4,124.35 151.5,124.32 151.61,124.33 151.62,124.33 151.64,124.33 151.71,124.27 151.73,124.26 151.73,124.23 151.73,121.17 151.66,120.8 151.45,120.49 150.36,119.4 149.83,118.61 149.65,117.67 149.65,115.03 149.55,114.53 149.26,114.11 145.92,110.76 145.47,110.11 145.29,109.33 145.29,109.32 145.28,109.3 145.2,109.23 145.18,109.23 145.1,109.24 145.02,109.23 145,109.24 144.93,109.3 144.92,109.32 144.92,109.34 145.14,110.24 145.66,111.01 148.63,113.97 149.16,114.77 149.35,115.71 149.35,118.62 149.4,118.92 149.57,119.16 150.7,120.29 151.12,120.92 151.26,121.66 151.26,124.25 151.27,124.28 151.29,124.29 151.37,124.35 151.39,124.35
DGND on L12-SIGNAL5 (solid shape): outline of 127 points within 181.52,91.98 186.52,104.35
DGND on L12-SIGNAL5 (solid shape): 221.99,23.18 222.02,23.19 222.05,23.19 222.06,23.19 222.08,23.16 222.08,17.4 222.08,17.38 222.07,17.36 221.05,16.35 221.03,16.34 221.01,16.33 214.89,16.33 214.87,16.34 214.83,16.37 214.81,16.37 205.18,16.37 205.15,16.38 205.13,16.4 205.12,16.42 205.13,16.45 205.86,17.18 205.88,17.19 205.9,17.2 206.6,17.2 206.62,17.19 206.64,17.18 206.7,17.1 206.7,17.08 206.7,17.07 207.03,16.62 207.35,17.07 207.35,17.08 207.36,17.1 207.41,17.18 207.43,17.19 207.45,17.2 214.89,17.2 214.91,17.19 214.93,17.17 215.34,17.02 215.57,17.38 215.57,17.42 215.63,17.48 215.65,17.49 215.67,17.5 216.22,17.5 216.24,17.49 216.25,17.48 216.75,16.99 216.76,16.98 216.78,16.97 219.2,16.97 219.22,16.97 219.24,16.96 219.3,16.89 219.3,16.86 219.64,16.48 219.98,16.86 219.99,16.89 220.05,16.96 220.06,16.97 220.08,16.97 220.42,16.97 220.44,16.98 220.46,16.99 221.71,18.24 221.72,18.26 221.73,18.28 221.73,22.89 221.73,22.91 221.74,22.93
DGND on L12-SIGNAL5 (solid shape): outline of 135 points within 47.18,29.83 52.28,40.17
DGND on L12-SIGNAL5 (solid shape): 81.57,31.77 82.99,30.35 83.01,30.34 83.03,30.33 84.72,30.33 84.74,30.33 84.76,30.32 94.15,20.92 94.17,20.91 94.19,20.91 97.69,20.91 97.72,20.9 97.73,20.89 97.79,20.81 97.79,20.78 97.79,20.77 98.11,20.31 98.43,20.77 98.43,20.78 98.43,20.81 98.49,20.89 98.51,20.9 98.53,20.91 99.19,20.91 99.22,20.9 99.23,20.89 99.29,20.81 99.29,20.78 99.29,20.77 99.61,20.31 99.93,20.77 99.93,20.78 99.93,20.81 99.99,20.89 100.01,20.9 100.03,20.91 100.69,20.91 100.72,20.9 100.73,20.89 100.79,20.81 100.79,20.78 100.79,20.77 101.05,20.32 101.45,20.66 101.45,20.67 101.47,20.7 101.57,20.74 101.6,20.74 101.63,20.73 103.42,18.93 103.44,18.91 103.43,18.88 103.43,18.86 103.4,18.85 92.83,18.85 92.81,18.85 92.8,18.86 87.03,24.63 87.01,24.64 86.99,24.65 86.22,24.65 86.2,24.65 86.18,24.66 84.09,26.75 84.08,26.77 84.08,26.79 84.08,28.91 84.07,28.93 84.06,28.95 81.51,31.5 81.5,31.51 81.5,31.53 81.5,31.72 81.51,31.75 81.53,31.77 81.54,31.77
DGND on L12-SIGNAL5 (solid shape): outline of 170 points within 118.68,96.52 120.45,107.91
DGND on L12-SIGNAL5 (solid shape): outline of 174 points within 108.63,62.54 115.13,69.18
DGND on L12-SIGNAL5 (solid shape): outline of 174 points within 134.13,103.55 136.93,108.62
DGND on L12-SIGNAL5 (solid shape): outline of 179 points within 50.52,116.74 53.88,131.49
DGND on L12-SIGNAL5 (solid shape): outline of 101 points within 83.01,88.93 94.9,97.46
DGND on L12-SIGNAL5 (solid shape): 150.26,124.26 150.34,124.27 150.36,124.26 150.43,124.2 150.45,124.19 150.45,124.16 150.45,121.66 150.36,121.23 150.12,120.86 148.99,119.74 148.65,119.23 148.53,118.62 148.53,115.71 148.41,115.08 148.05,114.54 145.09,111.58 144.38,110.54 144.1,109.3 144.1,109.29 144.09,109.27 144,109.21 143.97,109.21 143.96,109.21 143.52,109.08 143.55,108.62 143.57,108.6 143.57,108.51 143.55,108.49 143.48,108.09 143.81,107.87 143.83,107.87 143.85,107.85 143.89,107.75 143.9,107.72 143.88,107.7 143.04,106.86 142.73,106.39 142.62,105.84 142.62,105.09 142.53,104.62 142.27,104.22 141.36,103.32 141.33,103.31 141.3,103.31 141.2,103.38 141.19,103.41 141.2,103.43 141.3,103.82 141.34,104.23 141.34,106.22 141.4,106.52 141.57,106.78 142.66,107.87 142.98,108.34 143.09,108.89 143.09,109.54 143.18,110.04 143.47,110.46 147.46,114.46 148,115.27 148.19,116.23 148.19,119.45 148.25,119.7 148.39,119.92 149.53,121.06 149.93,121.66 150.07,122.36 150.07,124.17 150.07,124.19 150.09,124.21 150.16,124.26 150.18,124.27
DGND on L12-SIGNAL5 (solid shape): outline of 96 points within 102.17,74.25 111.41,78.34
DGND on L12-SIGNAL5 (solid shape): 146.53,145.66 146.55,145.65 146.62,145.56 146.68,145.48 147.29,144.88 147.35,144.79 147.37,144.68 147.37,137.72 147.54,136.87 148.03,136.14 152.46,131.7 152.8,131.2 152.92,130.61 152.92,120.94 152.81,120.38 151.41,118.82 150.94,118.12 150.78,117.3 150.78,114.8 150.64,114.09 150.24,113.49 147.05,110.3 146.56,109.57 146.39,108.71 146.39,107.82 146.32,107.47 146.12,107.18 145.77,106.83 145.47,106.37 145.36,105.83 145.36,104.51 145.35,104.5 144.83,104.5 144.77,104.5 144.74,104.51 144.72,104.53 144.71,104.55 144.7,104.58 144.71,104.61 144.84,104.87 144.88,105.15 144.88,105.93 144.95,106.25 145.13,106.52 145.68,107.07 145.99,107.54 146.1,108.1 146.1,109.24 146.2,109.76 146.49,110.19 149.84,113.53 150.3,114.22 150.46,115.03 150.46,117.67 150.58,118.3 150.94,118.83 152.03,119.92 152.41,120.49 152.55,121.17 152.55,129.14 152.2,130.89 151.2,132.38 145.77,137.81 145.46,138.28 145.35,138.84 145.35,145.38 145.36,145.42 145.4,145.43 145.89,145.43 146.17,145.49 146.4,145.65 146.41,145.66 146.43,145.67
DGND on L12-SIGNAL5 (solid shape): outline of 87 points within 119.89,115.22 131.16,159.7
DGND on L12-SIGNAL5 (solid shape): outline of 312 points within 77.84,29.39 87.69,40.87
DGND on L12-SIGNAL5 (solid shape): outline of 334 points within 45,35.43 50.52,49.32
DGND on L12-SIGNAL5 (solid shape): outline of 645 points within 116.09,93.33 128.78,161.2
DGND on L12-SIGNAL5 (solid shape): outline of 804 points within 48.02,47 58.31,68.89
DGND on L12-SIGNAL5 (solid shape): outline of 1066 points within 186.65,78.86 199.7,93.45
DGND on L14-SIGNAL6 (solid shape): 138.3,21.83 138.33,21.82 138.35,21.8 138.35,21.79 138.35,21.76 137.72,21.12 137.7,21.11 137.68,21.11 131.79,21.11 131.77,21.11 131.75,21.12 131.5,21.37 131.49,21.4 131.49,21.43 131.5,21.44 131.52,21.46 132.6,21.46 132.62,21.46 132.64,21.47 132.98,21.82 133,21.83 133.02,21.83
DGND on L14-SIGNAL6 (solid shape): 222.28,20.54 223.04,19.78 223.05,19.76 223.07,19.76 223.39,19.76 223.41,19.76 223.42,19.75 224.55,18.62 224.56,18.6 224.56,18.57 224.55,18.55 224.53,18.54 224.09,18.54 224.07,18.54 224.05,18.55 222.22,20.38 222.21,20.4 222.2,20.42 222.2,20.49 222.21,20.52 222.23,20.54 222.25,20.54
DGND on L14-SIGNAL6 (solid shape): 203.28,19.23 203.63,18.88 203.64,18.86 203.65,18.84 203.65,17.84 203.65,17.82 203.66,17.81 205.57,15.9 205.58,15.88 205.58,15.86 205.58,15.78 205.53,15.72 205.48,15.68 205.39,15.67 205.37,15.67 205.35,15.68 203.22,17.82 203.21,17.84 203.2,17.86 203.2,19.18 203.21,19.21 203.23,19.23 203.25,19.24
DGND on L14-SIGNAL6 (solid shape): 223.02,17.08 223.04,17.07 223.06,17.06 223.26,16.86 223.28,16.85 223.29,16.85 223.37,16.85 223.39,16.84 223.4,16.83 223.46,16.76 223.47,16.74 223.46,16.68 223.47,16.61 223.46,16.59 223.4,16.52 223.39,16.51 223.36,16.51 220.03,16.51 220.01,16.51 219.99,16.53 219.94,16.62 219.94,16.64 219.94,16.66 219.98,16.8 219.96,16.94 219.96,16.95 219.96,16.98 220.02,17.05 220.04,17.07 220.06,17.08
DGND on L14-SIGNAL6 (solid shape): 225.55,16.01 225.57,16.01 225.59,16 226.06,15.52 226.08,15.44 226.11,15.37 226.1,15.34 226.05,15.26 226.03,15.24 226.01,15.23 225.06,15.23 225.04,15.24 225.02,15.25 224.96,15.32 224.96,15.34 224.96,15.35 224.76,15.71 224.35,15.61 224.33,15.59 224.22,15.59 224.2,15.59 224.18,15.6 224.12,15.69 224.12,15.72 224.12,15.73 224.14,15.81 224.15,15.9 224.15,15.93 224.21,15.99 224.23,16.01 224.25,16.01
DGND on L14-SIGNAL6 (solid shape): 222.61,28.03 224.35,26.29 224.36,26.27 224.36,26.25 224.36,22.61 224.36,22.59 224.34,22.57 224.28,22.51 224.25,22.51 224.24,22.51 223.84,22.17 224.24,21.84 224.25,21.84 224.28,21.83 224.34,21.77 224.36,21.76 224.36,21.74 224.36,20.26 224.37,20.24 224.38,20.22 225.04,19.55 225.05,19.54 225.06,19.52 225.06,19.26 225.06,19.25 225.01,19.17 224.98,19.1 224.97,19.09 224.95,19.07 224.86,19.05 224.83,19.05 224.81,19.06 223.63,20.24 223.61,20.25 223.59,20.26 223.28,20.26 223.26,20.26 223.24,20.27 222.55,20.97 222.54,20.98 222.53,21 222.53,27.98 222.54,28.01 222.56,28.03 222.58,28.03
DGND on L14-SIGNAL6 (solid shape): 39.47,12.32 39.5,12.33 39.53,12.33 39.54,12.32 39.56,12.3 39.56,12.24 39.56,12.23 39.55,12.21 39.47,11.99 39.55,11.76 39.56,11.75 39.56,11.73 39.56,10.19 39.57,10.17 39.58,10.15 40.38,9.35 40.39,9.33 40.39,9.3 40.38,9.28 40.35,9.27 39.36,9.27 39.34,9.27 39.32,9.28 39.3,9.3 39.29,9.32 39.29,9.35 39.31,9.44 39.33,9.46 39.35,9.47 39.62,9.9 39.18,10.13 39.16,10.13 39.14,10.13 39.06,10.19 39.05,10.21 39.04,10.23 39.04,11.58 39.04,11.6 39.05,11.61 39.13,11.77 39.12,11.96
DGND on TOP: 191.63,121.76 191.63,119.73 190.61,119.73 190.36,119.48 187.56,119.48 187.56,118.97 190.36,118.97 190.74,118.59 191.25,118.59 191.37,118.72 191.37,119.48 192.26,119.48 192.26,121.76
DGND on TOP: 181.72,121.76 181.72,119.73 182.74,119.73 182.99,119.48 185.78,119.48 185.78,118.97 182.99,118.97 182.61,118.59 182.1,118.59 181.97,118.72 181.97,119.48 181.09,119.48 181.09,121.76
DGND on TOP: 57.95,178.65 57.95,175.29 59.47,175.29 59.47,178.65
DGND on TOP: 170.29,121.76 170.29,119.73 171.31,119.73 171.56,119.48 174.35,119.48 174.35,118.97 171.56,118.97 171.18,118.59 170.67,118.59 170.54,118.72 170.54,119.48 169.66,119.48 169.66,121.76
DGND on TOP: 73.34,101.89 75.37,101.89 75.37,100.87 75.62,100.62 75.62,97.82 76.13,97.82 76.13,100.62 76.51,101 76.51,101.51 76.39,101.63 75.62,101.63 75.62,102.52 73.34,102.52
DGND on TOP: 87.99,15.04 87.99,13.09 90.08,13.09 90.08,15.04
DGND on TOP: 159.57,50.2 159.57,54.39 157.41,54.39 157.41,53.25 158.56,53.25 158.56,51.34 156.52,51.34 156.14,50.96 156.14,50.07 159.44,50.07
DGND on TOP: 62.92,15.02 62.92,13.06 65.01,13.06 65.01,15.02
DGND on TOP: 73.34,114.33 75.37,114.33 75.37,115.35 75.62,115.6 75.62,118.4 76.13,118.4 76.13,115.6 76.51,115.22 76.51,114.71 76.39,114.59 75.62,114.59 75.62,113.7 73.34,113.7
DGND on TOP: 73.34,103.16 75.37,103.16 75.37,104.17 75.62,104.43 75.62,107.22 76.13,107.22 76.13,104.43 76.51,104.05 76.51,103.54 76.39,103.41 75.62,103.41 75.62,102.52 73.34,102.52
DGND on TOP: 180.45,121.76 180.45,119.73 179.43,119.73 179.18,119.48 176.39,119.48 176.39,118.97 179.18,118.97 179.56,118.59 180.07,118.59 180.2,118.72 180.2,119.48 181.09,119.48 181.09,121.76
DGND on TOP: 169.02,121.76 169.02,119.73 168,119.73 167.75,119.48 164.96,119.48 164.96,118.97 167.75,118.97 168.13,118.59 168.64,118.59 168.77,118.72 168.77,119.48 169.66,119.48 169.66,121.76
DGND on TOP: 192.9,121.76 192.9,119.73 193.91,119.73 194.17,119.48 196.96,119.48 196.96,118.97 194.17,118.97 193.79,118.59 193.28,118.59 193.15,118.72 193.15,119.48 192.26,119.48 192.26,121.76
DGND on TOP: 186.97,0.82 186.97,1.6 185.76,2.81 184.55,1.6 184.55,0.82 184.49,0.76 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,188.94 17.72,187.69 18.95,188.9 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,188.88 22.5,187.69 23.7,188.9 23.7,189.68 23.75,189.74 243,189.74 243,0.76 212.38,0.76 212.33,0.82 212.33,1.6 211.11,2.81 209.9,1.6 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.6 206.36,2.81 205.15,1.6 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.6 190.51,2.81 189.3,1.6 189.3,0.82 189.24,0.76 187.02,0.76 ; 5 cut-outs
DGND on TOP: 73.34,113.06 75.37,113.06 75.37,112.05 75.62,111.79 75.62,109 76.13,109 76.13,111.79 76.51,112.17 76.51,112.68 76.39,112.81 75.62,112.81 75.62,113.7 73.34,113.7
DGND on BOTTOM: 186.97,0.82 186.97,1.6 185.76,2.81 184.55,1.6 184.55,0.82 184.49,0.76 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,188.94 17.72,187.69 18.95,188.9 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,188.88 22.5,187.69 23.7,188.9 23.7,189.68 23.75,189.74 243,189.74 243,0.76 212.38,0.76 212.33,0.82 212.33,1.6 211.11,2.81 209.9,1.6 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.6 206.36,2.81 205.15,1.6 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.6 190.51,2.81 189.3,1.6 189.3,0.82 189.24,0.76 187.02,0.76 ; 2 cut-outs
DGND on BOTTOM: 204.97,42.53 206.88,42.53 206.88,38.55 204.97,38.55
DGND on BOTTOM: 199.23,41.85 197.33,41.85 197.33,38.55 199.23,38.55
