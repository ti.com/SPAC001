# Allegro board PROC184E1_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on BOTTOM: 179.36,75.6 179.36,72.93 179.74,72.93 179.97,72.7 179.97,70.06 179.79,69.88 177.61,69.88 177.61,66.33 178.24,65.69 178.24,62.64 173.92,62.64 173.92,65.82 174.56,66.45 174.56,69.02 173.95,69.63 173.29,69.63 173.29,71.28 173.34,71.28 173.34,74.66 173.03,74.96 172.78,74.96 172.53,75.22 172.53,76.4 172.16,76.76 172.16,78.05 172.62,78.5 174.56,78.5 174.56,81.82 173.92,82.46 173.92,85.5 178.24,85.5 178.24,82.46 178.21,82.46 177.59,81.83 177.61,81.82 177.61,78.57 180.02,78.57 180.02,75.88 179.74,75.6
DGND on BOTTOM: 7.12,41.82 7.12,38.95 15.63,38.95 15.63,41.82
DGND on BOTTOM: 232.7,151.25 232.7,159.38 243,159.38 243,151.25
DGND on BOTTOM: 17.15,129.67 17.15,126.93 21.78,126.93 21.78,129.67
DGND on BOTTOM: 179.15,24.19 179.15,23.12 175.62,23.12 175.62,24.19
DGND on BOTTOM: 126.53,171.08 135.64,171.08 135.64,169.5 134.07,169.5 134.04,169.53 132.49,169.53 132.29,169.32 132.29,166.5 132.14,166.35 130.89,166.35 130.72,166.53 130.72,168.94 130.21,169.45 126.53,169.45
DGND on BOTTOM: 32.32,37.24 32.32,35.59 36.38,35.59 36.38,37.24
DGND on BOTTOM: 173.47,154.07 173.47,147.32 179.65,147.32 179.65,154.07
DGND on BOTTOM: 138.01,188.63 138.01,181.59 141.82,181.59 141.82,188.63
DGND on BOTTOM: 207.96,95.54 209.86,95.54 209.86,92.23 207.96,92.23
DGND on BOTTOM: 110.4,176.03 110.4,166.63 110.14,166.38 109.2,166.38 108.82,166.76 108.82,168.41 108.85,168.43 108.85,169.98 108.64,170.19 105.82,170.19 105.67,170.34 105.67,171.58 105.85,171.76 108.26,171.76 108.77,172.27 108.77,176.18 108.95,176.36 110.07,176.36
DGND on BOTTOM: 8.97,133.15 8.97,131.22 12.28,131.22 12.28,133.15
DGND on BOTTOM: 116.14,114.75 116.14,116.89 115.77,117.25 115.77,118.19 117.69,118.19 117.69,117.32 117.15,117.32 117.15,115.25 117.98,115.25 117.98,114.75
DGND on BOTTOM: 202.22,95.54 200.31,95.54 200.31,92.23 202.22,92.23
DGND on BOTTOM: 231.61,137.03 231.61,130.55 242.32,130.55 242.32,137.03
DGND on BOTTOM: 175.45,186.24 175.45,184.46 178.7,184.46 178.7,186.24
DGND on BOTTOM: 43.77,71.03 43.77,67.85 45.53,67.85 45.53,71.03
DGND on BOTTOM: 8.97,156.45 8.97,154.52 12.28,154.52 12.28,156.45
DGND on BOTTOM: 219.85,82.66 222.06,82.66 222.06,78.52 219.85,78.52
DGND on BOTTOM: 92.41,125.66 82.74,125.66 82.74,127.31 86.55,127.31 86.55,130.23 86.7,130.39 87.94,130.39 88.12,130.21 88.12,127.29 92.41,127.29
DGND on BOTTOM: 215.71,75.37 215.71,63.15 218.75,63.15 218.75,64.68 219.26,65.18 226.75,65.18 226.75,75.37
DGND on L2-GND1, L6-GND3, L11-GND4, L13-GND5: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76
DGND on L4-GND2: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 1 cut-out
DGND on L8-PWR1: 33.89,189.31 128.33,189.31 129.95,187.69 129.95,174.15 128.23,172.42 83.22,172.42 79.33,176.31 79.33,181.19 53.37,181.19 53.37,166.71 50.76,164.09 32.22,164.09 30.79,165.51 30.79,186.21
DGND on L8-PWR1: 6.28,159.38 16.7,159.38 18.65,157.43 18.65,86.21 20.91,83.95 20.91,77.55 21.67,76.78 21.67,29.62 25.03,26.26 47.15,26.26 47.2,26.31 47.76,26.31 56.24,17.83 69.05,17.83 70.14,16.74 70.14,8.89 62.09,0.84 6.56,0.84 6.13,1.27 6.13,159.23 ; 1 cut-out
DGND on L8-PWR1: 213.55,189.59 241.84,189.59 242.55,188.87 242.55,167.69 229.88,167.69 229.47,168.1 229.47,180.8 228.89,181.38 217.99,181.38 217.08,180.47 217.08,176.68 216.67,176.28 215.22,176.28 213.55,177.95
DGND on L8-PWR1: 212.2,67.9 242.02,67.9 242.4,67.52 242.4,10.24 235.62,3.46 203.21,3.46 200.8,5.87 200.8,31.91 202.75,33.87 211.06,33.87 212.2,35.01
DGND on L8-PWR1: 152.74,81.05 149.14,81.05 149.14,81.04 147.78,81.04 145.73,78.99 145.73,77.72 145.98,77.47 147.2,77.47 147.23,77.5 152.48,77.5 156.6,73.39 156.6,64.62 155.63,63.65 136.71,63.65 128.61,71.76 128.61,79.65 128.99,80.04 128.99,81.81 128.61,82.19 128.61,86.13 131.34,88.86 136.8,88.86 141.82,93.88 155.53,93.88 156.68,92.74 156.68,84.98
DGND on L9-PWR2: 213.55,189.59 241.84,189.59 242.98,188.44 242.98,152.35 229.47,152.35 229.47,180.8 228.89,181.38 217.99,181.38 217.08,180.47 217.08,176.68 216.67,176.28 215.22,176.28 213.55,177.95
DGND on L15-GND6: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 11 cut-outs
V1V1_VDDUSB on TOP: 58.58,164.47 61.22,164.47 61.22,163.38 58.58,163.38
V1V1_VDDUSB on L8-PWR1: 54.26,180.55 54.26,162.19 77.73,162.19 77.73,180.55
V1V8_FT2232 on L7-SIGNAL3: 191.85,26.88 189.62,24.65 187.51,24.65 185.07,27.08 181.53,27.08 181.53,23.4 183.83,23.4 183.83,18.67 182.34,17.18 182.34,15.15 187.87,15.15 191.65,11.37 192.19,11.37 193.34,12.52 193.34,13.23 195.39,15.27 195.39,26.88
V3V3_DP0 on TOP: 125.06,174.54 124.82,174.78 124.82,178.16 126.39,178.16 126.39,174.53 126.7,174.22 129.3,174.22 129.68,173.83 129.68,172.67 129.13,172.12 127.47,172.12 125.06,174.53
V3V3_DP0 on BOTTOM: 130.44,167.7 130.44,169.17 125.84,169.17 125.84,173.23 126.27,173.66 126.27,176.36 126.02,176.61 125.21,176.61 124.93,176.33 124.93,168.28 125.51,167.7
V3V3_DP1 on TOP: 99.16,174.32 98.95,174.78 98.95,178.16 100.65,178.16 100.65,174.4 100.99,174.06 103.35,174.06 103.47,173.94 103.47,172.97 103,172.5 100.98,172.5
V3V3_DP1 on BOTTOM: 108.34,172.07 107.2,172.07 107.2,173.31 106.89,173.62 106.89,175.42 106.66,175.65 104.76,175.65 104.22,175.12 104.22,174.51 103.64,173.92 101.25,173.92 100.95,174.23 98.97,174.23 98.97,176.66 102.52,176.66 103.11,177.25 108.16,177.25 108.34,177.07
V3V3_FT2232 on L7-SIGNAL3: 175.52,8.74 204.17,8.74 204.17,27.33 201.83,29.68 187.77,29.68 187.77,25.43 189.24,25.43 191.35,27.54 195.82,27.54 196.15,27.21 196.15,14.64 194.32,12.81 194.32,12.07 192.97,10.73 191.19,10.73 187.44,14.49 181.31,14.49 181.31,17.38 183.24,19.31 183.24,23.15 176.46,23.15 175.52,22.21
V3V3_FT4232 on L3-SIGNAL1: 213.9,26.98 220.96,26.98 225.31,22.64 225.31,11.62 217.72,4.03 204.39,4.03 201.74,6.69 201.74,14.51 203.01,15.78 204.53,15.78 205.29,15.02 211.39,15.02 212.28,14.13 212.28,13.62 211.39,12.73 204.78,12.73 204.78,9.7 208.46,6.02 216.25,6.02 221.12,10.89 221.12,22.54 219.57,24.09 214.23,24.09 210.27,20.12 210.27,17.71 209.1,16.54 206.89,16.54 206.71,16.72 206.71,21.04 208.89,23.21 210.13,23.21
V5V0_OPAMP on TOP: 24.29,11.82 24.29,7.91 25.74,7.91 25.74,11.82
V5V0_OPAMP on L12-SIGNAL5: 23.53,23.78 26.4,23.78 26.4,13.32 28.02,11.69 32.75,11.69 32.75,20.18 30.41,20.18 30.41,21.7 41.99,21.7 41.99,20.02 36.23,20.02 34.76,18.55 34.76,10.83 33.46,9.53 25.51,9.53 24.16,10.88 24.16,21.67 23.53,22.31
V5V0_VOUT on TOP: 36.46,30.67 36.46,29.55 40.65,29.55 40.65,30.67
V12V0_VOUT on BOTTOM: 21.52,12.61 21.52,9.05 22.41,9.05 22.41,12.61
V12V0_VSUP1 on BOTTOM: 9.81,38.39 16.95,38.39 16.95,34.37 9.81,34.37
VBAT_LIN on BOTTOM: 6.76,33.41 6.76,30.26 12.2,30.26 12.2,33.41
VBAT_RTC on BOTTOM: 144.51,37.85 151.8,37.85 151.8,34.45 144.15,34.45 144.15,30.79 139.28,30.79 139.28,33.61 140.29,33.61 140.29,31.73 142.07,31.73 142.07,35.42
VBUS_5V_CONN1 on TOP: 46.92,180.14 48.98,180.14 48.98,176.28 50.25,175.01 50.25,172.35 46.92,172.35 46.92,173.24 43.67,173.24 43.67,174.68 46.92,174.68
VBUS_5V_CONN2 on TOP: 47.1,182.48 53.83,182.48 56.17,180.14 56.17,178.39 56.88,177.68 56.88,175.37 53.78,175.37 53.78,179.1 52.18,180.7 47.1,180.7
VBUS_5V_CONN2 on BOTTOM: 52.87,180.75 52.87,179.33 54.72,179.33 54.72,180.75
VBUS_USBC_CONN on TOP: 148.29,185.83 148.29,184.98 148.24,184.92 148.24,183.14 147.99,183.14 147.99,182.13 147.86,182 147.76,182 147.66,182.1 147.66,183.14 147.22,183.14 147.22,183.7 147.91,183.7 147.91,184.85 147.84,184.92 147.84,185.83
VBUS_USBC_CONN on TOP: 138.63,179.48 138.63,178.1 139.81,178.1 139.81,179.48
VBUS_USBC_CONN on TOP: 150.35,184.84 150.35,183.7 150.2,183.7 150.2,183.14 150.65,183.14 150.65,182.13 150.78,182 150.88,182 150.98,182.1 150.98,183.14 151.26,183.14 151.26,183.7 150.76,183.7 150.76,184.84 150.83,184.92 150.83,185.78 150.76,185.86 150.38,185.86 150.33,185.81 150.33,184.87
VBUS_USBC_CONN on L8-PWR1: 141.09,176.44 184.64,176.44 184.64,187.64 184.59,187.64 182.92,189.31 157.85,189.31 156.18,187.64 138.95,187.64 138.95,178.58
VBUS_XDS_USB on TOP: 23.44,176.72 23.44,176.73 22.86,176.73 21.82,177.77 21.82,179.19 19.97,181.04 19.07,181.04 17.33,182.79 17.33,184.44 18.58,185.68 18.58,187.1 19.03,187.1 19.03,184.87 18.73,184.56 18.73,183.42 19.08,183.07 22.91,183.07 24.44,181.54 24.44,178.18 25.81,178.18 25.81,176.72
VCC1V2_UFS on BOTTOM: 137.14,148.06 145.75,148.06 145.75,148.85 140.2,148.85 140.2,149.29 139.26,150.23 136.84,150.23 136.76,150.15 136.76,148.45
VCC1V8_EMMC on TOP: 165.46,100.18 165.46,91.35 166.26,91.35 166.26,100.18
VCC1V8_EMMC on BOTTOM: 176.72,97.09 177.2,97.09 177.58,96.71 179.41,96.71 179.41,97.47 180.75,97.47 180.75,95.84 178.82,95.84 178.67,95.99 176.72,95.99
VCC1V8_EMMC on L3-SIGNAL1: 178.48,97.69 180.81,97.69 181.16,97.33 181.16,94.2 180.95,93.99 176.56,93.99 176.35,94.2 172.1,94.2 170.25,92.35 166.14,92.35 165.4,93.09 165.4,101.35 165.7,101.66 171.27,101.66 175.53,97.39 178.19,97.39
VCC1V8_EMMC on L8-PWR1: 165.41,101.63 181.16,101.63 181.16,95.66 179.92,94.42 167.75,94.42 166.18,95.99 166.18,98.84 165.41,99.6
VCC3V3_EMMC on BOTTOM: 175.67,100.92 175.67,98.79 177.25,98.79 177.25,100.92
VCC3V3_XDS on TOP: 24.15,176.42 24.15,171.61 28.13,171.61 28.13,172.75 26.53,172.75 26.25,173.03 26.25,174.94 25.84,175.34 25.84,176.42
VCC3V3_XDS on L8-PWR1: 6.05,186.04 6.05,160.43 20.89,160.43 29.4,168.94 29.4,186.04
VCC_1V1 on TOP: 55.66,165.54 55.66,163.53 58.05,163.53 58.05,165.54
VCC_1V1 on L5-SIGNAL2: 38.82,169.07 38.82,167.72 41.94,164.6 41.94,164.52 58.48,164.52 58.48,166.94 42.5,166.94 40.37,169.07
VCC_1V1 on L7-SIGNAL3: 75.9,30.34 78.78,27.46 78.78,24.09 76.51,21.83 74.61,21.83 74.61,20.38 73.21,20.38 73.21,21.9 70.32,21.9 68,19.59 68,15.4 58.23,15.4 58.23,15.48 28.2,15.48 7.02,36.66 7.02,169.81 41,169.81 41,165.77 12.86,165.77 9.53,162.44 9.53,80.02 14.61,74.94 14.61,34.3 28.81,20.1 61.91,20.1 66.35,24.54 66.35,28.48 68.21,30.34
VCC_1V2 on BOTTOM: 136.61,154.97 139.25,154.97 139.25,150.68 136.61,150.68
VCC_1V2 on BOTTOM: 88.43,127.72 88.43,128.86 89.67,128.86 89.98,129.17 93.3,129.17 93.89,129.75 93.89,133.36 96.17,135.64 99.02,135.64 99.02,132.82 95.64,132.82 95.26,132.44 95.26,128.79 94.19,127.72
VCC_1V2 on L7-SIGNAL3: 82.48,129.01 94.18,129.01 99.3,123.89 106.7,123.89 108.07,125.25 114.26,125.25 114.64,125.64 114.64,129.04 114.08,129.6 114.08,130.13 114.16,130.13 114.16,135.11 113.52,135.75 113.52,140.22 125.43,152.13 138.59,152.13 138.59,155.66 122.11,155.66 101.31,134.86 85.84,134.86 82.48,131.5
VCC_12V0 on TOP: 37.83,81.8 37.83,79.92 40.7,79.92 40.7,81.8
VCC_12V0 on TOP: 18.17,159.7 21.27,159.7 22.61,158.35 22.61,153.17 20.79,151.34 20.79,149.13 20.18,148.52 17.61,148.52 17.23,148.9 17.23,158.76
VCC_12V0 on TOP: 226.75,73.44 226.75,72.3 232.85,72.3 232.85,73.44 233.74,73.44 233.74,80.3 232.33,81.7 217.77,81.7 216.89,80.82 216.89,76.41 223.78,76.41
VCC_12V0 on TOP: 213.77,32.29 213.77,28.35 215.68,28.35 215.68,32.29
VCC_12V0 on TOP: 173,172.32 174,172.32 174.37,172.69 174.37,173.34 174.48,173.45 175.57,173.45 175.62,173.4 175.62,170.94 174.28,169.59 169.95,169.59 164.53,164.17 160.59,164.17 160.59,173.08 172.23,173.08
VCC_12V0 on BOTTOM: 21.52,8.8 21.52,4.1 22.41,4.1 22.41,8.8
VCC_12V0 on BOTTOM: 238.57,81.8 238.57,80.22 241.84,80.22 241.84,81.8
VCC_12V0 on BOTTOM: 216.85,78.49 219.44,78.49 219.44,85.73 216.85,85.73
VCC_12V0 on BOTTOM: 17.38,130.23 17.38,132.98 19.95,135.54 19.95,139.5 22.72,139.5 22.72,131.48 21.47,130.23
VCC_12V0 on BOTTOM: 215.88,28.36 215.88,32.04 213.98,32.04 213.98,28.36
VCC_12V0 on BOTTOM: 13.09,32.62 13.09,30.41 16.39,30.41 16.39,32.62
VCC_12V0 on BOTTOM: 38.54,86.6 38.54,84.46 40.95,84.46 40.95,82.41 40.09,81.54 38.08,81.54 38.08,79.92 41.33,79.92 42.6,81.19 42.6,86.6
VCC_12V0 on BOTTOM: 19.08,155.2 19.08,151.62 21.93,151.62 21.93,152.59 22.72,153.37 22.72,155.2
VCC_12V0 on L7-SIGNAL3: 233.49,5.37 233.49,78.65 234.12,79.28 242.5,79.28 242.5,86.52 224.09,86.52 222.18,84.61 222.18,5.37
VCC_12V0 on L9-PWR2: 97.85,165.64 179.79,165.64 218.37,127.06 218.37,81.06 227.01,81.06 228.79,79.28 228.79,39.02 217.61,27.85 192.72,27.85 192.72,71.66 189.04,75.34 189.04,123.6 169.71,142.93 91.83,142.93 89.7,140.8 88.02,140.8 87.31,141.51 87.31,143.42 56.75,143.42 56.75,125.86 40.7,125.86 40.7,76.41 27.19,62.9 27.19,19.26 22.93,15.01 22.93,3.31 5.57,3.31 5.57,162.44 10.55,167.42 17.35,167.7 95.79,167.7
VCC_CSI_IO on BOTTOM: 204.33,96.17 204.33,88.9 202.6,88.9 202.6,96.17
VCC_CSI_IO on BOTTOM: 179.23,27.11 179.23,25.66 180.91,25.66 180.91,27.11
VCC_CSI_IO on BOTTOM: 201.34,42.37 201.34,35.22 199.61,35.22 199.61,42.37
VCC_CSI_IO on L7-SIGNAL3: 178.02,26.24 178.02,32.05 178.25,32.29 189.8,32.29 196.27,38.77 196.27,48.8 191.19,53.88 187.77,53.88 185.86,55.79 185.86,58.39 195.2,58.39 202.12,65.31 202.12,97.7 208.34,97.7 208.34,54.77 212.28,50.83 212.28,42.2 200.21,30.13 182.56,30.13 181.24,28.81 181.24,26.02 181.16,25.94 178.31,25.94
VCC_LM5140 on TOP (solid shape): 224.2,106.29 224.22,106.28 224.23,106.27 224.37,106.13 224.39,106.11 224.39,106.09 224.39,103.43 224.39,103.41 224.37,103.39 224.25,103.27 224.23,103.26 224.21,103.25 222.83,103.25 222.81,103.26 222.79,103.27 222.25,103.81 222.23,103.82 222.21,103.82 221.99,103.82 221.98,103.82 220.34,103.82 220.32,103.82 220.3,103.83 220.24,103.9 220.24,103.93 220.2,104.11 220.07,104.25 220.06,104.25 219.96,104.35 219.94,104.36 219.92,104.37 218.75,104.37 218.72,104.38 218.7,104.42 218.7,105.16 218.72,105.19 218.75,105.21 219.92,105.21 219.94,105.21 219.96,105.22 220.06,105.32 220.07,105.33 220.2,105.48 220.23,105.68 220.23,105.69 220.24,105.71 220.29,105.78 220.31,105.79 220.33,105.79 222.27,105.79 222.29,105.8 222.3,105.81 222.77,106.27 222.78,106.28 222.8,106.29
VCC_USBC_PD_5V on BOTTOM (solid shape): outline of 170 points within 167.73,179.21 177.1,183.78
VCC_USBC_PD_5V on TOP: 175.85,182.91 175.85,177.91 177.07,177.91 177.07,182.91
VCCA_1V2 on TOP: 100.97,136.43 100.97,134.17 102.88,134.17 102.88,136.43
VCCA_1V2 on BOTTOM: 99.53,135.69 99.53,133.94 102.68,133.94 102.68,135.69
VCCA_1V2 on L12-SIGNAL5: 100.39,135.77 111.46,135.77 111.46,133.71 102.62,133.71 101.51,132.6 101.51,129.57 103.34,127.74 103.34,126.14 103.56,125.92 107.15,125.92 109.99,123.07 109.99,120.53 109.89,120.43 109.51,120.43 109.38,120.56 109.38,121.31 105.59,125.1 102.73,125.1 102.56,125.27 102.56,126.87 99.98,129.45 99.98,135.36
VCCA_3V3 on TOP: 81.85,66.73 81.85,68.21 81.09,68.21 80.81,68.49 80.81,69.88 79.33,69.88 79.33,66.73
VCCA_3V3 on TOP: 80.88,79.5 79.37,79.5 79.23,79.36 78.06,79.36 78.06,77.58 80.88,77.58
VCCA_3V3 on TOP: 178.5,77.7 178.5,78.58 179.64,79.72 179.64,85.75 180.33,86.44 186.21,86.44 187.43,87.66 187.43,88.61 187.65,88.83 188.52,88.83 188.66,88.97 188.66,89.54 193.5,89.54 193.5,96.07 190.7,96.07 190.4,96.38 181.03,96.38 181.03,94.9 179.13,93 173.01,93 171.69,91.67 171.69,87.36 172.15,86.89 172.15,86.11 172.63,85.63 172.63,81.95 172.53,81.84 172.53,79.63 173.68,78.47 173.68,77.7 174.05,77.7 174.05,78.98 174.27,79.2 174.27,81.98 174.04,82.22 173.85,82.22 173.8,82.27 173.8,85.73 173.87,85.8 178,85.8 178.39,85.41 178.39,82.31 178.28,82.2 178.02,82.2 177.88,82.05 177.88,79.34 178.11,79.1 178.11,77.7 178.14,77.68 178.49,77.68
VCCA_3V3 on TOP: 85.8,79.41 85.8,77.54 88.48,77.54 88.48,79.41
VCCA_3V3 on TOP: 161.98,53.88 161.86,54.01 160.08,54.01 159.83,53.75 159.83,52.05 161.98,52.05
VCCA_3V3 on TOP: 74.65,72.74 77.34,72.74 77.34,73.72 77.55,73.93 78.05,73.93 78.05,74.73 76.97,74.73 75.93,73.69 74.65,73.69
VCCA_3V3 on TOP: 171.48,26.32 173.92,26.32 174.51,25.74 174.51,23.68 172.73,23.68 172.4,23.35 172.4,22.92 172.3,22.82 171.48,22.82
VCCA_3V3 on TOP: 106.66,118.9 107.5,118.9 108.77,117.63 108.77,116.7 108.34,116.7 107.58,117.46 106.66,117.46
VCCA_3V3 on TOP: 85.15,72.73 86.8,72.73 86.8,74.82 85.15,74.82
VCCA_3V3 on TOP: 179.76,73.69 183.51,73.69 183.51,74.84 181.67,74.84 180.91,74.07 179.76,74.07
VCCA_3V3 on BOTTOM: 173.16,71.13 173.16,74.28 172.4,75.04 172.4,76.61 172.07,76.61 171.81,76.87 171.81,77.72 171.67,77.86 171.18,77.86 170.87,77.55 170.87,71.58 171.05,71.41 171.89,71.41 172.17,71.13
VCCA_3V3 on L9-PWR2: 57.49,96.81 57.49,142.78 86.67,142.78 86.67,141.21 87.69,140.19 90,140.19 90.02,140.2 91.75,141.94 169.43,141.94 171.16,140.2 188.02,123.35 188.02,75.04 191.83,71.23 191.83,32.16 185,25.33 171.86,25.33 171.56,25.64 171.56,28.75 172.61,28.75 184.47,40.61 184.47,65.96 179.26,71.18 173.13,71.18 167.93,76.39 167.93,82.91 166.81,84.03 166.81,104.5 151.52,119.79 110.37,119.79 108.36,117.79 104.66,117.79 102.65,119.79 78.89,119.79 78.03,118.93 78.03,97.31 88.66,86.67 90.08,85.25 90.08,71.58 82.66,71.58 81.62,70.54 81.62,65.72 80.68,64.78 79.3,64.78 78.21,65.87 73.94,65.87 71.99,67.81 71.99,82.3
VCCA_3V3 on L10-SIGNAL4: 177.54,92.69 185.63,92.69 185.63,62.61 182.28,59.26 182.28,52.58 180.17,50.47 161.25,50.47 160.33,49.56 157.23,49.56 156.78,50.01 156.78,57.38 161.86,62.46 171.59,62.46 175.29,66.17 175.29,76.19 177.54,78.43
VCCA_3V3_CORE on TOP: 67.45,96.2 67.45,131 77.66,131 77.66,119.9 77.25,119.49 77.25,118.93 77.28,118.9 77.28,116.11 77.25,116.11 77.25,111.28 77.28,111.28 77.28,108.3 77.25,108.27 77.25,107.75 77.28,107.73 77.28,104.93 77.25,104.93 77.25,100.11 77.28,100.11 77.28,97.12 77.25,97.1 77.25,96.2 ; 2 cut-outs
VCCA_3V3_CORE on L8-PWR1: 64.32,129.19 56.19,121.06 56.19,100.92 60,97.11 77.35,97.11 77.35,129.19
VCCA_3V3_CPU_AVS on TOP: 185.23,131 187.31,128.91 201.81,128.91 201.81,117.82 194.68,117.82 194.64,117.86 194.64,118.65 194.69,118.7 197.19,118.7 197.26,118.78 197.26,119.67 197.19,119.74 194.29,119.74 194.06,119.97 193.18,119.97 193.12,120.02 193.12,121.9 192.9,122.13 191.47,122.13 191.3,121.95 191.3,118.52 190.61,117.84 162.1,117.84 161.53,118.41 160.46,118.41 160.48,129.82 161.65,131 ; 5 cut-outs
VCCA_3V3_CPU_AVS on L7-SIGNAL3: 162.57,130.84 185.35,130.84 187.38,128.81 199.07,128.81 199.58,128.3 199.58,118.65 199.04,118.12 163.21,118.12 162.42,118.91 162.42,130.69
VCCA_3V3_DDR on TOP: 193,89.29 188.78,89.29 188.78,84.89 193,84.89
VCCA_3V3_DDR on TOP: 178.11,66.71 178.11,70.26 178.24,70.39 178.49,70.39 178.49,69.37 179.38,68.49 179.38,66.71
VCCA_3V3_DDR on TOP: 174.03,66.71 174.03,70.28 173.92,70.39 173.67,70.39 173.67,69.37 172.78,68.49 172.78,66.71
VCCA_3V3_DDR on L7-SIGNAL3: 181.49,93.38 190.94,93.38 197.16,87.15 197.16,69.25 186.75,58.83 173.95,58.83 171.99,60.79 171.99,70.92 181.49,70.92
VCCAD_5V0 on TOP: 53.15,19.21 53.27,19.34 57.01,19.34 57.01,17.94 52.66,17.94 52.13,18.47 51.6,18.47 51.47,18.6 51.01,18.6 50.83,18.78 50.83,19.11 50.94,19.21
VCCDA_5V0 on TOP: 59.6,9.02 59.6,7.88 53.96,7.88 53.96,8.36 54.87,8.36 55.53,9.02
VDD1_DDR_1V8 on TOP: 153.45,54.59 153.45,51.87 154.77,51.87 154.77,54.59
VDD1_DDR_1V8 on L12-SIGNAL5: 161.79,100.81 161.79,54.26 158.98,51.45 144.99,51.45 142.93,53.51 142.93,98.67 146.37,102.12 160.49,102.12 ; 2 cut-outs
VDD1_DDR_1V8_REG on TOP: 158.43,51.98 158.43,52.99 157.16,52.99 157.16,54.52 155.1,54.52 155.1,51.98
VDD_1V0 on TOP: 109.33,29.04 115.17,29.04 115.17,30.18 113.93,30.18 113.62,30.49 109.33,30.49
VDD_1V0 on L7-SIGNAL3: 99.12,20.35 99.12,21.11 98.74,21.5 94.67,21.5 94.04,22.13 94.04,32.16 114.99,32.16 114.99,23.15 101.41,23.15 100.39,22.13 100.39,20.35
VDD_2V5 on L7-SIGNAL3: 70.29,21.32 72.78,21.32 72.78,19.78 75.12,19.78 75.12,21.32 78.44,21.32 78.89,21.76 83,21.76 83.73,22.49 85.89,22.49 85.89,17.66 70.29,17.66
VDD_CORE_0V8 on TOP: 87.74,92.23 87.74,96.73 79.89,96.73 79.89,119.03 89.67,119.03 90.99,117.71 96.34,117.71 96.34,114.05 95.44,113.15 95.44,97.16 96.38,96.22 102.8,96.22 103.66,95.37 103.66,93.7 102.19,92.23
VDD_CORE_0V8 on BOTTOM: 79.66,96.73 87.63,96.73 87.92,96.44 87.92,93.37 95.26,93.37 95.26,91.36 95.99,91.36 96.02,91.34 102.17,91.34 102.73,91.9 102.73,95.17 102.24,95.66 101,95.66 100.96,95.62 95.45,95.62 95.44,95.63 95.44,115.37 83.12,115.37 83.12,118.86 79.66,118.86
VDD_CORE_0V8 on L5-SIGNAL2: 95.33,77.75 90.7,82.39 90.7,92.01 90.71,92.02 90.71,94.29 87.61,97.39 87.61,97.42 79.41,97.42 79.41,119.03 95.47,119.03 98.77,115.73 98.82,115.73 98.82,104.55 97.36,103.09 97.36,98.48 100.21,95.63 102.93,95.63 106.63,91.93 117.89,91.93 120.46,89.36 120.46,87.27 117.56,87.27 116.42,86.13 116.42,80.29 117.18,79.53 127.19,79.53 127.65,79.07 127.65,75.36 127.69,75.31 115.3,75.31 112.86,77.75
VDD_CORE_0V8 on L7-SIGNAL3: 128.33,74.81 108.87,74.81 105.62,78.06 100.29,78.06 100.27,78.04 96.68,78.04 87.61,87.1 87.61,94.17 86.17,95.61 80.39,95.61 79.41,96.6 79.41,117.91 80.53,119.03 88.93,119.03 90.26,117.7 91.65,117.7 92.18,118.24 97.67,118.24 112.3,103.61 112.3,99.09 114.26,97.13 117.58,97.13 120.46,94.26 120.46,87.27 117.69,87.27 116.42,86 116.42,80.04 116.97,79.48 127.41,79.48 128.33,78.57
VDD_CORE_0V8 on L8-PWR1: 103.74,79.4 103.74,82.89 102.93,83.7 91.6,83.7 87.61,87.68 87.61,91.42 84.42,94.61 79.41,94.61 79.41,119.03 87.18,119.03 87.18,119.02 112.41,119.02 112.41,98.23 117.22,93.43 117.22,87.4 116.42,86.6 116.42,78.13 116.92,77.62 116.92,73.56 119.34,73.56 119.85,74.07 119.85,77.62 120.61,78.38 124.93,78.38 126.2,79.65 127.08,79.65 128.35,78.38 128.35,72.8 127.21,71.65 115.65,71.65 115.02,72.29 115.02,75.72 112.1,78.64 104.5,78.64
VDD_CORE_0V8 on L9-PWR2: 118.51,75.27 116.73,77.04 94.57,77.04 94.57,77.04 92.92,77.04 91.09,78.86 91.09,85.35 79.41,97.03 79.41,118.54 79.89,119.02 79.89,119.03 87.12,119.03 87.12,119.03 102.4,119.03 102.4,112.8 120,95.21 120,90.09 121.77,88.32 124.57,88.32 124.57,88.32 127.28,88.32 127.63,87.97 127.69,87.97 127.69,75.44 127.52,75.27
VDD_CORE_HCPS_SW1 on TOP: 75.88,113.06 76.64,113.06 77.4,112.3 77.4,111.92 79.31,111.92 79.31,115.48 77.4,115.48 77.4,115.09 76.64,114.33 75.88,114.33
VDD_CORE_HCPS_SW2 on TOP: 75.88,101.89 76.64,101.89 77.4,101.12 77.4,100.74 79.29,100.74 79.29,104.29 77.4,104.29 77.4,103.92 76.64,103.16 75.88,103.16
VDD_CPU_AVS on TOP: 149.79,103.07 149.79,107.25 149.77,107.27 110.96,107.27 110.96,107.26 110.93,107.26 110.93,109.7 114.49,113.26 114.49,117.58 114.92,118.02 161.48,118.02 163.91,115.58 197.93,115.58 197.93,103.07 164.75,103.07 164.32,102.64 163.58,102.64 163.15,103.07
VDD_CPU_AVS on BOTTOM: 136.1,118.32 136.1,107.24 150.05,107.24 150.15,107.14 150.15,105.7 158.71,105.7 158.71,105.69 165.44,105.69 165.44,118.32
VDD_CPU_AVS on L3-SIGNAL1: 111.51,84.91 111.51,87.27 110.94,87.85 110.03,87.85 108.69,89.18 108.69,93.75 109.89,94.95 109.89,112.39 114.58,117.09 115.28,117.79 198,117.79 198,102.27 150.84,102.27 142.57,102.27 139.28,102.27 128.86,91.85 128.86,91.82 128.46,91.41 128.46,80.98 125.97,78.49 125.31,78.49 124.87,78.05 124.87,72.8 124.04,71.96 112.02,71.96 110.4,73.58 110.4,79.88 110.83,80.32 110.83,84.23
VDD_CPU_AVS on L5-SIGNAL2: 116.67,80.42 116.67,86.13 117.69,87.15 120.71,87.15 120.71,89.46 115.78,94.39 115.78,94.75 115.74,94.79 115.74,107.11 115.02,107.83 115.02,114.05 114.71,114.35 114.71,117.04 114.84,117.17 117.93,117.17 118.5,117.74 197.47,117.74 197.47,103.49 159.29,103.49 157.95,104.83 148.22,104.83 146.87,103.49 142.26,103.49 130.74,91.97 130.74,89.64 128.35,87.25 128.35,80.7 127.45,79.8 117.29,79.8 ; 1 cut-out
VDD_CPU_AVS on L7-SIGNAL3: 121.66,86.83 122.35,86.24 121.88,87.01 121.88,95.28 117.86,99.3 117.08,99.3 115.64,100.74 115.64,102.78 114.79,103.63 114.79,111.76 120.74,117.71 162.75,117.71 162.99,117.47 197.47,117.47 197.47,103.56 176.81,103.56 176.81,81.89 174.83,79.91 163.75,79.91 159.58,84.08 159.58,90.57 155.46,94.69 137.09,94.69 128.89,86.49 128.89,80.8 127.86,79.78 117.05,79.78 116.67,80.16 116.67,86 117.5,86.83 ; 1 cut-out
VDD_CPU_AVS on L8-PWR1: 116.67,78.26 116.67,86.51 116.92,86.77 116.93,86.77 117.44,87.27 117.44,94.06 117.32,94.17 113.19,98.3 113.19,118.9 196.27,118.9 197.93,117.25 197.93,103.41 196.78,102.27 147.79,102.27 145.63,100.1 145.63,98.32 136.61,89.31 131.2,89.31 128.35,86.46 128.35,82.04 128.61,81.78 128.61,80.16 125.94,80.16 124.29,78.51 120.35,78.51 119.59,77.75 119.59,73.81 119.46,73.69 117.05,73.69 117.05,77.88
VDD_CPU_AVS on L10-SIGNAL4: 139.99,117.74 139.99,103.46 197.47,103.46 197.47,116.54 196.27,117.74
VDD_CPU_HCPS_SW1 on TOP: 169.02,119.22 169.02,118.46 168.26,117.7 167.88,117.7 167.88,116.17 171.43,116.17 171.43,117.7 171.05,117.7 170.29,118.46 170.29,119.22
VDD_CPU_HCPS_SW2 on TOP: 180.45,119.22 180.45,118.46 179.69,117.7 179.31,117.7 179.31,116.18 182.86,116.18 182.86,117.7 182.48,117.7 181.72,118.46 181.72,119.22
VDD_CPU_HCPS_SW3 on TOP: 191.63,119.22 191.63,118.46 190.86,117.7 190.48,117.7 190.48,116.1 194.04,116.1 194.04,117.7 193.66,117.7 192.9,118.46 192.9,119.22
VDD_DDR_1V1 on TOP: 164.91,53.53 164.91,62.39 167.29,62.39 167.72,62.82 167.72,68.03 168.31,68.61 170.24,68.61 170.24,66.45 170.75,65.95 172.02,65.95 172.91,65.06 172.91,62.9 174.05,61.75 179,61.75 179.89,62.64 179.89,65.69 181.29,65.69 181.8,66.2 181.8,68.87 184.72,68.87 184.72,59.39 182.79,57.46 177.88,57.46 174.99,54.57 174.99,53.53
VDD_DDR_1V1 on BOTTOM: 180.02,65.69 179.89,65.56 179.89,62.64 179.26,62.01 173.8,62.01 172.91,62.9 172.91,64.98 172.07,65.82 168.08,65.82 167.72,65.46 167.72,62.8 167.32,62.39 164.93,62.39 164.91,62.36 164.91,53.63 165.01,53.53 174.86,53.53 174.99,53.65 174.99,54.57 177.88,57.46 182.79,57.46 184.72,59.39 184.72,65.69
VDD_DDR_1V1 on L3-SIGNAL1: 166.65,56.95 161.8,52.1 161.8,50.72 145.07,50.72 125.92,69.88 125.92,77.88 128.84,80.8 128.84,91.19 139.23,101.58 164.22,101.58 164.22,74.14 168.19,70.17 168.19,56.95
VDD_DDR_1V1 on L5-SIGNAL2: 128.2,74.68 128.2,79.88 128.63,80.31 128.63,87.2 142.81,101.37 160.99,101.37 163.78,98.59 163.78,91.3 170.36,84.72 176.97,84.72 178.9,82.79 178.9,74.15 183.4,69.65 183.4,53.67 166.26,53.67 164.53,51.94 142.05,51.94 128.79,65.2 128.79,72.21 128.42,72.58 119.81,72.58 119.49,72.9 119.49,74.22 119.95,74.68 ; 1 cut-out
VDD_DDR_1V1 on L8-PWR1: 165.03,97.95 161.5,101.48 149.64,101.48 148.4,101.51 147.79,101.51 146.11,99.82 146.11,94.79 146.64,94.26 155.79,94.26 157.06,92.99 157.06,84.73 152.99,80.67 147.91,80.67 146.11,78.87 146.11,78.36 146.49,77.98 152.61,77.98 157.03,73.56 157.06,73.56 157.06,64.41 155.79,63.14 144.32,63.14 141.54,60.36 141.54,46.99 145.05,43.48 158.13,43.48 168.36,53.71 168.36,68.33 163.91,72.78 163.91,86.7 165.03,87.82
VDD_DDR_1V1 on L9-PWR2: 128.08,74.8 128.2,74.93 128.2,85.34 144.36,101.51 159.84,101.51 163.91,97.44 163.91,83.92 165.33,82.5 165.33,76.45 165.31,76.44 165.31,71.04 164.4,70.13 164.4,62.21 168.41,62.21 171.97,58.66 171.97,52.51 162.88,43.43 162.87,43.43 148.7,43.43 119.46,72.67 119.46,73.94 120.33,74.8
VDD_DDR_1V1 on L14-SIGNAL6: 162.37,100.24 164.52,98.08 164.52,59.85 164.46,59.79 164.46,56.99 159.94,52.47 133.27,52.47 119.44,66.29 119.44,73.91 121.38,75.85 127.31,75.85 127.82,76.36 127.82,85.24 137.85,85.24 141.66,89.05 141.66,96.18 145.2,99.72 146.25,99.72 147.93,101.39 161.21,101.39
VDD_GPIORET_IO_3V3 on TOP: 85.8,70.98 87,70.98 87,69.51 87.27,69.25 87.27,66.16 86.51,66.16 86.51,67.72 85.8,67.72
VDD_GPIORET_IO_3V3 on L12-SIGNAL5: 85.4,66.02 85.4,36.51 87.54,36.51 87.54,66.02
VDD_GPIORET_IO_3V3_LS on TOP: 83.28,66.71 83.28,68.05 83.43,68.21 83.43,69.31 83.59,69.46 85.5,69.46 85.5,67.85 84.9,67.85 84.77,67.72 84.77,66.71
VDD_GPIORET_IO_3V3_LS on BOTTOM: 83.55,69.15 84.74,69.15 84.74,68.51 84.03,67.8 80.68,67.8 80.68,68.49 83.37,68.49 83.55,68.66
VDD_GPIORET_WK_0V8 on TOP: 82.51,73.81 84.45,73.81 84.45,72.04 83.3,72.04 83.3,72.6 82.51,72.6
VDD_GPIORET_WK_0V8 on L8-PWR1: 83.93,63.2 83.93,55.91 85.12,54.72 85.12,54.69 85.73,54.08 87.41,54.08 87.41,73.82 83.47,73.82 83.24,73.59 83.24,63.89
VDD_GPIORET_WK_0V8_REG on TOP: 79.54,74.75 79.54,73.88 80.23,73.88 80.23,72.61 82.24,72.61 82.24,74.83 81.29,74.83 81.21,74.75
VDD_GPIORET_WK_0V8_REG on L8-PWR1: 73.74,75.72 73.74,73.27 82.33,73.27 82.33,75.72
VDD_IO_1V8 on TOP: 165.16,86.9 165.16,84.23 167.45,84.23 167.45,86.9
VDD_IO_1V8 on L9-PWR2: 153.28,110.64 156.01,110.64 156.01,104.68 154.66,103.33 153.68,103.33 153.28,103.73
VDD_IO_1V8 on L10-SIGNAL4: 172.4,82.07 172.91,82.58 172.91,86.14 171.89,87.15 168.21,87.15 166.68,88.68 166.68,102.27 142.33,102.27 138.95,98.88 138.95,96.83 132.14,90.02 128.68,90.02 128.1,89.43 128.1,87.53 128.5,87.13 140.44,87.13 150.49,97.19 162.06,97.19 162.06,84.67 164.65,82.07
VDD_IO_1V8_REG on TOP: 168.72,79.53 170.11,79.53 170.37,79.79 170.37,81.95 170.75,82.33 171.89,82.33 172.27,82.71 172.27,85.68 171.94,86.01 169.88,86.01 169.91,86.04 169.91,86.88 167.7,86.88 167.7,80.55
VDD_IO_3V3 on BOTTOM: 77.22,84.84 77.22,83.83 78.42,83.83 78.42,84.84
VDD_IO_3V3 on L10-SIGNAL4: 112.8,80.04 111.46,80.04 110.4,81.1 93.64,81.1 92.67,82.07 76.84,82.07 76.84,85.35 110.67,85.35 112.8,83.22
VDD_IO_3V3_LS on TOP: 80.86,80.93 79.68,80.93 79.38,81.23 79.38,81.68 79.21,81.86 78.19,81.86 78,81.67 78,81.29 76.78,81.29 76.78,83.57 80.86,83.57
VDD_IO_3V3_LS on BOTTOM: 77.22,83.57 77.22,82.41 78.67,82.41 78.67,83.57
VDD_MCU_0V85 on TOP: 187.64,73.17 187.64,68.44 191.14,68.44 191.14,73.17
VDD_MCU_0V85 on L12-SIGNAL5: 97.6,52.07 97.6,41.05 98.75,39.9 111.08,39.9 117.66,33.33 132.95,33.33 139.53,39.9 161.57,39.9 168.11,46.44 168.11,66.63 174.3,72.83 180.37,72.83 183.09,75.55 189.54,75.55 190.79,74.3 190.79,63.94 182.69,55.84 182.69,43.9 171.79,33 149.21,33 143.49,27.28 127.03,27.28 126.55,26.8 126.53,26.8 126.12,26.39 117.92,26.39 114.99,29.31 99.18,29.31 87.69,40.8 87.69,69.25 89.04,70.6 106.5,70.6 110.22,74.32 111.49,74.32 112.78,75.62 112.78,76.2 113.98,77.39 116.9,77.39 117.31,76.99 117.31,75.46 116.42,74.57 116.42,70.89
VDD_MCU_0V85_REG on TOP: 187.38,70.26 187.38,74.71 183.83,74.71 183.83,70.26
VDD_MCU_0V85_REG on BOTTOM: 184.23,74.79 187.03,74.79 187.03,71.89 184.11,71.89 184.11,74.66
VDD_MCU_2V5 on TOP: 108.95,21.6 115.17,21.6 115.17,22.74 113.93,22.74 113.62,23.05 108.95,23.05
VDD_MCU_2V5 on L7-SIGNAL3: 97.08,20.99 97.08,17.51 121.07,17.51 121.07,23.53 119.56,23.53 119.56,23.01 119.15,22.6 114.31,22.6 113.38,23.53 102.17,23.53 100.64,22 100.64,19.79 98.46,19.79 98.46,20.99
VDD_MCU_WAKE1 on TOP: 83.76,71.69 84.44,71.69 84.44,70.95 83.89,70.4 82.81,70.4 82.81,70.96 83.54,70.96 83.76,71.19
VDD_MCU_WAKE1 on L9-PWR2: 82.43,70.92 82.43,65.79 83.88,64.34 108.67,64.34 111.43,67.09 111.43,70.93 113.32,72.82 113.32,74.57 113.17,74.73 111.01,74.73 104.43,68.15 91.4,68.15 88.37,71.17 82.69,71.17
VDD_MCUIO_1V8 on TOP: 166.76,65.29 166.76,65.84 164.96,65.84 164.96,63.99 166.33,63.99 166.53,64.19 166.53,64.83 166.47,64.89 166.47,64.99
VDD_MCUIO_1V8 on L9-PWR2: 151.51,40.04 160.85,40.04 172.75,51.94 172.75,58.43 168.26,62.92 165.16,62.92 165.16,65.74 171.28,65.74 173.01,64.02 174.07,64.02 177.28,60.82 177.28,49.05 164.02,35.8 136.99,35.8 130.06,42.72 127.77,42.72 119.65,50.84 118.08,50.84 111.78,57.15 111.78,70.98 115.12,74.33 118.24,74.33 119.01,73.56 119.01,72.54
VDD_MCUIO_1V8_REG on TOP: 170.87,71.48 172.47,71.48 172.47,71.1 171.41,71.1 170.72,70.42 170.72,69.58 170.24,69.1 168.13,69.1 167.42,68.38 167.42,66.12 165.62,66.12 165.62,67.83 166.86,67.83 166.86,69.3 167.55,69.3 168.08,69.83 169.68,69.83 169.91,70.06 169.91,71.03 170.42,71.03
VDD_MCUIO_3V3 on BOTTOM: 164.96,67.93 164.96,66.71 166.02,66.71 166.02,67.93
VDD_MCUIO_3V3 on L9-PWR2: 92.72,60.82 92.72,59.79 94.75,57.76 110.04,57.76 111.21,58.93 111.21,61.54 108.67,64.08 86.27,64.08 86.27,62.82 86.75,62.34 91.19,62.34
VDD_MCUIO_3V3 on L14-SIGNAL6: 159.68,49.01 164.96,54.29 164.96,67.95 166.96,67.95 166.96,66.15 172.02,61.09 172.02,54.62 175.27,51.37 175.27,49.05 174.49,48.28 170.73,48.28 156.27,33.81 112.29,33.81 109.91,36.2 109.91,71.53 111.87,73.49 111.87,73.49 112.3,73.91 116.72,73.91 118.04,72.59 118.04,65.61 134.64,49.01
VDD_MCUIO_3V3_REG on BOTTOM: 170.01,72.37 170.42,72.37 170.59,72.19 170.59,71.84 169.78,71.02 168.69,71.02 168.41,70.74 168.41,67.57 167.55,66.71 166.25,66.71 166.25,67.98 166.81,67.98 166.81,69.91 166.35,70.37 166.35,71.1 167.67,71.1 168.26,71.69 169.32,71.69
VDD_MMC1 on TOP (solid shape): outline of 224 points within 23.61,114.1 30.78,122.24
VDD_PHYCORE_0V8 on TOP: 96.6,116.23 96.6,114.13 104.55,114.13 104.55,112.78 106.12,112.78 106.12,116.23
VDD_PHYCORE_0V8 on L9-PWR2: 109.56,117.95 150.11,117.95 152.92,115.15 152.92,103.69 139.99,103.69 135.98,107.7 127.58,107.7 125.8,105.93 110.4,105.93 109.36,106.97 109.36,108.92 115.67,108.92 117.42,110.66 137.19,110.66 137.19,114.66 113.04,114.66 111.91,113.54 108.48,113.54 107.88,112.94 104.53,112.94 104.22,113.24 104.22,116.57 104.58,116.92 108.53,116.92
VDD_PMIC_BUCK_SW1 on TOP: 178.67,69.71 178.67,70.39 179.51,70.39 179.51,70.26 181.16,68.61 181.16,66.33 180.02,66.33 180.02,68.36
VDD_PMIC_BUCK_SW2 on TOP: 173.45,69.66 173.45,70.39 172.65,70.39 172.65,70.26 171,68.61 171,66.33 172.14,66.33 172.14,68.36
VDD_PMIC_BUCK_SW3 on TOP: 178.7,78.47 178.7,77.76 179.51,77.76 179.51,77.88 181.16,79.53 181.16,81.82 180.02,81.82 180.02,79.79
VDD_PMIC_BUCK_SW4 on TOP: 173.44,78.49 173.44,77.76 172.65,77.76 172.65,77.88 171,79.53 171,81.82 172.14,81.82 172.14,79.79
VDD_PMIC_BUCK_SW5 on TOP: 181.42,72.42 179.64,72.42 179.64,73.44 182.1,73.44 182.86,72.68 183.07,72.68 183.07,70.39 181.8,70.39 181.8,72.04
VDD_RAM_0V85 on TOP: 183.8,84.97 183.8,83.19 184.44,82.56 186.29,82.56 186.29,85.1 184.56,85.1 184.44,84.97
VDD_RAM_0V85 on BOTTOM: 92.44,70.56 92.44,75.13 90.92,76.66 90.92,80.14 88.25,80.14 88.07,79.96 88.07,71.65 89.16,70.56
VDD_RAM_0V85 on L8-PWR1: 90.28,76.48 87.77,73.96 87.77,36.99 92.72,32.04 172.3,32.04 192.49,52.23 192.49,83.93 190.84,85.58 184.31,85.58 184.31,55.4 176.04,47.14 175.19,47.14 164.55,36.5 97.66,36.5 94.49,39.67 94.49,65.43 95.44,66.38 95.44,69.74 94.95,70.22 94.95,74.85 93.33,76.48
VDD_RAM_0V85_REG on TOP: 183.32,79.53 181.92,79.53 181.67,79.79 181.67,81.95 181.42,82.2 180.02,82.2 179.64,82.58 179.64,85.25 180.02,85.63 183.57,85.63 183.57,83.73 184.21,83.09 184.21,80.42
VDD_SD_DV on TOP: 76.5,86.98 76.5,85.53 78.71,85.53 78.71,86.98
VDD_SD_DV on L8-PWR1: 100.1,76.36 99.75,76.71 99.75,77.75 100.39,78.38 111.95,78.38 112.5,77.83 112.5,76.78 112.08,76.36
VDD_SD_DV on L8-PWR1: 71.41,85.45 78.57,85.45 78.57,89.67 71.81,96.43 59.5,96.43 55.5,100.43 55.5,114.26 37.52,114.26 37.52,110.14 44.66,103 44.66,93.86 46.08,92.44 70,92.44 71.41,91.03
VDD_SD_DV on L12-SIGNAL5: 102.7,75.72 102.7,76.79 102.17,77.32 82.34,77.32 77.91,81.74 77.91,86.62 77.61,86.93 74.79,86.93 74.56,86.7 74.56,79.99 79.31,75.24 90.86,75.24 91.35,75.72
VDD_SD_DV on L12-SIGNAL5: 26.58,119.41 26.58,111.72 29.29,111.72 29.29,118.22 32.7,118.22 37.12,113.8 37.12,111.69 37.83,110.98 38.85,110.98 39.61,111.74 39.61,114.61 34.81,119.41
VDD_SD_DV_REG on TOP: 76.51,92.88 76.51,87.29 78.21,87.29 78.21,92.88
VDD_WAKE0 on L12-SIGNAL5: 89.24,74.91 89.24,72.98 94.52,72.98 94.52,74.91
VDDA_LM5140 on L12-SIGNAL5: 209.86,110.04 209.86,95.69 215.68,95.69 215.68,110.04
VDDAR_CORE_0V85 on BOTTOM: 99.14,81.83 100.21,81.83 100.21,80.28 101.48,80.28 101.48,81.01 102.29,81.01 102.29,78.97 102.04,78.71 99.14,78.71 98.97,78.71 96.63,76.38 91.73,76.38 91.45,76.66 91.45,80.29 91.52,80.37 99.14,80.37
VDDAR_CORE_0V85 on L14-SIGNAL6: 124.52,85.67 119.45,85.67 115.65,81.87 115.65,78.54 114.94,77.83 113.01,77.83 112.63,78.21 112.63,79.05 112.4,79.28 105.16,79.28 104.86,78.97 100.79,78.97 100.28,79.48 100.28,82.43 100.76,82.92 111.36,82.92 112.95,84.51 112.95,88.18 113.22,88.45 123.44,88.45 124.52,87.38
VDDAR_CPU_0V85 on BOTTOM: 92.67,72.66 92.67,70.28 93.3,69.65 97.66,69.65 98.12,70.12 98.12,70.73 98.32,70.92 99.93,70.92 99.93,72.99 96.43,72.99 96.43,71.47 95.96,71 94.63,71 94.32,71.31 94.32,72.66
VDDAR_CPU_0V85 on L14-SIGNAL6: 127.06,76.11 127.57,76.61 127.57,86.67 127.54,86.69 125.15,86.69 125.05,86.59 125.05,85.58 124.72,85.25 119.65,85.25 115.83,81.43 115.83,78.38 114.28,76.84 106.59,76.84 104.08,74.33 95.31,74.33 93.39,72.41 93.39,71.29 94.24,70.45 108.23,70.45 111.95,74.17 119.2,74.17 121.14,76.11
VDDAR_MCU_0V85 on L9-PWR2: 117.6,74.54 117.6,75.67 116.53,76.73 100,76.73 96.58,73.31 96.58,70.77 96.83,70.52 101.91,70.52 102.42,71.03 106.94,71.03 110.82,74.91 113.42,74.91 113.78,74.54
VDDSHV0_MCU on L10-SIGNAL4: 99.45,63.22 86.71,63.22 86.71,66.28 96.96,66.28 97.93,67.26 97.95,67.26 98.13,67.44 98.13,69.04 101.86,72.77 107.55,72.77 109.23,74.45 112.1,74.45 112.96,73.58 112.96,73.05 112.5,72.59 110.85,72.59 108.97,70.71 105.29,70.71 103.31,68.73 99.63,68.73 99.45,68.56
VDDSHV2_DV on L10-SIGNAL4: 86.88,72.2 91.37,72.2 92.81,73.64 92.81,74.27 98.76,80.21 110.55,80.21 110.93,79.83 112.48,79.83 112.48,77.14 112.28,76.94 100.89,76.94 95.94,71.99 95.94,71.15 94.51,69.72 86.88,69.72
VINPUT on TOP: 204,68.36 213.17,68.36 213.17,75.98 204,75.98
VINPUT on TOP: 229.18,108.08 233.61,108.08 234.86,109.33 239.53,109.33 239.53,99.98 236.3,99.98 234.96,101.33 229.18,101.33
VINPUT on TOP: 179.94,155.28 179.94,145.75 185.97,145.75 187.98,147.76 187.98,152.86 187.28,153.56 187.28,155.28
VINPUT on TOP, L5-SIGNAL2: 216.26,143.92 216.26,129.12 231.96,129.12 231.96,143.92
VINPUT on BOTTOM: 216.34,143.92 216.34,129.19 230.82,129.19 230.82,143.92
VINPUT on BOTTOM: 180.29,155.61 180.29,145.15 185.64,145.15 185.64,155.61
VINPUT on BOTTOM: 212.17,63.15 215.07,63.15 215.07,75.47 207.2,75.47 207.2,61.15 212.17,61.15
VINPUT on L3-SIGNAL1: 216.26,142.6 216.26,129.12 231.96,129.12 231.96,143.92 217.58,143.92
VINPUT on L7-SIGNAL3: 179.51,158.26 209.89,158.26 209.89,149.33 215.48,143.74 239.45,143.74 239.45,91.6 220.02,91.6 220.02,109.51 201.99,109.51 201.99,127.79 199.7,130.08 188.4,130.08 185.61,132.87 185.61,139.35 179.51,139.35
VINPUT on L8-PWR1: 178.84,167.03 242.68,167.03 242.68,68.89 208.85,68.89 208.85,73.69 215.78,80.63 215.78,134.75 212.61,137.93 196.83,137.93 189.72,145.04 181.28,145.04 177.05,149.27 177.05,165.23
VINPUT on L10-SIGNAL4: 221.78,142.53 239.45,142.53 239.45,91.35 223.07,91.35 223.07,112.17 223.06,112.19 223.06,126.34 220.12,129.27 220.12,140.88
(no net) on TOP: 233.1,118.6 219.03,118.6 219.03,108.92 219.21,108.74 219.57,108.74 219.69,108.87 219.69,110.14 220.07,110.52 223.79,110.52 225.69,108.62 233.1,108.62
(no net) on TOP: 195.66,148.8 196.88,148.8 197.43,149.34 198.8,149.34 199.4,149.94 201.13,149.94 201.13,150.76 199.32,150.76 198.76,151.32 197.44,151.32 196.87,151.88 195.66,151.88
(no net) on TOP: 186.47,138.35 199.72,138.35 200.95,139.58 200.95,146.36 201.58,147 201.58,147.68 201.51,147.76 201.28,147.76 201.18,147.66 201.18,147.07 200.31,146.21 200.31,144.74 200.08,144.51 196.1,144.51 195.18,145.42 195.18,147 194.62,147.56 188.49,147.56 186.47,145.54
(no net) on TOP: 218.37,128.48 218.37,118.9 233.1,118.9 233.1,128.48
(no net) on TOP: 178.6,187.03 178.6,189.67 181.47,189.67 181.47,188.21 181.86,187.82 181.86,185.97 179.8,185.97 179.8,187.03
(no net) on TOP: 228.79,169.58 228.79,180.7 217.86,180.7 217.86,175.67 212.66,175.67 212.66,185.88 206.41,185.88 206.41,169.58
(no net) on TOP: 194.74,155.16 195.26,155.68 200.29,155.68 200.77,155.2 200.77,154.08 201.13,153.73 201.13,152.97 201.61,152.97 201.61,155.58 200.03,157.16 200.03,162.98 187.84,162.98 187.84,153.78 188.59,153.04 194.4,153.04 194.74,153.38
(no net) on TOP: 174.16,176 172.12,176 172.12,173.93 174.16,173.93
(no net) on TOP: 29.08,122.24 30.78,122.24 30.78,115.13 29.75,114.1 23.61,114.1 23.61,117.23 25.87,117.23 26.37,116.72 27.06,116.72 29.08,118.74
(no net) on TOP: 227.26,91.61 227.26,95.79 218.12,95.79 218.12,91.61
(no net) on TOP: 166.12,189.39 176.34,189.39 176.34,186.42 175.33,186.42 174.65,187.1 170.89,187.1 170.51,187.48 168.14,187.48 167.63,186.98 166.12,186.98
(no net) on TOP: 218.22,96.4 232.03,96.4 232.03,100.93 232.01,100.95 228.63,100.95 228.4,100.72 225.79,100.72 224.54,99.47 218.22,99.47
(no net) on TOP: 227.64,95.79 233.49,95.79 233.49,84.69 229.42,84.69 229.04,85.07 227.64,85.07
(no net) on TOP: 166.91,186.46 160.38,186.46 160.38,180.94 166.79,180.94 166.79,179.63 171.71,179.63 172.65,180.57 172.65,185.16 172.02,185.8 167.57,185.8
(no net) on TOP: 161.03,177.06 166.39,177.06 166.39,180.41 161.03,180.41
(no net) on TOP: 224.22,106.29 222.78,106.29 222.29,105.79 218.7,105.79 218.7,103.82 221.98,103.82 221.99,103.82 222.24,103.82 222.8,103.25 224.23,103.25 224.39,103.41 224.39,106.11
(no net) on BOTTOM: 58.53,15.96 58.53,20.58 59.62,20.58 59.62,19.16 60.08,18.7 60.08,15.96
(no net) on BOTTOM: 58.56,22.79 58.56,28 59.67,28 59.67,26.04 59.62,25.99 59.62,22.79
(no net) on BOTTOM: 63.64,28.94 66.84,28.94 66.84,30.46 63.74,30.46 63.64,30.36
(no net) on BOTTOM: 143.26,150.1 153.6,150.1 153.6,151.16 142.88,151.16 142.88,150.48
(no net) on BOTTOM: 92.77,30.16 95.97,30.16 95.97,28.63 92.87,28.63 92.77,28.73
(no net) on BOTTOM: 89.29,28.58 92.49,28.58 92.49,27.06 89.39,27.06 89.29,27.16
(no net) on BOTTOM: 198.71,9.86 198.71,7.75 199.75,7.75 199.75,11.65 198.63,11.65 198.59,11.61 198.59,9.99
(no net) on BOTTOM: 219.67,6.99 219.67,5.62 222.77,5.62 222.77,6.99
(no net) on BOTTOM: 81.77,22.54 81.77,31.94 82.03,32.19 82.96,32.19 83.35,31.81 83.35,30.16 83.32,30.13 83.32,28.58 83.52,28.38 86.34,28.38 86.5,28.23 86.5,26.98 86.32,26.8 83.9,26.8 83.4,26.3 83.4,22.38 83.22,22.21 82.1,22.21
(no net) on BOTTOM: 15.45,189.6 15.45,185.74 18.43,185.74 18.43,188.09 21.82,188.09 21.82,185.67 24.75,185.67 24.75,189.6
(no net) on BOTTOM: 228.79,169.55 228.79,180.7 217.84,180.7 217.84,175.67 212.63,175.67 212.63,185.88 206.41,185.88 206.41,169.55
(no net) on BOTTOM: 83.83,21.62 83.83,26.5 84.97,26.5 84.97,25.26 85.28,24.95 85.28,21.62
(no net) on BOTTOM: 83.85,28.71 83.85,33.92 84.92,33.92 84.92,28.71
(no net) on BOTTOM: 167.45,185.2 171.89,185.2 173.41,186.72 177.48,186.72 177.73,186.98 177.73,189.26 177.61,189.39 167.45,189.39
(no net) on BOTTOM: 197.06,7.48 197.06,6.1 200.16,6.1 200.16,7.48
(no net) on BOTTOM: 177.1,183.78 177.1,180.41 173.66,180.41 172.46,179.21 167.73,179.21 167.73,183.78
(no net) on BOTTOM: 89.29,28.94 92.49,28.94 92.49,30.46 89.39,30.46 89.29,30.36
(no net) on BOTTOM: 67.12,30.16 70.32,30.16 70.32,28.63 67.22,28.63 67.12,28.73
(no net) on BOTTOM: 29.14,117.74 29.14,116.48 27.64,116.48 27.64,117.74
(no net) on BOTTOM: 218.45,6.97 218.45,5.34 212.96,5.34 212.96,6.97
(no net) on BOTTOM: 221.32,9.38 221.32,7.27 222.36,7.27 222.36,10.78 221.19,10.78 221.19,9.51
(no net) on BOTTOM: 63.64,28.58 66.84,28.58 66.84,27.06 63.74,27.06 63.64,27.16
(no net) on BOTTOM: 141.18,149.13 145.98,149.13 146.29,148.83 149.31,148.83 149.31,149.79 142.81,149.79 142.5,150.1 142.5,155.07 141.26,155.07 141.18,155
(no net) on BOTTOM: 162.16,176.59 162.16,174.8 163.14,173.82 172.05,173.82 172.07,173.84 173.39,173.84 173.82,174.27 173.82,176.86 172.91,177.77 168.67,177.77 166.45,179.99 162.04,179.99 161.7,179.66 161.7,177.05
(no net) on BOTTOM: 56.47,16.62 56.47,26.27 58.12,26.27 58.12,22.77 58.43,22.46 61.04,22.46 61.2,22.31 61.2,21.06 61.02,20.89 58.28,20.89 58.1,20.71 58.1,16.62
(no net) on BOTTOM: 67.12,30.51 70.32,30.51 70.32,32.04 67.22,32.04 67.12,31.94
(no net) on BOTTOM: 92.77,30.51 95.97,30.51 95.97,32.04 92.87,32.04 92.77,31.94
(no net) on BOTTOM: 195.84,7.45 195.84,5.82 190.36,5.82 190.36,7.45
(no net) on L3-SIGNAL1: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 265 cut-outs
(no net) on L5-SIGNAL2: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 241 cut-outs
(no net) on L7-SIGNAL3: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 86 cut-outs
(no net) on L10-SIGNAL4: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 91 cut-outs
(no net) on L12-SIGNAL5: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 217 cut-outs
(no net) on L14-SIGNAL6: 5.76,0.76 5.76,189.74 16.47,189.74 16.53,189.68 16.53,189.48 18.95,189.48 18.95,189.68 19,189.74 21.22,189.74 21.28,189.68 21.28,189.48 23.7,189.48 23.7,189.68 23.75,189.74 242.95,189.74 242.98,189.72 243,189.69 243,0.76 212.38,0.76 212.33,0.82 212.33,1.02 209.9,1.02 209.9,0.82 209.85,0.76 207.63,0.76 207.58,0.82 207.58,1.02 205.15,1.02 205.15,0.82 205.1,0.76 191.77,0.76 191.72,0.82 191.72,1.02 189.3,1.02 189.3,0.82 189.24,0.76 187.02,0.76 186.97,0.82 186.97,1.02 184.55,1.02 184.55,0.82 184.49,0.76 ; 166 cut-outs
CS_LM5141 on TOP: 222.06,52.99 232.47,52.99 232.47,64.29 222.06,64.29
EXP_3V3 on TOP: 205.88,133.94 205.88,126.98 215.22,126.98 215.22,133.94
EXP_3V3 on BOTTOM: 28.3,161.12 29.73,161.12 29.73,157.69 28.28,156.24 27.72,156.24 27.29,156.67 27.29,157.26 28.3,158.27
EXP_3V3 on BOTTOM: 207.5,88.9 204.91,88.9 204.91,95.64 207.5,95.64
EXP_3V3 on BOTTOM: 26.48,153.17 26.48,150.6 27.59,150.6 27.59,153.17
EXP_3V3 on BOTTOM: 204.52,35.22 201.92,35.22 201.92,41.96 204.52,41.96
EXP_3V3 on BOTTOM: 38.67,37.24 38.67,35.44 44.13,35.44 44.13,37.24
EXP_3V3 on BOTTOM: 28.3,140.8 29.73,140.8 29.73,137.37 28.28,135.92 27.72,135.92 27.29,136.35 27.29,136.94 28.3,137.95
EXP_3V3 on BOTTOM: 26.48,132.85 26.48,130.28 27.57,130.28 27.57,132.85
EXP_3V3 on L8-PWR1: 181.67,141.89 191.19,141.89 195.77,137.32 211.87,137.32 215.15,134.04 215.15,81.39 208.21,74.45 208.21,67.06 211.16,64.12 211.16,36.46 209.15,34.45 200.21,34.45 200.21,85.99 197.95,88.25 197.95,100.32 198.69,101.06 198.69,117.89 196.91,119.67 79.38,119.67 79.38,129.94 63.93,129.94 55.36,121.37 55.36,115.78 54.58,115.01 48.46,115.01 48.45,114.99 36.61,114.99 36.61,110.12 43.96,102.76 43.96,92 50.02,85.94 50.02,35.55 43.96,29.5 23.71,29.5 22.56,30.64 22.56,84.84 19.44,87.97 19.44,154.93 20.51,156 26.14,161.63 68.88,161.63 75.28,155.23 168.33,155.23
L_TPS61240 on TOP: 139.89,20.71 141.03,20.71 141.46,21.14 142.99,21.14 142.99,19.87 141.41,19.87 141.03,20.25 139.89,20.25
L_TPS61240_1 on TOP: 171.46,22.56 172.6,22.56 173.03,22.99 174.56,22.99 174.56,21.72 172.98,21.72 172.6,22.11 171.46,22.11
LM5143_SW1 on BOTTOM: 186.11,150.35 188.65,150.35 190.65,148.34 194.47,148.34 194.47,144.91 188.63,144.91 187.03,146.51 186.11,146.51
LM5143_SW2 on TOP (solid shape): 189.02,162.98 189.04,162.98 189.06,162.96 189.12,162.86 189.45,162.45 189.79,162.86 189.85,162.96 189.87,162.98 189.89,162.98 199.98,162.98 200.02,162.97 200.03,162.93 200.03,157.18 200.04,157.16 200.05,157.14 201.59,155.6 201.6,155.58 201.61,155.56 201.61,153.02 201.59,152.98 201.56,152.97 201.18,152.97 201.14,152.98 201.13,153.02 201.13,153.71 201.12,153.73 201.11,153.74 200.78,154.07 200.77,154.09 200.77,154.1 200.77,155.18 200.77,155.2 200.76,155.22 200.3,155.67 200.29,155.68 200.27,155.68 195.28,155.68 195.26,155.68 195.24,155.67 194.75,155.18 194.74,155.16 194.74,155.14 194.74,153.4 194.73,153.38 194.72,153.36 194.41,153.05 194.39,153.04 194.37,153.04 188.61,153.04 188.59,153.04 188.57,153.05 187.86,153.77 187.85,153.78 187.84,153.8 187.84,162.36 187.85,162.38 187.92,162.45 187.97,162.46 188.28,162.55 188.38,162.86 188.44,162.96 188.45,162.98 188.48,162.98
LM5143_SW2 on BOTTOM: 186.12,155.85 186.12,152.2 194.24,152.2 194.24,155.85
MCU_ETH_EARTH on TOP: 87.44,9.23 87.44,12.4 110.83,12.4 110.83,9.23 110.8,9.25 107.5,9.25 107.02,9.74 104.81,9.74 104.25,9.18 104.25,0.76 96.55,0.76 96.55,9.25 95.92,9.89 93.94,9.89 93.28,9.23
