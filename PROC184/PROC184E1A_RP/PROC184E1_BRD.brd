# Allegro board PROC184E1_BRD.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TP58  -  [TP30_SMD]  30.01 117.13 0 top
TP59  -  [TP30_SMD]  155.37 115.97 0 top
TP60  -  [TP20_SMD]  29.38 115.6 0 top
TP61  -  [TP30_SMD]  99.82 115.49 0 top
TP62  -  [TP30_SMD]  88.39 113.89 0 top
TP64  -  [TP20_SMD]  27.6 113.53 0 top
TP65  -  [TP30_SMD]  29.18 112.71 0 top
TP66  -  [TP20_SMD]  27.6 111.91 0 top
TP67  -  [TP30_SMD]  107.78 110.04 0 top
TP68  -  [TP30_SMD]  23.22 107.38 0 top
TP69  -  [TP30_SMD]  19.94 106.43 0 top
TP70  THRU HOLE  [TP_40X65]  65.44 103.06 0 top
TP71  -  [TP30_SMD]  19.93 102.88 0 top
TP72  -  [TP30_SMD]  30.18 102.88 0 top
TP73  -  [TP30_SMD]  162.9 102.83 0 top
TP75  -  [TP40_SMD]  206.43 103.12 90 top
TP76  -  [TP20_SMD]  167.82 101.28 0 top
TP77  THRU HOLE  [TP_40X65]  65.44 100.52 0 top
TP78  -  [TP30_SMD]  29.03 100.18 0 top
TP79  -  [TP20_SMD]  167.82 99.91 0 top
TP80  -  [TP20_SMD]  167.82 98.53 0 top
TP81  -  [TP30_SMD]  87.3 98.41 0 top
TP82  -  [TP30_SMD]  27.39 98.21 0 top
TP83  -  [TP20_SMD]  167.82 97.16 0 top
TP84  -  [TP30_SMD]  29.09 96.48 0 top
TP85  -  [TP30_SMD]  42.17 96.43 180 top
TP86  -  [TP30_SMD]  183.55 96.12 0 top
TP87  -  [TP20_SMD]  167.82 95.79 0 top
TP90  -  [TP30_SMD]  42.22 95.08 180 top
TP93  -  [TP30_SMD]  88.15 95.45 0 top
TP94  -  [TP20_SMD]  167.82 94.42 0 top
TP95  THRU HOLE  [TP_40X65]  194.24 89.82 270 top
TP96  5002  [TP_CIR67D40_TH_4-6]  58.45 93.81 0 top
TP97  -  [TP20_SMD]  167.82 93.05 0 top
TP98  -  [TP30_SMD]  77.74 92.3 0 top
TP99  THRU HOLE  [TP_40X65]  194.24 87.28 270 top
TP100  -  [TP20_SMD]  167.82 91.68 0 top
TP101  -  [TP18_SMD]  169.07 91.68 0 top
TP102  -  [TP20_SMD]  79.02 88.18 0 top
TP103  -  [TP20_SMD]  80.01 88.18 0 top
TP104  -  [TP20_SMD]  81 88.18 0 top
TP105  -  [TP20_SMD]  81.99 88.18 0 top
TP106  -  [TP20_SMD]  82.98 88.18 0 top
TP107  -  [TP20_SMD]  83.98 88.18 0 top
TP108  THRU HOLE  [TP_40X65]  225.18 88.07 180 top
TP109  -  [TP20_SMD]  79.02 85.9 0 top
TP110  -  [TP20_SMD]  80.01 85.9 0 top
TP111  -  [TP20_SMD]  81 85.9 0 top
TP112  -  [TP20_SMD]  81.99 85.9 0 top
TP113  -  [TP20_SMD]  83.98 85.9 0 top
TP114  -  [TP30_SMD]  188.8 83.39 270 top
TP115  -  [TP30_SMD]  165.53 85.48 0 top
TP116  -  [TP20_SMD]  102.57 68.44 0 top
TP117  -  [TP30_SMD]  85.15 84.27 0 top
TP118  -  [TP30_SMD]  188.8 81.98 270 top
TP119  -  [TP30_SMD]  185.71 82.91 0 top
TP120  -  [TP30_SMD]  90.14 82.76 0 top
TP121  -  [TP30_SMD]  54.71 82.33 0 top
TP122  -  [TP30_SMD]  95.94 82.33 0 top
TP123  -  [TP30_SMD]  166.99 81.82 0 top
TP125  -  [TP30_SMD]  188.8 79.36 0 top
TP126  -  [TP30_SMD]  54.71 80.42 0 top
TP127  -  [TP30_SMD]  185.54 79.84 0 top
TP129  -  [TP30_SMD]  188.8 77.95 0 top
TP130  -  [TP30_SMD]  167.82 79.36 0 top
TP132  -  [TP30_SMD]  75.76 77.76 0 top
TP133  THRU HOLE  [TP_40X65]  226.37 77.55 0 top
TP134  -  [TP30_SMD]  166.58 76.83 0 top
TP135  -  [TP40_SMD]  33.77 76.41 0 top
TP136  -  [TP30_SMD]  188.8 75.33 0 top
TP137  -  [TP30_SMD]  73.9 75.75 0 top
TP138  -  [TP30_SMD]  188.8 73.91 0 top
TP139  -  [TP30_SMD]  84.26 74.08 0 top
TP140  -  [TP30_SMD]  19.53 73.97 0 top
TP141  -  [TP30_SMD]  166.91 73.8 0 top
TP142  -  [TP30_SMD]  63.57 73.44 0 top
TP143  -  [TP30_SMD]  190.55 72.7 0 top
TP144  -  [TP30_SMD]  80.12 70.67 0 top
TP145  -  [TP30_SMD]  183.29 69.63 0 top
TP146  -  [TP30_SMD]  64.71 69.5 0 top
TP147  -  [TP40_SMD]  164.66 69.37 270 top
TP148  -  [TP30_SMD]  15.99 69.17 0 top
TP149  -  [TP30_SMD]  71.56 65.91 0 top
TP150  -  [TP30_SMD]  185.61 67.5 0 top
TP151  -  [TP30_SMD]  164.77 67.28 0 top
TP152  -  [TP30_SMD]  88.15 66.4 0 top
TP153  -  [TP30_SMD]  185.61 66.25 0 top
TP154  -  [TP30_SMD]  31.03 65.88 0 top
TP155  -  [TP30_SMD]  96.48 65.39 0 top
TP156  -  [TP30_SMD]  81.33 64.06 0 top
TP157  -  [TP30_SMD]  74.38 63.91 0 top
TP158  -  [TP30_SMD]  167.29 63.41 0 top
TP159  -  [TP30_SMD]  164.95 63.4 0 top
TP160  -  [TP30_SMD]  96.29 62.07 0 top
TP161  -  [TP30_SMD]  97.52 61.37 0 top
TP162  -  [TP30_SMD]  107.96 64.11 0 top
TP163  -  [TP30_SMD]  97.52 59.98 0 top
TP164  -  [TP30_SMD]  24.09 59.55 90 top
TP165  -  [TP30_SMD]  124.48 52.62 0 top
TP166  -  [TP20_SMD]  130.51 46.16 180 bottom
TP167  -  [TP30_SMD]  165.35 58.33 0 top
TP168  -  [TP40_SMD]  61.35 58.28 0 top
TP170  -  [TP30_SMD]  170.29 54.5 0 top
TP171  -  [TP30_SMD]  153.83 52.31 0 top
TP172  -  [TP30_SMD]  185.22 51.65 270 top
TP173  -  [TP30_SMD]  163.21 51.58 180 top
TP174  -  [TP30_SMD]  185.22 50.23 270 top
TP177  -  [TP20_SMD]  129.59 46.16 180 bottom
TP178  -  [TP30_SMD]  185.22 46.89 270 top
TP179  THRU HOLE  [TP_40X65]  8.26 46.17 0 top
TP181  -  [TP30_SMD]  185.22 45.47 270 top
TP182  -  [TP40_SMD]  16.57 45.15 0 top
TP183  THRU HOLE  [TP_40X65]  163.18 44.77 90 top
TP184  THRU HOLE  [TP_40X65]  165.72 44.77 90 top
TP189  -  [TP40_SMD]  84.36 43.68 0 top
TP190  THRU HOLE  [TP_40X65]  8.26 43.63 270 top
TP191  THRU HOLE  [TP_40X65]  78.95 43.02 90 top
TP192  THRU HOLE  [TP_40X65]  81.49 43.02 90 top
TP193  -  [TP40_SMD]  46.73 42.99 90 top
TP194  -  [TP30_SMD]  185.22 42.7 270 top
TP195  -  [TP30_SMD]  185.22 41.28 270 top
TP196  -  [TP40_SMD]  30.88 41.13 0 top
TP197  -  [TP30_SMD]  81.34 41.05 180 top
TP198  -  [TP30_SMD]  169.12 41.03 180 top
TP199  -  [TP30_SMD]  170.53 41.03 180 top
TP200  -  [TP30_SMD]  173.44 41.03 90 top
TP201  -  [TP30_SMD]  174.85 41.03 90 top
TP202  -  [TP30_SMD]  177.76 41.03 90 top
TP203  -  [TP30_SMD]  179.17 41.03 90 top
TP204  THRU HOLE  [TP_40X65]  159.08 40.76 270 top
TP205  THRU HOLE  [TP_40X65]  161.62 40.76 270 top
TP206  -  [TP30_SMD]  76.14 40.56 90 top
TP207  5002  [TP_CIR67D40_TH_4-6]  218.5 40.42 0 top
TP208  -  [TP30_SMD]  71.6 39.83 0 top
TP209  -  [TP30_SMD]  185.22 38.5 270 top
TP210  -  [TP30_SMD]  185.22 37.09 270 top
TP211  5002  [TP_CIR67D40_TH_4-6]  66.45 36.43 0 top
TP212  -  [TP40_SMD]  46.19 36.15 270 top
TP213  THRU HOLE  [TP_40X65]  183.13 35.83 0 top
TP214  -  [TP30_SMD]  153.38 35.38 90 top
TP215  -  [TP30_SMD]  154.79 35.38 90 top
TP216  -  [TP30_SMD]  185.22 34.31 180 top
TP217  -  [TP40_SMD]  46.19 34.12 270 top
TP218  -  [TP30_SMD]  185.22 32.9 180 top
TP219  -  [TP30_SMD]  109.66 29.83 180 top
TP220  -  [TP30_SMD]  162.68 29.58 0 top
TP221  -  [TP40_SMD]  168.76 29.13 0 top
TP222  -  [TP40_SMD]  139.28 27.6 180 top
TP223  -  [TP30_SMD]  193.72 26.97 0 top
TP224  -  [TP30_SMD]  219.82 26.97 0 top
TP225  -  [TP40_SMD]  180.63 25.84 0 top
TP226  -  [TP40_SMD]  228.15 25.31 270 top
TP227  THRU HOLE  [TP_40X65]  133.64 24.85 0 top
TP228  -  [TP30_SMD]  95.86 24.77 0 top
TP229  -  [TP30_SMD]  70.33 24.77 0 top
TP230  -  [TP40_SMD]  55.66 23.35 0 top
TP231  -  [TP40_SMD]  52.89 22.97 0 top
TP232  -  [TP30_SMD]  85.68 22.69 0 top
TP233  -  [TP40_SMD]  43.36 22.51 180 top
TP234  -  [TP40_SMD]  109.41 22.32 0 top
TP235  -  [TP30_SMD]  69.37 21.63 0 top
TP236  -  [TP30_SMD]  95.03 21.63 0 top
TP237  -  [TP30_SMD]  133.61 20.21 90 top
TP238  -  [TP30_SMD]  167.5 19.67 180 top
TP239  -  [TP30_SMD]  113.75 18.5 270 top
TP240  THRU HOLE  [TP_40X65]  63.74 17.43 0 top
TP243  THRU HOLE  [TP_40X65]  182.24 13.68 0 top
TP244  THRU HOLE  [TP_40X65]  199.32 12.68 0 top
TP245  -  [TP40_SMD]  36 12.56 270 top
TP246  THRU HOLE  [TP_40X65]  223.55 11.62 90 top
TP247  -  [TP40_SMD]  36.46 9.58 270 top
TP248  THRU HOLE  [TP_40X65]  212.74 9.18 0 top
TP249  THRU HOLE  [TP_40X65]  16.32 8.57 0 top
TP250  -  [TP30_SMD]  113.47 8.16 0 top
TP251  THRU HOLE  [TP_40X65]  195.51 2.52 90 top
TP252  -  [TP30_SMD]  185.07 181.74 270 bottom
TP253  -  [TP30_SMD]  185.05 180.02 270 bottom
TP254  -  [TP30_SMD]  180.78 179.36 270 bottom
TP255  -  [TP40_SMD]  102.51 173.28 0 top
TP256  -  [TP40_SMD]  128.5 173.14 0 top
TP258  -  [TP30_SMD]  116.11 132.42 180 bottom
TP259  -  [TP30_SMD]  97.19 133.29 270 top
TP260  -  [TP30_SMD]  33.64 125.48 180 bottom
TP261  -  [TP30_SMD]  152.15 124.73 270 bottom
TP262  -  [TP30_SMD]  150.73 124.73 270 bottom
TP263  -  [TP30_SMD]  66.4 124.07 0 bottom
TP264  -  [TP30_SMD]  66.4 122.66 0 bottom
TP265  -  [TP30_SMD]  94 122.63 0 bottom
TP266  -  [TP30_SMD]  136.18 121.83 180 bottom
TP269  -  [TP30_SMD]  142.76 126.75 180 bottom
TP270  -  [TP30_SMD]  94 121.21 0 bottom
TP271  -  [TP30_SMD]  159.44 121.1 0 bottom
TP272  -  [TP30_SMD]  136.18 120.57 180 bottom
TP275  -  [TP30_SMD]  144.08 126.75 180 bottom
TP277  -  [TP30_SMD]  159.44 119.68 0 bottom
TP278  -  [TP30_SMD]  67.07 118.25 270 bottom
TP279  -  [TP30_SMD]  65.66 118.25 270 bottom
TP280  -  [TP30_SMD]  94.26 117.6 90 bottom
TP283  -  [TP30_SMD]  94.26 116.19 90 bottom
TP287  -  [TP30_SMD]  122.53 115.23 0 top
TP289  -  [TP40_SMD]  183.21 103 0 top
TP290  -  [TP30_SMD]  50.81 101.83 0 bottom
TP291  -  [TP18_SMD]  175.73 97.32 180 bottom
TP292  -  [TP18_SMD]  174.71 96.69 180 bottom
TP293  -  [TP30_SMD]  89.26 95.45 180 bottom
TP294  -  [TP30_SMD]  71.36 94.28 0 bottom
TP295  -  [TP30_SMD]  91.35 95.43 180 bottom
TP296  -  [TP30_SMD]  71.36 92.87 0 bottom
TP297  -  [TP30_SMD]  197.84 92.81 270 bottom
TP298  -  [TP30_SMD]  196.43 92.81 270 bottom
TP299  -  [TP30_SMD]  193.01 92.56 270 bottom
TP300  -  [TP30_SMD]  191.59 92.56 270 bottom
TP301  -  [TP30_SMD]  188.8 82.99 0 bottom
TP302  -  [TP30_SMD]  188.8 84.4 0 bottom
TP303  -  [TP30_SMD]  71.36 89.24 0 bottom
TP304  -  [TP30_SMD]  71.36 87.82 0 bottom
TP305  -  [TP30_SMD]  71.36 84.19 0 bottom
TP306  -  [TP30_SMD]  71.36 82.77 0 bottom
TP307  -  [TP30_SMD]  71.36 79.14 0 bottom
TP308  -  [TP30_SMD]  166.97 78.2 0 top
TP309  -  [TP30_SMD]  71.36 77.73 0 bottom
TP310  -  [TP30_SMD]  167.63 75.99 0 top
TP311  -  [TP30_SMD]  71.36 74.56 180 bottom
TP312  -  [TP30_SMD]  96.84 74.03 180 bottom
TP313  -  [TP30_SMD]  95.53 74.03 180 bottom
TP314  -  [TP30_SMD]  71.36 73.14 180 bottom
TP315  -  [TP30_SMD]  162.38 73.18 0 top
TP316  -  [TP30_SMD]  71.36 69.04 180 bottom
TP317  -  [TP30_SMD]  71.36 67.63 180 bottom
TP318  -  [TP30_SMD]  93.54 66.63 180 bottom
TP319  -  [TP30_SMD]  71.36 64.26 0 bottom
TP320  -  [TP30_SMD]  71.36 62.85 0 bottom
TP321  -  [TP40_SMD]  24.93 49.61 0 top
TP322  -  [TP30_SMD]  208.33 25.59 0 top
TP323  5002  [TP_CIR67D40_TH_4-6]  60.26 3.84 0 top
TP324  5002  [TP_CIR67D40_TH_4-6]  31.49 179.15 0 top
TP325  5002  [TP_CIR67D40_TH_4-6]  236.1 13.24 0 top
TP326  5002  [TP_CIR67D40_TH_4-6]  125.42 31.08 180 bottom
TP327  THRU HOLE  [TP_40X65]  178.25 5.18 0 top
TP328  THRU HOLE  [TP_40X65]  178.25 7.72 0 top
TP329  THRU HOLE  [TP_40X65]  175.71 7.72 0 top
TP330  THRU HOLE  [TP_40X65]  175.71 5.18 0 top
TP331  THRU HOLE  [TP_40X65]  178.25 2.64 0 top
TP10123  -  [TP30_SMD]  136.18 116 0 top
TP10124  -  [TP30_SMD]  136.18 117.15 0 top
U1  CSD85312Q3E  [VSON8_CSD85312Q3E_130X130_1]  177.5 187.58 0 top
U2  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  19.54 184.05 270 top
U3  BZX84C6V8LT1G  [SOT23-123_1-2]  137.55 181.31 270 top
U4  BSS138-7-F  [SOT23-123_1-1]  155.39 179.65 270 top
U5  TPD2E2U06-Q1  [SC70-3_1-1]  149.35 178.12 90 top
U6  TPS79601DRBR  [SON8_25-59_130X130_1]  26.9 176.68 0 top
U7  BSS138-7-F  [SOT23-123_1-1]  155.99 175.75 0 top
U8  TPS25830QWRHBTQ1  [VQFN32_TPS25830-Q1_200X200_1]  176.26 175.52 90 top
U9  TPD3S014DBVR  [SOT23-6_1-5]  42.99 172.59 90 top
U10  SN74AVC8T245PWR  [TSSOP24_25-59_315X180_1-2]  16.11 172.42 90 top
U11  TUSB4041IPAPR  [HTQFP64_TUSB4041I_400X400_1-2]  67.66 169.93 0 top
U12  TS3USB221ARSER  [UQFN10_19-68_80X60]  138.31 168.74 270 top
U13  LM4040B25IDCKR  [SC70-5_1-1]  22.79 167.43 0 top
U14  SN74LVC1G00DCKRG4  [SC70-5_1-1]  33.58 167.11 90 top
U15  SN74CBTLV1G125DBVR  [SOT23-5]  29.83 166.96 180 top
U16  LM74500QDDFRQ1  [SOT23-8_1-1]  207.73 164.65 90 top
U18  TCA6408ARGTR  [QFN16_19-68_120X120_1_EP1-6]  134.35 161.63 90 top
U19  SN74CBTLV3257PWR  [TSSOP16_25-59_205X180]  12.12 160.77 270 top
U20  PCA9306DCTR  [SSOP8_25-59_120X110_1-3]  128.14 160.68 90 top
U21  CSD18540Q5B  [VSON8_CSD1850_240X200_1-1]  216.21 159.67 270 top
U22  CDCI6214RGET  [QFN24_19-68_160X160_1]  109.9 158.43 180 top
U23  CDCEL937PWR  [TSSOP20_25-59_260X180_1-2]  93.02 154.46 0 top
U24  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  192.87 153.77 90 top
U25  LM5143QRHARQ1  [QFN40_19-68_240X240_1_EP3-4]  203.72 150.35 270 top
U26  THGAF8G8T23BAIL  [VFBGA153_19-68_460X520_0-8]  145.59 150.07 90 top
U27  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  192.71 146.92 270 top
U28  SUM60N10-17-E3  [D2PAK-3]  216.34 148.5 0 top
U29  SN74CB3Q3125PWR  [TSSOP14_25-59_205X180_1-2]  9.42 143.58 270 top
U30  CSD16407Q5  [VSON8_CSD16407Q5_240X200_1-1]  187.87 98.52 90 top
U31  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  203.17 136.14 0 top
U32  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  203.17 136.14 270 top
U33  SN74LVC1G00DCKRG4  [SC70-5_1-1]  48.27 123.28 180 top
U34  TPS22918DBVR  [SOT23-6]  29.38 122.96 270 top
U35  TPS62873Y1QWRXSRQ1  [VQFN16_TPS62872-Q1_100X140_1-1]  169.66 120.62 0 top
U36  TPS62873Y1QWRXSRQ1  [VQFN16_TPS62872-Q1_100X140_1-1]  181.09 120.62 0 top
U37  TPS62873Y1QWRXSRQ1  [VQFN16_TPS62872-Q1_100X140_1-1]  192.26 120.62 0 top
U38  SN74CBTLV1G125DBVR  [SOT23-5]  48.42 119.52 270 top
U39  SN74LVC1G08DBVRE4  [SOT23-5]  43.39 119.41 270 top
U40  CDCI6214RGET  [QFN24_19-68_160X160_1]  58.3 117.36 270 top
U41  TPS74501PQWDRVRQ1  [SON6_25-59_85X85_0-8]  109.2 115.95 90 top
U42  TPS62873Y1QWRXSRQ1  [VQFN16_TPS62872-Q1_100X140_1-1]  74.48 113.7 90 top
U43  TCA6416ARTWR  [WQFN24_19-68_160X160]  45.63 113.41 270 top
U44  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  227.03 109.23 90 top
U45  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  231.48 107.46 270 top
U46  LM5140QRWGTQ1  [QFN40_19-68_240X240_0-9_EP3-4]  216.06 104.79 90 top
U47  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  25.08 103.85 0 top
U48  TPS62873Y1QWRXSRQ1  [VQFN16_TPS62872-Q1_100X140_1-1]  74.48 102.52 90 top
U49  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  231.48 102.11 90 top
U50  SN74CBT16214CDGGR  [TSSOP56_19-68_560X240_1-2]  48.29 101.33 180 top
U51  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  227.03 100.04 270 top
U52  MTFC32GAZAQHD-AAT  [VFBGA153_19-68_460X520_0-9]  175.19 98.56 90 top
U53  TLV7103318DSET  [WSON6_19-68_60X60]  73.45 91.24 0 top
U54  MT53E2G32D4DE-046 AUT:C  [WFBGA200_MT53DDS_400X570_1-2]  150.73 89.71 180 top
U55  TMP100NA/3K  [SOT23-6_1-5]  100.67 86.98 180 top
U56  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  196.06 83.43 180 top
U57  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  196.06 83.43 270 top
U58  SN74CBT16214CDGGR  [TSSOP56_19-68_560X240_1-2]  48.29 83.98 180 top
U59  J7AHP27  [BGASKT-33X33-1063-P8MM]  121.12 81.43 180 top
U60  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  196.06 79.4 180 top
U61  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  196.06 79.4 270 top
U62  TPS22965NDSGR  [WSON8_19-68_80X80_0-8]  80.98 80.22 90 top
U63  TPS74501PQWDRVRQ1  [SON6_25-59_85X85_0-8#2]  85.31 80.27 270 top
U64  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  196.06 75.37 270 top
U65  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  196.06 75.37 180 top
U66  TPS74501PQWDRVRQ1  [SON6_25-59_85X85_0-8]  78.8 75.22 180 top
U67  TLV73318PQDRVRQ1  [SON6_25-59_85X85_0-8#2]  87.61 75.22 180 top
U68  TPS6594133ARWERQ1  [VQFN56_19-68_320X320_0-9_EP6]  176.08 74.07 0 top
U69  RE1J002YNTCL  [SOT416F-6_0-9]  75.83 70.98 180 top
U70  NX3008CBKS  [SOT363-6_1-1]  72.8 69.83 90 top
U71  MT53E2G32D4DE-046 AUT:C  [WFBGA200_MT53DDS_400X570_1-2]  150.73 68.37 180 top
U72  CAT24C256WI-GT3  [SOIC8_1-8]  23.4 68.08 0 top
U73  CAV24C256YE-GT3  [TSSOP8_25-59_125X180_1-2]  23.4 68.08 270 top
U75  TPS22965NDSGR  [WSON8_19-68_80X80_0-8]  82.57 66.58 0 top
U76  TCA6408ARGTR  [QFN16_19-68_120X120_1_EP1-6]  192.85 66.12 180 top
U78  SN74LVC2G66QDCURQ1  [VSSOP8_19-68_85X95_0-9]  27.82 62.16 270 top
U79  MT25QU512ABB8E12-0SIT  [TPBGA24_39-37_240X320_1-2]  138.6 46.73 180 top
U80  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  191.91 58.07 180 top
U81  LM5141QRGETQ1  [VQFN24_LM5141_160X160_1]  206.76 57.69 90 top
U82  TMP100NA/3K  [SOT23-6_1-5]  195.94 100.05 0 top
U83  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  192.48 51.69 180 top
U84  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  192.48 51.69 270 top
U85  TPS74501PQWDRVRQ1  [SON6_25-59_85X85_0-8]  159.06 51.59 0 top
U86  SN74LVC1G08DBVRE4  [SOT23-5]  71.05 50.78 270 top
U87  PPS389006004NRTERQ1  [QFN16_19-68_120X120_0-8_EP1-8]  179.46 50.63 0 top
U88  PCA9306DCTR  [SSOP8_25-59_120X110_1-3]  207.81 50.22 180 top
U89  PPS389006004NRTERQ1  [QFN16_19-68_120X120_0-8_EP1-8]  169.83 49.89 90 top
U92  SN74LVC1G08DBVRE4  [SOT23-5]  67.01 49.66 270 top
U93  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  192.48 46.93 270 top
U94  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  192.48 46.93 180 top
U97  SN74LVC1G08DBVRE4  [SOT23-5]  71.05 45.83 270 top
U98  MAX6818EAP+T  [SSOP20_25-59_295X220_2]  226.7 45.3 180 top
U99  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  192.48 42.74 270 top
U100  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  192.48 42.74 180 top
U101  SN74LVC1G08DBVRE4  [SOT23-5]  87.54 42.73 180 top
U102  SN74LVC1G08DBVRE4  [SOT23-5]  65.92 42.35 90 top
U103  SN74LVC1G17DCKR  [SC70-5]  49.23 41.05 180 top
U104  TXB0101DRLR  [SOT563-6_0-6]  82.2 39.07 180 top
U105  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  192.48 38.55 270 top
U106  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  192.48 38.55 180 top
U107  SN74LVC1G08DBVRE4  [SOT23-5]  74.92 37.79 270 top
U108  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  60.48 37.66 90 top
U109  TLIN1022DMTTQ1  [VSON14_25-59_120X180_0-9]  25.7 36.67 90 top
U110  TXB0101DRLR  [SOT563-6_0-6]  82.2 36.41 180 top
U111  SN74LVC1G08DBVRE4  [SOT23-5]  90.14 35.56 0 top
U112  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  51.53 34.92 180 top
U113  SN74LVC2G74  [VSSOP8_19-68_85X95]  227.01 34.83 270 top
U114  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  192.48 34.36 270 top
U115  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  192.48 34.36 180 top
U116  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  170.58 33.78 180 top
U117  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  170.58 33.78 90 top
U118  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  174.9 33.78 90 top
U119  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  174.9 33.78 180 top
U120  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  179.21 33.78 90 top
U121  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  179.21 33.78 180 top
U122  TPS3711DDCR  [SOT23-6_1-1]  160.71 31.96 0 top
U123  TPS3808G33DBVR  [SOT23-6_1-5]  223.71 31.53 270 top
U124  SN74LVC1G11DCKR  [SC70-6]  166 31.45 0 top
U125  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  116.26 30.51 180 top
U126  BSS138-7-F  [SOT23-123_1-1]  80.17 30.31 90 top
U127  SN74LVC1G126DBVR  [SOT23-5_1-5]  132.85 29.45 180 top
U128  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  154.84 28.12 90 top
U129  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  154.84 28.12 180 top
U130  SN74LVC1G11DCKR  [SC70-6]  228.28 27.97 0 top
U131  TPS3808G33DBVR  [SOT23-6_1-5]  163.51 27.13 0 top
U132  TCA6408ARGTR  [QFN16_19-68_120X120_1_EP1-6]  54.59 26.53 90 top
U133  BSS138-7-F  [SOT23-123_1-1]  108.29 25.84 0 top
U134  SN74LVC1G07DRLRG4  [SOT553-5_0-6]  126.2 25.61 90 top
U135  OPA2322AIDGKR  [VSSOP8_25-59_120X120_1-1]  30.72 24.97 270 top
U136  OPA2322AIDGKR  [VSSOP8_25-59_120X120_1-1]  40.55 24.19 270 top
U137  BSS138LT1G  [SOT23-123_1-2]  129.17 24.11 90 top
U138  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  116.26 23.07 180 top
U139  TPS61240DRV  [SON6_25-59_85X85]  170.72 22.34 0 top
U140  BSS138-7-F  [SOT23-123_1-1]  82.51 20.89 270 top
U141  OPA2322AIDGKR  [VSSOP8_25-59_120X120_1-1]  26.54 20.72 90 top
U142  TPS61240DRV  [SON6_25-59_85X85]  139.15 20.48 0 top
U143  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  202.12 20.16 270 top
U144  FT2232HL  [LQFP64_19-68_400X400_1-6]  190.29 19.18 90 top
U145  FT4232HL  [LQFP64_19-68_390X390_1-6]  216.39 19.18 90 top
U146  OPA2322AIDGKR  [VSSOP8_25-59_120X120_1-1]  30.72 16 90 top
U147  93LC56B-I/SN  [SOIC8]  177.74 14.86 90 top
U148  TCAN1043-Q1  [SOIC14_1-8]  119.06 12.22 270 top
U149  TCAN1042HGVD  [SOIC8_1-8]  130.62 12.03 270 top
U150  TCAN1042HGVD  [SOIC8_1-8]  140.42 12.03 270 top
U151  TCAN1042HGVD  [SOIC8_1-8]  150.22 12.03 270 top
U152  TCAN1042HGVD  [SOIC8_1-8]  160.03 12.03 270 top
U153  TCAN1042HGVD  [SOIC8_1-8]  169.83 12.03 270 top
U154  PCM3168APAP  [HTQFP64_19-68_400X400_1-2_EP7-3X7]  46.76 11.24 0 top
U155  SN74LVC1G04DRLR  [SOT553-5]  125.76 10.32 270 top
U156  TPD2E001DRLR  [SOT553-5_0-6]  188.44 6.86 180 top
U157  TPD2E001DRLR  [SOT553-5_0-6]  211.37 6.86 180 top
U158  TUSB321RWBR  [X2QFN12_TUSB322I_60X60_0-4]  181.86 183.88 270 bottom
U160  TPD3S014DBVR  [SOT23-6_1-5]  54.85 181.35 180 bottom
U161  SN74LVC1G08DBVRE4  [SOT23-5]  160.13 179.02 90 bottom
U162  BSS138-7-F  [SOT23-123_1-1]  156.23 178.82 270 bottom
U163  TPD3S014DBVR  [SOT23-6_1-5]  139.9 178.73 180 bottom
U164  TPD2E2U06-Q1  [SC70-3_1-1]  149.35 177.83 270 bottom
U165  SN74CBTLV1G125DBVR  [SOT23-5]  181.77 176.11 270 bottom
U166  SI2301CDS-T1-GE3  [SOT23-123]  186.75 176.06 0 bottom
U167  SN74LVC1G17DCKR  [SC70-5]  123.59 175.41 270 bottom
U168  SN74LVC1G17DCKR  [SC70-5]  97.45 175.31 270 bottom
U169  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  106.87 170.97 90 bottom
U170  TM4C1294NCPDTT3R  [TQFP128_15-74_550X550_1-2]  17.06 170.26 90 bottom
U171  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  189.5 170.05 180 bottom
U172  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  189.5 170.05 270 bottom
U173  TCA6424ARGJR  [QFN32_19-68_200X200]  157.66 167.9 180 bottom
U174  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  131.5 167.55 180 bottom
U175  SN74LVC1G08DBVRE4  [SOT23-5]  33.88 166.91 270 bottom
U176  SN74CBTLV1G125DBVR  [SOT23-5]  30.25 166.91 270 bottom
U177  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  146.73 164.69 180 bottom
U178  CSD18563Q5A  [VSONP8_CSD19531_230X200_1-1]  183.82 153.32 180 bottom
U179  BSS138-7-F  [SOT23-123_1-1]  207.17 152.76 90 bottom
U180  CSD18563Q5A  [VSONP8_CSD19531_230X200_1-1]  183.82 147.45 180 bottom
U181  TCA9543APWR  [TSSOP14_25-59_205X180_1-2]  21.2 144.78 270 bottom
U182  LM5060MM  [MSOP10_19-68_120X120_1-1]  210.12 140.62 90 bottom
U183  19.200MHz  [OSC4_831056216_80X70_SMD_0-8]  118.3 134.72 0 bottom
U184  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  152.19 131.99 270 bottom
U185  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  152.19 131.99 180 bottom
U186  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  87.33 129.19 0 bottom
U187  SN65DSI86IPAPQ1  [HTQFP64_SN65DSI86_400X400_1-2]  107.27 128.06 90 bottom
U188  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  59.14 124.11 270 bottom
U189  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  59.14 124.11 0 bottom
U190  SN74LVC1G08DBVRE4  [SOT23-5]  48.47 123.58 0 bottom
U191  TPD2E001DRLR  [SOT553-5_0-6]  25.04 123.34 270 bottom
U192  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  86.76 122.6 270 bottom
U193  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  86.76 122.6 0 bottom
U194  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  152.18 121.14 270 bottom
U195  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  152.18 121.14 0 bottom
U196  SN74CBTLV1G125DBVR  [SOT23-5]  48.47 119.95 0 bottom
U197  TPD2E001DRLR  [SOT553-5_0-6]  25.23 119.65 90 bottom
U198  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  87.02 117.57 270 bottom
U199  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  87.02 117.57 0 bottom
U200  TPD2E001DRLR  [SOT553-5_0-6]  27.35 116.1 180 bottom
U201  TLV73333PQDRVRQ1  [SON6_25-59_85X85_0-8#2]  116.7 115.68 180 bottom
U202  TPD2E001DRLR  [SOT553-5_0-6]  25.57 112.41 180 bottom
U203  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  65.62 110.99 90 bottom
U204  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  65.62 110.99 0 bottom
U206  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  25.08 103.85 0 bottom
U207  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  197.88 100.07 180 bottom
U208  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  197.88 100.07 270 bottom
U209  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  193.05 99.82 270 bottom
U210  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  193.05 99.82 180 bottom
U211  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  196.06 82.95 90 bottom
U212  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  196.06 82.95 180 bottom
U213  SN74LVC1G17DCKR  [SC70-5]  182.71 98.66 90 bottom
U214  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 94.33 270 bottom
U215  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 94.33 0 bottom
U216  RE1J002YNTCL  [SOT416F-6_0-9]  175.9 91.73 0 bottom
U217  RE1J002YNTCL  [SOT416F-6_0-9]  172.58 90.16 0 bottom
U218  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 89.28 0 bottom
U219  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 89.28 270 bottom
U220  SN74LVC1G07DRLRG4  [SOT553-5_0-6]  26.88 84.89 270 bottom
U221  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 84.23 0 bottom
U222  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 84.23 270 bottom
U223  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  233.75 80.52 90 bottom
U224  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  233.75 80.5 180 bottom
U225  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 79.18 270 bottom
U226  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 79.18 0 bottom
U227  SN74CB3Q3257PWR  [TSSOP16_25-59_205X180]  28.3 77.63 270 bottom
U228  LSM6DSRXTR  [LGA14_19-68_120X100_0-9]  19.54 76.16 270 bottom
U229  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 74.6 0 bottom
U230  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 74.6 270 bottom
U231  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 69.09 270 bottom
U232  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 69.09 0 bottom
U233  SN74AVC8T245RHL  [QFN24_19-68_220X140_1]  52.49 66.59 180 bottom
U234  SN74LVC1G126DBVR  [SOT23-5_1-5]  199.6 65.62 90 bottom
U235  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  64.1 64.27 270 bottom
U236  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  64.1 64.27 0 bottom
U237  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  213.8 63.79 90 bottom
U238  INA231AIYFDR  [DSBGA12_15-74_60X70_0-4]  238.8 63.65 0 bottom
U239  INA226AIDGSR  [MSOP10_19-68_120X120_1-1]  238.8 63.65 90 bottom
U240  CSD18543Q3A  [VSONP8_CSD18543Q_120X130_0-9]  218.25 62.01 270 bottom
U241  TS3DDR3812RUAR  [TQFN42_19-68_140X360_0-8]  124.29 45.91 270 top
U242  TXS0108ERGYR  [QFN20_19-68_185X145_1]  192.16 58.07 180 bottom
U243  TCA6424ARGJR  [QFN32_19-68_200X200]  52.62 57.45 90 bottom
U244  SN74AVC4T245DGVR  [TVSOP16_15-74_150X180]  59.27 51.52 0 bottom
U245  W35N01JWTBAG  [TPBGA24_39-37_240X320_1-2]  120.35 37.9 180 top
U246  S28HS512TGABHM010  [BGA24_39-37_240X310_1]  128.1 37.9 180 top
U247  SN74LVC1G08DBVRE4  [SOT23-5]  16.13 47.31 180 bottom
U248  SN74AVC4T245DGVR  [TVSOP16_15-74_150X180]  59.27 46.77 0 bottom
U249  SN74LVC1G11DCKR  [SC70-6]  26.06 44.67 90 bottom
U250  AT24CM01  [TSSOP8_25-59_125X180_1-2]  192.44 44.53 90 bottom
U251  SN74LVC1G11DCKR  [SC70-6]  21.94 43.79 180 bottom
U252  SN74LVC1G11DCKR  [SC70-6]  15.47 43.79 0 bottom
U253  SN74LVC1G08DBVRE4  [SOT23-5]  49.23 40.8 180 bottom
U254  SN74LVC1G08DBVRE4  [SOT23-5]  82.18 38.17 270 bottom
U255  SN74LVC1G11DCKR  [SC70-6]  160.59 31.83 270 bottom
U256  MCP79410-I/SN  [SOIC8_1-8]  139.3 30.11 270 bottom
U257  SN74LVC1G06DCKT  [SC70-5_1-1]  61.44 29.53 180 bottom
U258  SN74LVC1G11DCKR  [SC70-6]  163.89 29.17 0 bottom
U259  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  185.19 27.71 270 bottom
U260  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  85.3 27.59 270 bottom
U261  DP83867ERGZT  [VQFN48_19-68_285X285]  99.36 25.02 90 bottom
U262  DP83867ERGZT  [VQFN48_19-68_285X285]  73.71 25.02 90 bottom
U263  BSS138-7-F  [SOT23-123_1-1]  108.62 24.95 0 bottom
U264  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  219.36 24.21 0 bottom
U265  TLV7103318DSET  [WSON6_19-68_60X60]  179.48 22.99 90 bottom
U266  TPS74801DRCR  [VSON10_TPS74801-Q1_120X120_1]  60 21.67 270 bottom
U267  OPA1688IDR  [SOIC8_1-8]  26.59 20.72 270 bottom
U268  CCBTLV3257MPWREP  [TSSOP16_25-59_205X180_1-2]  227.92 19.57 90 bottom
U269  SN74CB3Q3125PWR  [TSSOP14_25-59_205X180_1-2]  234.25 19.36 270 bottom
U270  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  193.2 19.11 0 bottom
U271  BSS138-7-F  [SOT23-123_1-1]  107.96 18.73 270 bottom
U272  BSS138-7-F  [SOT23-123_1-1]  82.3 18.73 270 bottom
U273  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  219.29 18.13 0 bottom
U274  TPD4E004DRYR  [SON6_19-68_40X60_PB_0-6]  238.34 17.83 180 bottom
U275  93LC56B-I/SN  [SOIC8]  204.28 10.87 270 bottom
U276  TPS73433DDCT  [SOT23-5_1-1]  196.5 8.11 0 bottom
U277  TPS73433DDCT  [SOT23-5_1-1]  219.11 7.63 0 bottom
U278  SN74LVC1G07DRLRG4  [SOT553-5_0-6]  128.65 25.34 90 bottom
U279  SN74LVC1G97DBVT  [SOT23-6]  76.51 66.93 180 top
U281  SN74LVC1G97DBVT  [SOT23-6]  64.7 93.09 0 top
U5028  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  151.01 106.76 90 top
U5029  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  152.92 106.76 90 top
U5030  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  154.82 106.76 90 top
U5031  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  156.73 106.76 90 top
U5036  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  97.21 94.52 90 bottom
U5037  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  99.5 94.52 90 top
U5038  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  99.5 97.06 90 top
U5039  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  99.5 91.98 90 top
U5049  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  145.35 56.8 0 top
U5050  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  142.81 55.15 0 top
U5051  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  145.98 54.9 0 top
U5052  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  149.16 54.9 0 top
U5053  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  142.81 53.75 0 top
U5054  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  145.98 52.99 0 top
U5055  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  149.16 52.99 0 top
U5064  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  88.96 113.89 180 bottom
U5072  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  91.25 112.75 0 bottom
U5073  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  88.96 112.75 180 bottom
U5074  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  91.25 111.6 0 bottom
U5075  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  88.96 111.6 180 bottom
U5077  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  91.25 110.46 0 bottom
U5078  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  88.96 110.46 0 bottom
U5079  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  91.25 109.32 0 bottom
U5080  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  88.96 109.32 0 bottom
U5090  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  156.73 106.76 270 bottom
U5091  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  154.82 106.76 270 bottom
U5092  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  152.92 106.76 270 bottom
U5093  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  151.01 106.76 270 bottom
U5099  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  126.45 87.71 45 bottom
U50100  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.93 87.83 225 bottom
U50101  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  113.9 81.23 180 bottom
U50102  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  125.51 77.42 135 bottom
U50103  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  126.32 78.23 315 bottom
U50104  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  112.31 86.61 180 bottom
U50105  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  116.31 80.23 270 bottom
U50106  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.92 83.82 225 bottom
U50107  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  126.2 75.95 45 bottom
U50108  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  114.33 86.26 225 bottom
U50109  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.93 86.23 225 bottom
U50110  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  126.32 83.03 225 bottom
U50111  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.11 80.65 315 bottom
U50112  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.64 80.52 225 bottom
U50113  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  128.74 100.1 90 bottom
U50114  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  111.92 85.42 45 bottom
U50115  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.51 79.05 225 bottom
U50116  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  114.31 87.83 225 bottom
U50117  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  124.72 86.23 225 bottom
U50118  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  123.91 77.45 135 bottom
U50119  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.11 74.22 225 bottom
U50120  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  118.32 76.63 225 bottom
U50121  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  123.25 87.71 225 bottom
U50123  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  123.12 86.23 225 bottom
U50124  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.25 83.16 135 bottom
U50125  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.92 82.63 180 bottom
U50126  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  118.19 78.36 225 bottom
U50127  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.51 86.23 225 bottom
U50128  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.38 87.96 225 bottom
U50129  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  121.88 78.79 180 bottom
U50130  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  121.62 82.19 90 bottom
U50131  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.51 77.83 180 bottom
U50133  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  118.32 83.82 45 bottom
U50134  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  134.7 100.1 270 bottom
U50135  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  125.1 84.23 270 bottom
U50136  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.93 83.85 135 bottom
U50138  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  123.53 81.43 180 bottom
U50139  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  120.53 76.23 270 bottom
U50140  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  121.04 87.83 210 bottom
U50142  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  123.53 82.83 180 bottom
U50143  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.53 84.63 225 bottom
U50144  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.11 86.23 225 bottom
U50145  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  132.55 100.1 90 bottom
U50146  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  130.64 100.1 90 bottom
U50147  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  124.32 76.2 180 bottom
U50148  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  122.31 77.42 135 bottom
U50149  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  121.12 80.16 180 bottom
U50152  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.52 77.03 270 bottom
U50153  10uF  [EMIFIL_NFM18C_0603_0-7_TI]  123.53 80.04 180 bottom
U50156  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  122.31 75.82 135 bottom
U50157  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.11 88.65 135 bottom
U50158  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.92 83.82 135 bottom
U50159  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.52 76.23 90 bottom
U50160  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  117.51 74.22 225 bottom
U50162  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.14 79.05 135 bottom
U50163  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  122.31 73.43 225 bottom
U50164  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  111.92 87.83 135 bottom
U50165  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  113.52 78.23 225 bottom
U50166  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  113.52 79.83 45 bottom
U50167  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  115.12 79.83 225 bottom
U50168  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  126.32 85.42 135 bottom
U50169  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  123.91 73.43 225 bottom
U50171  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  112.66 83.77 135 bottom
U50172  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  111.92 83.03 135 bottom
U50174  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  113.91 85.01 0 bottom
U50178  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.92 85.42 135 bottom
U50179  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.24 80.49 225 bottom
U50183  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  119.92 73.43 225 bottom
U50184  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  128.71 76.63 225 bottom
U50185  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  128.84 78.11 225 bottom
U50186  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  128.71 75.03 45 bottom
U50187  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  125.51 73.43 225 bottom
U50188  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  122.72 74.63 180 bottom
U50189  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.24 73.3 225 bottom
U50191  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  125.66 79.68 225 bottom
U50192  1uF  [EMIFIL_NFM15CC_0402_0-5_TI]  127.97 87.07 135 bottom
Y1  24.000MHz  [XTAL_ECX-64AEN_240X150_SMD_1-1]  93 161.78 180 top
Y2  24.000MHz  [XTAL_ECX-64AEN_240X150_SMD_1-1]  70.34 156.06 0 top
Y3  25.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  117.15 155.84 270 top
Y4  25.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  60.89 124.62 0 top
Y5  26.000MHz  [XTAL4_ABM10W_100X80_SMD_0-6]  118.58 59.4 180 top
Y6  19.200MHz  [XTAL4_ABM10W_100X80_SMD_0-6]  112.09 60.78 270 top
Y7  12.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  207.63 10.29 270 top
Y8  12.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  183.08 9.27 270 top
Y9  16.000MHZ  [XTAL4_NX3225GA_130X100_SMD_0-9]  20.11 182.07 0 bottom
Y10  32.768KHz  [XTAL_ECS-32_130X60_SMD_0-9]  184.59 80.55 270 bottom
Y11  32.768KHz  [XTAL_ABS07_130X60_SMD_0-9]  138.03 36.58 180 bottom
Y12  25.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  90.72 23.02 90 bottom
Y13  25.000MHz  [XTAL_ABM3_205X130_SMD_1-4]  65.07 23.02 90 bottom

## Library data of the parts
B1 = BATTERY
C1-C24 C26-C31 C33-C36 C41-C43 C48-C50 C53-C55 C58-C60 C63 C64 C66-C79 C81-C91 C93-C123 C126 C134 C136-C171 C175-C198 C200-C234 C236-C247 C249-C279 C281-C331 C334-C343 C346-C355 C358-C366 C369-C373 C376-C548 C550-C620 C629-C643 C650 C654 C655 C666-C668 C676 C678-C726 C729-C731 C742-C744 C746 C747 C749-C753 C755 C756 C758 C762-C766 C768-C770 C772-C774 C776-C780 C782-C830 C832-C841 C844-C851 C853-C860 C862-C867 C870 C872-C875 C877-C902 C904-C923 C925-C944 C947-C955 C957-C960 C962 C963 C965-C974 C976-C986 C988-C990 C992-C997 C999-C1012 C1014-C1029 C1031-C1060 C1062-C1075 C1077-C1086 C1089-C1093 C1095-C1098 C1105 C1117 C1118 C1120 C1122-C1124 C1131 C1134 C1135 C1137 C1138 C1161-C1214 C1216-C1228 C1230-C1269 C1271 C1290-C1293 C2582-C2592 = CAP
C25 C32 C80 C92 C124 C130 C172-C174 C199 C235 C248 C280 C549 C1215 C1229 = CAP_POL
C37-C40 C44-C47 C51 C52 C621-C628 = CAP: signal model: CAP_CAP0201_0-5_0.22UF_0.22uF
C125 C129 FL95 FL161 FL196 R1-R49 R51-R54 R56-R66 R69-R73 R76-R118 R125 R126 R129-R135 R137-R155 R157-R171 R174-R179 R182-R184 R186-R211 R213 R215 R216 R218 R220-R225 R227-R232 R234-R237 R239-R241 R244 R245 R247-R279 R281-R307 R309-R337 R339-R350 R353-R356 R358-R361 R363-R367 R370-R376 R378-R381 R383-R385 R387-R389 R392-R396 R398 R399 R401-R414 R416 R417 R419-R426 R428 R430 R431 R433 R435-R438 R440-R457 R459-R476 R478 R479 R481-R484 R486-R525 R527-R531 R533 R534 R536-R732 R734-R834 R845-R851 R853 R854 R857-R922 R924-R941 R944-R966 R968-R979 R981-R1013 R1015-R1043 R1045-R1051 R1053-R1056 R1059-R1091 R1093-R1095 R1097-R1118 R1120-R1145 R1147 R1149-R1151 R1153 R1155-R1162 R1168 R1170-R1172 R1177-R1200 R1207 R1208 R1215-R1292 R1294-R1305 R1308-R1318 = RESISTOR
C656-C665 = CAP: signal model: CAP_CAP0201_0-5_0.1UF_0.1uF
D1-D28 = DIODE_TPD1E05U06
D29 = DIODE_TVS_DUAL
D30 D36 D39 D41 = DIODE_ZENER
D31 D32 D34 D35 D38 D40 = DIODE_SCHOTTKY
D33 D37 = DIODE_SOD323
D42-D45 = DIODE
F1 F2 = FUSE_HOLDER_0154
FL1-FL6 FL8 FL9 FL26 FL27 = CAP_FILTER
FL7 FL42 FL56-FL63 FL65-FL67 FL70 FL71 FL76 FL81-FL84 FL86 FL87 FL89 FL94 FL96-FL98 FL132 FL151 FL175 FL176 FL194 FL198 = EMIFILTER_IND
FL10-FL25 FL32-FL35 FL40 FL41 FL43-FL48 FL122 FL137 FL141 FL150 FL154 FL170 FL177 FL193 U5028-U5031 U5036-U5039 U5049-U5055 U5064 U5072-U5075 U5077-U5080 U5090-U5093 U5099 U50100-U50121 U50123-U50131 U50133-U50136 U50138-U50140 U50142-U50149 U50152 U50153 U50156-U50160 U50162-U50169 U50171 U50172 U50174 U50178 U50179 U50183-U50189 U50191 U50192 = CAP_NFM_TI
J1 J48 J49 = CON_MUSB-B_5_1051640001
J2 J28 J41 = HEADER_4X1
J3 J47 = CON_TRBLK_2X1
J4 = CON_USB-C_24_1240183621_TI
J5 = CON_USB-A_8
J6 J24 J25 J37 J42-J46 = HEADER_3X1
J7 = CON_POWERJACK_PD-40S
J8 J9 = CON20_USB_F_TI
J10 J55 J57 = CON_PMC_20X2_F_DP_TI
J14 J17 = CON_PCI_32X2_10142333
J23 = CON_PMC_30X2_F_4SH
J26 = HEADER_6X1
J27 = HEADER_10X2
J29 = CON_AUDIOJACK6_STX-4235-3/3
J30 = HEADER_5X1
J32-J36 = HEADER_2X1
J39 J40 = CON_RJ45-14_LPJG16314A4NL
J50 = CON_FLEX_40X1_FH12A-40S-0.5SH
J53 = CON_SDCARD_10_DM3BT-DSF-PEJS
J54 J56 = CON_PMC_60X2_HQCD
L1 L19 L20 L40-L43 = INDUCTOR_FERRITE
L2 L3 L5 L6 = INDUCTOR_DLW31S: signal model: INDUCTOR_DLW31S_IND4_DLW21H_90X_90E
L4 L21-L37 = INDUCTOR
L7-L18 L38 L39 = INDUCTOR_DLW31S
LD1 LD6 = DIODE_LED
LD2-LD5 LD7-LD12 = LED_598-8170-107F
Q1 Q2 U137 = MOSFET_BSS138W
Q3 Q4 U70 = MOSFET_NX3008CBKS
R122 R123 R212 R214 R217 R219 R233 R238 R242 R246 = RESISTOR: signal model: RESISTOR_RES0402_0-5_33E_1%_33E_1%
R136 R180 R181 R185 R308 = RESISTOR_KRL_TI
R226 R243 R338 R351 R352 R357 R362 R369 R377 R382 R415 R418 R427 R429 R432 R439 R485 R923 R1014 R1044 R1052 R1057 R1058 R1092 R1096 = RESISTOR-4TERM
R368 R458 R477 R967 R1119 = RESISTOR: signal model: RESISTOR_RES0402_0-5_0E_0E
R526 R532 = RESISTOR: signal model: RESISTOR_RES0402_0-5_22E_1%_22E_1%
R1201-R1206 R1209-R1214 = RESISTOR: signal model: RESISTOR_RES0201_0-5_0E_0E
SW1 = SW3_SPDT_1101
SW2 = SW10_218-10LPST
SW3 SW5 SW6 SW8-SW10 SW12 SW14 SW15 = 7914G-1-000E _7914G
SW4 SW13 = SW4_GDH02S04
SW7 SW11 = SW8_218-8LPSTR
SW16 = SW8_BD04
TP1-TP5 TP7 TP8 TP10-TP14 TP16-TP18 TP20-TP24 TP26-TP28 TP30-TP40 TP44 TP48 TP49 TP51-TP53 TP57-TP62 TP64-TP73 TP75-TP87 TP90 TP93-TP123 TP125-TP127 TP129 TP130 TP132-TP168 TP170-TP174 TP177-TP179 TP181-TP184 TP189-TP240 TP243-TP256 TP258-TP266 TP269-TP272 TP275 TP277-TP280 TP283 TP287 TP289-TP331 TP10123 TP10124 = TESTPOINT
U1 = MOSFET_CSD85312Q3E
U2 = TPD4E004_SON6
U3 = DIODE_ZENER_SOT23_13
U4 U7 U126 U133 U140 U162 U179 U263 U271 U272 = MOSFET_2N7002_SOT23
U5 U164 = TPD2E007DCK_SC70-3
U6 = TPS79601DRBR_SON8
U8 = TPS25830WQRHBQ1_VQFN32_TI
U9 U160 U163 = TPD3S014D_SOT23-6
U10 = SN74AVC8T245PWR_TSSOP24
U11 = TUSB4041IPAPQ1_HTQFP64_TI
U12 = TS3USB221ARSER_UQFN10
U13 = LM4040B25IDCKR_SC70-5
U14 U33 = SN74LVC1G00_SC70-5
U15 U38 U165 U176 U196 = SN74CBTLV1G125DBVR_SOT23-5
U16 = LM74500QDDFRQ1_SOT23-8
U18 U76 U132 = TCA6408ARGTR_VQFN16
U19 = SN74CBTLV3257PWR_TSSOP16
U20 U88 = PCA9306DCT_SSOP8
U21 = MOSFET_CSD18501Q5A
U22 U40 = CDCI6214RGET_VQFN24
U23 = CDCEL937-Q1_TSSOP20
U24 U27 U44 U45 U49 U51 U237 U240 = MOSFET_CSD18501Q5A_TI
U25 = LM5143-Q1_VQFNP40
U26 = THGAF4G9N4LBAIR_VFBGA153
U28 = MOSFET_IRFZ24NS
U29 U269 = SN74CBTLV3125PWR_TSSOP14
U30 U178 U180 = MOSFET_CSD17301Q5A
U31 U57 U61 U64 U84 U93 U99 U105 U114 U116 U119 U121 U129 U171 U185 U188 U192 U194 U198 U204 U207 U210 U211 U214 U219 U222 U223 U225 U230 U231 U235 U238 = INA231_DSBGA12
U32 U56 U60 U65 U83 U94 U100 U106 U115 U117 U118 U120 U128 U172 U184 U189 U193 U195 U199 U203 U208 U209 U212 U215 U218 U221 U224 U226 U229 U232 U236 U239 = INA226AIDGS_MSOP10
U34 = TPS22918DBVR_SOT23-6
U35-U37 U42 U48 = TPS62872-Q1_VQFN16
U39 U86 U92 U97 U101 U102 U107 U111 U161 U175 U190 U247 U253 U254 = SN74LVC1G08DBVRE4_SOT23-5
U41 U63 U66 U85 = TPS74501_WSON6
U43 = TCA6416ARTWR_WQFN24
U46 = LM5140QRWGTQ1_VQFNP40_TI
U47 U108 U112 U177 U206 U227 = SN74CB3Q3257PWR_TSSOP16
U50 U58 = SN74CBT16214CDGGR_TSSOP56_TI
U52 = MTFC16GAPALBH_TFBGA153
U53 U265 = TLV7103318D_WSON6
U54 U71 = MT53D1024M32D4DT_VFBGA200
U55 U82 = TMP100NA/3K_SOT23-6
U59 = J7AHP27SoC_BGA1063
U62 U75 = TPS22965DSGT_WSON8
U67 U201 = TLV733P-Q1_WSON6
U68 = TPS65941-Q1_VQFN56
U69 U216 U217 = MOSFET_2N7002BK
U72 U73 = CAT24C256WI-GT3_SOIC8
U78 = SN74LVC2G66DCUR_VSSOP8
U79 = MT25QL02GCBB8E12_TPBGA24
U80 U143 U259 U264 U270 U273 = SN74AVC4T245PW_TSSOP16
U81 = LM5141RGET_VQFN24
U87 U89 = PPS38900603NRTERQ1_WQFN16
U98 = MAX6818EAP_SSOP20
U103 U167 U168 U213 = SN74LVC1G17DCKR_SC70-5
U104 U110 = TXS0101DBVR_SOT23-6
U109 = TLIN1022DMTTQ1_VSON14
U113 = SN74LVC2G74DCUR_VSSOP8
U122 = TPS3711DDCR_SOT23-6
U123 U131 = TPS3808G33DBV_SOT23-6
U124 U130 U249 U251 U252 U255 U258 = SN74LVC1G11DCKR_SC70-6
U125 U138 U169 U174 U186 U260 U266 = TPS74801DRCR_SON10
U127 U234 = SN74LVC1G126DBVR_SOT23-5
U134 U220 U278 = SN74LVC1G07DRLRG4_SOT553-5
U135 U136 U141 U146 U267 = OPA2350UA_SOIC8
U139 U142 = TPS61240DRV_SON6
U144 = FT2232H_LQFP64_TI
U145 = FT4232H_LQFP64_TI
U147 U275 = 93LC56B-I/SN_SOIC8
U148 = TCAN1043DQ1_SOIC14_TI
U149-U153 = TCAN1042HGVD_SOIC8
U154 = PCM3168APAP_HTQFP64_TI
U155 = SN74LVC1G04DRLR_SOT553-5
U156 U157 U200 = TPD2E001DRLR_SOT-5
U158 = TUSB321RWB_X2QFN12_TI
U166 = SI2301CDS_SOT23-3
U170 = TM4C1294NCPDTT3R_TQFP128
U173 U243 = TCA6424ARGJR_QFN32
U181 = TCA9543APWR_TSSOP14
U182 = LM5060_MSOP10_TI
U183 = OSC4_ASDMB
U187 = SN65DSI86-Q1_HTQFP64
U191 U197 U202 = TPD2E001DRLR_SOT-5_1
U228 = MODULE_LSM6DSR
U233 = SN74AVC8T245RHL_QFN24
U241 = TS3DDR3812RUAR_WQFN42
U242 = TXS0108ERGYR_QFN20
U244 U248 = SN74AVC4T245DGVR_TVSOP16
U245 = W35N01JWTB_TFBGA24
U246 = S28HS512T_BGA24
U250 = AT24HC04B-TH-B_TSSOP8
U256 = MCP79410_SOIC8
U257 = SN74LVC1G06DCKT_SC70-5
U261 U262 = DP83867ERGZT_VQFN48
U268 = SN74CBTLV3257D_SOIC16
U274 = TPD4E004_SON6_0
U276 U277 = TPS73028DBV_SOT23-5
U279 U281 = SN74LVC1G97DBVT_SOT23-6
Y1-Y4 Y7 Y8 Y10-Y13 = CRY
Y5 Y6 = CRY4_ABM8G
Y9 = CRY4_13

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BATTH_BC501SM_580X590_SMD_4-2
  round 1.194 hole 1.321 unplated: (-4,0)
  round 0.889 hole 1.016 unplated: (3.5,0)
  rect 3.531x2.591 smd: 1(-8.23,0)
  rect 3.658x2.591 smd: 2(7.57,0)
BGA24_39-37_240X310_1
  round 0.356 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
BGASKT-33X33-1063-P8MM
  round 0.406 smd: A1(-12.4,12.8) A2(-11.6,12.8) A3(-10.8,12.8) A4(-10,12.8) A5(-9.2,12.8) A6(-8.4,12.8) A7(-7.6,12.8) A8(-6.8,12.8) A9(-6,12.8) A10(-5.2,12.8) A11(-4.4,12.8) A12(-3.6,12.8) A13(-2.8,12.8) A14(-2,12.8) A15(-1.2,12.8) A16(-0.4,12.8) A17(0.4,12.8) A18(1.2,12.8) A19(2,12.8) A20(2.8,12.8) A21(3.6,12.8) A22(4.4,12.8) A23(5.2,12.8) A24(6,12.8) A25(6.8,12.8) A26(7.6,12.8) A27(8.4,12.8) A28(9.2,12.8) A29(10,12.8) A30(10.8,12.8) A31(11.6,12.8) A32(12.4,12.8) AA1(-12.4,-3.2) AA2(-11.6,-3.2) AA3(-10.8,-3.2) AA4(-10,-3.2) AA5(-9.2,-3.2) AA6(-8.4,-3.2) AA7(-7.6,-3.2) AA8(-6.8,-3.2) AA9(-6,-3.2) AA10(-5.2,-3.2) AA11(-4.4,-3.2) AA12(-3.6,-3.2) AA13(-2.8,-3.2) AA14(-2,-3.2) AA15(-1.2,-3.2) AA16(-0.4,-3.2) AA17(0.4,-3.2) AA18(1.2,-3.2) AA19(2,-3.2) AA20(2.8,-3.2) AA21(3.6,-3.2) AA22(4.4,-3.2) AA23(5.2,-3.2) AA24(6,-3.2) AA25(6.8,-3.2) AA26(7.6,-3.2) AA27(8.4,-3.2) AA28(9.2,-3.2) AA29(10,-3.2) AA30(10.8,-3.2) AA31(11.6,-3.2) AA32(12.4,-3.2) AA33(13.2,-3.2) AB1(-12.4,-4) AB2(-11.6,-4) AB3(-10.8,-4) AB4(-10,-4) AB5(-9.2,-4) AB6(-8.4,-4) AB7(-7.6,-4) AB8(-6.8,-4) AB9(-6,-4) AB10(-5.2,-4) AB11(-4.4,-4) AB12(-3.6,-4) AB13(-2.8,-4) AB14(-2,-4) AB15(-1.2,-4) AB16(-0.4,-4) AB17(0.4,-4) AB18(1.2,-4) AB19(2,-4) AB20(2.8,-4) AB21(3.6,-4) AB22(4.4,-4) AB23(5.2,-4) AB24(6,-4) AB25(6.8,-4) AB26(7.6,-4) AB27(8.4,-4) AB28(9.2,-4) AB29(10,-4) AB30(10.8,-4) AB31(11.6,-4) AB32(12.4,-4) AB33(13.2,-4) AC1(-12.4,-4.8) AC2(-11.6,-4.8) AC3(-10.8,-4.8) AC4(-10,-4.8) AC5(-9.2,-4.8) AC6(-8.4,-4.8) AC7(-7.6,-4.8) AC8(-6.8,-4.8) AC9(-6,-4.8) AC10(-5.2,-4.8) AC11(-4.4,-4.8) AC12(-3.6,-4.8) AC13(-2.8,-4.8) AC14(-2,-4.8) AC15(-1.2,-4.8) AC16(-0.4,-4.8) AC17(0.4,-4.8) AC18(1.2,-4.8) AC19(2,-4.8) AC20(2.8,-4.8) AC21(3.6,-4.8) AC22(4.4,-4.8) AC23(5.2,-4.8) AC24(6,-4.8) AC25(6.8,-4.8) AC26(7.6,-4.8) AC27(8.4,-4.8) AC28(9.2,-4.8) AC29(10,-4.8) AC30(10.8,-4.8) AC31(11.6,-4.8) AC32(12.4,-4.8) AC33(13.2,-4.8) AD1(-12.4,-5.6) AD2(-11.6,-5.6) AD3(-10.8,-5.6) AD4(-10,-5.6) AD5(-9.2,-5.6) AD6(-8.4,-5.6) AD7(-7.6,-5.6) AD8(-6.8,-5.6) AD9(-6,-5.6) AD10(-5.2,-5.6) AD11(-4.4,-5.6) AD12(-3.6,-5.6) AD13(-2.8,-5.6) AD14(-2,-5.6) AD15(-1.2,-5.6) AD16(-0.4,-5.6) AD17(0.4,-5.6) AD18(1.2,-5.6) AD19(2,-5.6) AD20(2.8,-5.6) AD21(3.6,-5.6) AD22(4.4,-5.6) AD23(5.2,-5.6) AD24(6,-5.6) AD25(6.8,-5.6) AD26(7.6,-5.6) AD27(8.4,-5.6) AD28(9.2,-5.6) AD29(10,-5.6) AD30(10.8,-5.6) AD31(11.6,-5.6) AD32(12.4,-5.6) AD33(13.2,-5.6) AE1(-12.4,-6.4) AE2(-11.6,-6.4) AE3(-10.8,-6.4) AE4(-10,-6.4) AE5(-9.2,-6.4) AE6(-8.4,-6.4) AE7(-7.6,-6.4) AE8(-6.8,-6.4) AE9(-6,-6.4) AE10(-5.2,-6.4) AE11(-4.4,-6.4) AE12(-3.6,-6.4) AE13(-2.8,-6.4) AE14(-2,-6.4) AE15(-1.2,-6.4) AE16(-0.4,-6.4) AE17(0.4,-6.4) AE18(1.2,-6.4) AE19(2,-6.4) AE20(2.8,-6.4) AE21(3.6,-6.4) AE22(4.4,-6.4) AE23(5.2,-6.4) AE24(6,-6.4) AE25(6.8,-6.4) AE26(7.6,-6.4) AE27(8.4,-6.4) AE28(9.2,-6.4) AE29(10,-6.4) AE30(10.8,-6.4) AE31(11.6,-6.4) AE32(12.4,-6.4) AE33(13.2,-6.4) AF1(-12.4,-7.2) AF2(-11.6,-7.2) AF3(-10.8,-7.2) AF4(-10,-7.2) AF5(-9.2,-7.2) AF6(-8.4,-7.2) AF7(-7.6,-7.2) AF8(-6.8,-7.2) AF9(-6,-7.2) AF10(-5.2,-7.2) AF11(-4.4,-7.2) AF12(-3.6,-7.2) AF13(-2.8,-7.2) AF14(-2,-7.2) AF15(-1.2,-7.2) AF16(-0.4,-7.2) AF17(0.4,-7.2) AF18(1.2,-7.2) AF19(2,-7.2) AF20(2.8,-7.2) AF21(3.6,-7.2) AF22(4.4,-7.2) AF23(5.2,-7.2) AF24(6,-7.2) AF25(6.8,-7.2) AF26(7.6,-7.2) AF27(8.4,-7.2) AF28(9.2,-7.2) AF29(10,-7.2) AF30(10.8,-7.2) AF31(11.6,-7.2) AF32(12.4,-7.2) AF33(13.2,-7.2) AG1(-12.4,-8) AG2(-11.6,-8) AG3(-10.8,-8) AG4(-10,-8) AG5(-9.2,-8) AG6(-8.4,-8) AG7(-7.6,-8) AG8(-6.8,-8) AG9(-6,-8) AG10(-5.2,-8) AG11(-4.4,-8) AG12(-3.6,-8) AG13(-2.8,-8) AG14(-2,-8) AG15(-1.2,-8) AG16(-0.4,-8) AG17(0.4,-8) AG18(1.2,-8) AG19(2,-8) AG20(2.8,-8) AG21(3.6,-8) AG22(4.4,-8) AG23(5.2,-8) AG24(6,-8) AG25(6.8,-8) AG26(7.6,-8) AG27(8.4,-8) AG28(9.2,-8) AG29(10,-8) AG30(10.8,-8) AG31(11.6,-8) AG32(12.4,-8) AG33(13.2,-8) AH1(-12.4,-8.8) AH2(-11.6,-8.8) AH3(-10.8,-8.8) AH4(-10,-8.8) AH5(-9.2,-8.8) AH6(-8.4,-8.8) AH7(-7.6,-8.8) AH8(-6.8,-8.8) AH9(-6,-8.8) AH10(-5.2,-8.8) AH11(-4.4,-8.8) AH12(-3.6,-8.8) AH13(-2.8,-8.8) AH14(-2,-8.8) AH15(-1.2,-8.8) AH16(-0.4,-8.8) AH17(0.4,-8.8) AH18(1.2,-8.8) AH19(2,-8.8) AH20(2.8,-8.8) AH21(3.6,-8.8) AH22(4.4,-8.8) AH23(5.2,-8.8) AH24(6,-8.8) AH25(6.8,-8.8) AH26(7.6,-8.8) AH27(8.4,-8.8) AH28(9.2,-8.8) AH29(10,-8.8) AH30(10.8,-8.8) AH31(11.6,-8.8) AH32(12.4,-8.8) AH33(13.2,-8.8) AJ1(-12.4,-9.6) AJ2(-11.6,-9.6) AJ3(-10.8,-9.6) AJ4(-10,-9.6) AJ5(-9.2,-9.6) AJ6(-8.4,-9.6) AJ7(-7.6,-9.6) AJ8(-6.8,-9.6) AJ9(-6,-9.6) AJ10(-5.2,-9.6) AJ11(-4.4,-9.6) AJ12(-3.6,-9.6) AJ13(-2.8,-9.6) AJ14(-2,-9.6) AJ15(-1.2,-9.6) AJ16(-0.4,-9.6) AJ17(0.4,-9.6) AJ18(1.2,-9.6) AJ19(2,-9.6) AJ20(2.8,-9.6) AJ21(3.6,-9.6) AJ22(4.4,-9.6) AJ23(5.2,-9.6) AJ24(6,-9.6) AJ25(6.8,-9.6) AJ26(7.6,-9.6) AJ27(8.4,-9.6) AJ28(9.2,-9.6) AJ29(10,-9.6) AJ30(10.8,-9.6) AJ31(11.6,-9.6) AJ32(12.4,-9.6) AJ33(13.2,-9.6) AK1(-12.4,-10.4) AK2(-11.6,-10.4) AK3(-10.8,-10.4) AK4(-10,-10.4) AK5(-9.2,-10.4) AK6(-8.4,-10.4) AK7(-7.6,-10.4) AK8(-6.8,-10.4) AK9(-6,-10.4) AK10(-5.2,-10.4) AK11(-4.4,-10.4) AK12(-3.6,-10.4) AK13(-2.8,-10.4) AK14(-2,-10.4) AK15(-1.2,-10.4) AK16(-0.4,-10.4) AK17(0.4,-10.4) AK18(1.2,-10.4) AK19(2,-10.4) AK20(2.8,-10.4) AK21(3.6,-10.4) AK22(4.4,-10.4) AK23(5.2,-10.4) AK24(6,-10.4) AK25(6.8,-10.4) AK26(7.6,-10.4) AK27(8.4,-10.4) AK28(9.2,-10.4) AK29(10,-10.4) AK30(10.8,-10.4) AK31(11.6,-10.4) AK32(12.4,-10.4) AK33(13.2,-10.4) AL1(-12.4,-11.2) AL2(-11.6,-11.2) AL3(-10.8,-11.2) AL4(-10,-11.2) AL5(-9.2,-11.2) AL6(-8.4,-11.2) AL7(-7.6,-11.2) AL8(-6.8,-11.2) AL9(-6,-11.2) AL10(-5.2,-11.2) AL11(-4.4,-11.2) AL12(-3.6,-11.2) AL13(-2.8,-11.2) AL14(-2,-11.2) AL15(-1.2,-11.2) AL16(-0.4,-11.2) AL17(0.4,-11.2) AL18(1.2,-11.2) AL19(2,-11.2) AL20(2.8,-11.2) AL21(3.6,-11.2) AL22(4.4,-11.2) AL23(5.2,-11.2) AL24(6,-11.2) AL25(6.8,-11.2) AL26(7.6,-11.2) AL27(8.4,-11.2) AL28(9.2,-11.2) AL29(10,-11.2) AL30(10.8,-11.2) AL31(11.6,-11.2) AL32(12.4,-11.2) AL33(13.2,-11.2) AM1(-12.4,-12) AM2(-11.6,-12) AM3(-10.8,-12) AM4(-10,-12) AM5(-9.2,-12) AM6(-8.4,-12) AM7(-7.6,-12) AM8(-6.8,-12) AM9(-6,-12) AM10(-5.2,-12) AM11(-4.4,-12) AM12(-3.6,-12) AM13(-2.8,-12) AM14(-2,-12) AM15(-1.2,-12) AM16(-0.4,-12) AM17(0.4,-12) AM18(1.2,-12) AM19(2,-12) AM20(2.8,-12) AM21(3.6,-12) AM22(4.4,-12) AM23(5.2,-12) AM24(6,-12) AM25(6.8,-12) AM26(7.6,-12) AM27(8.4,-12) AM28(9.2,-12) AM29(10,-12) AM30(10.8,-12) AM31(11.6,-12) AM32(12.4,-12) AM33(13.2,-12) AN1(-12.4,-12.8) AN2(-11.6,-12.8) AN3(-10.8,-12.8) AN4(-10,-12.8) AN5(-9.2,-12.8) AN6(-8.4,-12.8) AN7(-7.6,-12.8) AN8(-6.8,-12.8) AN9(-6,-12.8) AN10(-5.2,-12.8) AN11(-4.4,-12.8) AN12(-3.6,-12.8) AN13(-2.8,-12.8) AN14(-2,-12.8) AN15(-1.2,-12.8) AN16(-0.4,-12.8) AN17(0.4,-12.8) AN18(1.2,-12.8) AN19(2,-12.8) AN20(2.8,-12.8) AN21(3.6,-12.8) AN22(4.4,-12.8) AN23(5.2,-12.8) AN24(6,-12.8) AN25(6.8,-12.8) AN26(7.6,-12.8) AN27(8.4,-12.8) AN28(9.2,-12.8) AN29(10,-12.8) AN30(10.8,-12.8) AN31(11.6,-12.8) AN32(12.4,-12.8) B1(-12.4,12) B2(-11.6,12) B3(-10.8,12) B4(-10,12) B5(-9.2,12) B6(-8.4,12) B7(-7.6,12) B8(-6.8,12) B9(-6,12) B10(-5.2,12) B11(-4.4,12) B12(-3.6,12) B13(-2.8,12) B14(-2,12) B15(-1.2,12) B16(-0.4,12) B17(0.4,12) B18(1.2,12) B19(2,12) B20(2.8,12) B21(3.6,12) B22(4.4,12) B23(5.2,12) B24(6,12) B25(6.8,12) B26(7.6,12) B27(8.4,12) B28(9.2,12) B29(10,12) B30(10.8,12) B31(11.6,12) B32(12.4,12) B33(13.2,12) C1(-12.4,11.2) C2(-11.6,11.2) C3(-10.8,11.2) C4(-10,11.2) C5(-9.2,11.2) C6(-8.4,11.2) C7(-7.6,11.2) C8(-6.8,11.2) C9(-6,11.2) C10(-5.2,11.2) C11(-4.4,11.2) C12(-3.6,11.2) C13(-2.8,11.2) C14(-2,11.2) C15(-1.2,11.2) C16(-0.4,11.2) C17(0.4,11.2) C18(1.2,11.2) C19(2,11.2) C20(2.8,11.2) C21(3.6,11.2) C22(4.4,11.2) C23(5.2,11.2) C24(6,11.2) C25(6.8,11.2) C26(7.6,11.2) C27(8.4,11.2) C28(9.2,11.2) C29(10,11.2) C30(10.8,11.2) C31(11.6,11.2) C32(12.4,11.2) C33(13.2,11.2) D1(-12.4,10.4) D2(-11.6,10.4) D3(-10.8,10.4) D4(-10,10.4) D5(-9.2,10.4) D6(-8.4,10.4) D7(-7.6,10.4) D8(-6.8,10.4) D9(-6,10.4) D10(-5.2,10.4) D11(-4.4,10.4) D12(-3.6,10.4) D13(-2.8,10.4) D14(-2,10.4) D15(-1.2,10.4) D16(-0.4,10.4) D17(0.4,10.4) D18(1.2,10.4) D19(2,10.4) D20(2.8,10.4) D21(3.6,10.4) D22(4.4,10.4) D23(5.2,10.4) D24(6,10.4) D25(6.8,10.4) D26(7.6,10.4) D27(8.4,10.4) D28(9.2,10.4) D29(10,10.4) D30(10.8,10.4) D31(11.6,10.4) D32(12.4,10.4) D33(13.2,10.4) E1(-12.4,9.6) E2(-11.6,9.6) E3(-10.8,9.6) E4(-10,9.6) E5(-9.2,9.6) E6(-8.4,9.6) E7(-7.6,9.6) E8(-6.8,9.6) E9(-6,9.6) E10(-5.2,9.6) E11(-4.4,9.6) E12(-3.6,9.6) E13(-2.8,9.6) E14(-2,9.6) E15(-1.2,9.6) E16(-0.4,9.6) E17(0.4,9.6) E18(1.2,9.6) E19(2,9.6) E20(2.8,9.6) E21(3.6,9.6) E22(4.4,9.6) E23(5.2,9.6) E24(6,9.6) E25(6.8,9.6) E26(7.6,9.6) E27(8.4,9.6) E28(9.2,9.6) E29(10,9.6) E30(10.8,9.6) E31(11.6,9.6) E32(12.4,9.6) E33(13.2,9.6) F1(-12.4,8.8) F2(-11.6,8.8) F3(-10.8,8.8) F4(-10,8.8) F5(-9.2,8.8) F6(-8.4,8.8) F7(-7.6,8.8) F8(-6.8,8.8) F9(-6,8.8) F10(-5.2,8.8) F11(-4.4,8.8) F12(-3.6,8.8) F13(-2.8,8.8) F14(-2,8.8) F15(-1.2,8.8) F16(-0.4,8.8) F17(0.4,8.8) F18(1.2,8.8) F19(2,8.8) F20(2.8,8.8) F21(3.6,8.8) F22(4.4,8.8) F23(5.2,8.8) F24(6,8.8) F25(6.8,8.8) F26(7.6,8.8) F27(8.4,8.8) F28(9.2,8.8) F29(10,8.8) F30(10.8,8.8) F31(11.6,8.8) F32(12.4,8.8) F33(13.2,8.8) G1(-12.4,8) G2(-11.6,8) G3(-10.8,8) G4(-10,8) G5(-9.2,8) G6(-8.4,8) G7(-7.6,8) G8(-6.8,8) G9(-6,8) G10(-5.2,8) G11(-4.4,8) G12(-3.6,8) G13(-2.8,8) G14(-2,8) G15(-1.2,8) G16(-0.4,8) G17(0.4,8) G18(1.2,8) G19(2,8) G20(2.8,8) G21(3.6,8) G22(4.4,8) G23(5.2,8) G24(6,8) G25(6.8,8) G26(7.6,8) G27(8.4,8) G28(9.2,8) G29(10,8) G30(10.8,8) G31(11.6,8) G32(12.4,8) G33(13.2,8) H1(-12.4,7.2) H2(-11.6,7.2) H3(-10.8,7.2) H4(-10,7.2) H5(-9.2,7.2) H6(-8.4,7.2) H7(-7.6,7.2) H8(-6.8,7.2) H9(-6,7.2) H10(-5.2,7.2) H11(-4.4,7.2) H12(-3.6,7.2) H13(-2.8,7.2) H14(-2,7.2) H15(-1.2,7.2) H16(-0.4,7.2) H17(0.4,7.2) H18(1.2,7.2) H19(2,7.2) H20(2.8,7.2) H21(3.6,7.2) H22(4.4,7.2) H23(5.2,7.2) H24(6,7.2) H25(6.8,7.2) H26(7.6,7.2) H27(8.4,7.2) H28(9.2,7.2) H29(10,7.2) H30(10.8,7.2) H31(11.6,7.2) H32(12.4,7.2) H33(13.2,7.2) J1(-12.4,6.4) J2(-11.6,6.4) J3(-10.8,6.4) J4(-10,6.4) J5(-9.2,6.4) J6(-8.4,6.4) J7(-7.6,6.4) J8(-6.8,6.4) J9(-6,6.4) J10(-5.2,6.4) J11(-4.4,6.4) J12(-3.6,6.4) J13(-2.8,6.4) J14(-2,6.4) J15(-1.2,6.4) J16(-0.4,6.4) J17(0.4,6.4) J18(1.2,6.4) J19(2,6.4) J20(2.8,6.4) J21(3.6,6.4) J22(4.4,6.4) J23(5.2,6.4) J24(6,6.4) J25(6.8,6.4) J26(7.6,6.4) J27(8.4,6.4) J28(9.2,6.4) J29(10,6.4) J30(10.8,6.4) J31(11.6,6.4) J32(12.4,6.4) J33(13.2,6.4) K1(-12.4,5.6) K2(-11.6,5.6) K3(-10.8,5.6) K4(-10,5.6) K5(-9.2,5.6) K6(-8.4,5.6) K7(-7.6,5.6) K8(-6.8,5.6) K9(-6,5.6) K10(-5.2,5.6) K11(-4.4,5.6) K12(-3.6,5.6) K13(-2.8,5.6) K14(-2,5.6) K15(-1.2,5.6) K16(-0.4,5.6) K17(0.4,5.6) K18(1.2,5.6) K19(2,5.6) K20(2.8,5.6) K21(3.6,5.6) K22(4.4,5.6) K23(5.2,5.6) K24(6,5.6) K25(6.8,5.6) K26(7.6,5.6) K27(8.4,5.6) K28(9.2,5.6) K29(10,5.6) K30(10.8,5.6) K31(11.6,5.6) K32(12.4,5.6) K33(13.2,5.6) L1(-12.4,4.8) L2(-11.6,4.8) L3(-10.8,4.8) L4(-10,4.8) L5(-9.2,4.8) L6(-8.4,4.8) L7(-7.6,4.8) L8(-6.8,4.8) L9(-6,4.8) L10(-5.2,4.8) L11(-4.4,4.8) L12(-3.6,4.8) L13(-2.8,4.8) L14(-2,4.8) L15(-1.2,4.8) L16(-0.4,4.8) L17(0.4,4.8) L18(1.2,4.8) L19(2,4.8) L20(2.8,4.8) L21(3.6,4.8) L22(4.4,4.8) L23(5.2,4.8) L24(6,4.8) L25(6.8,4.8) L26(7.6,4.8) L27(8.4,4.8) L28(9.2,4.8) L29(10,4.8) L30(10.8,4.8) L31(11.6,4.8) L32(12.4,4.8) L33(13.2,4.8) M1(-12.4,4) M2(-11.6,4) M3(-10.8,4) M4(-10,4) M5(-9.2,4) M6(-8.4,4) M7(-7.6,4) M8(-6.8,4) M9(-6,4) M10(-5.2,4) M11(-4.4,4) M12(-3.6,4) M13(-2.8,4) M14(-2,4) M15(-1.2,4) M16(-0.4,4) M17(0.4,4) M18(1.2,4) M19(2,4) M20(2.8,4) M21(3.6,4) M22(4.4,4) M23(5.2,4) M24(6,4) M25(6.8,4) M26(7.6,4) M27(8.4,4) M28(9.2,4) M29(10,4) M30(10.8,4) M31(11.6,4) M32(12.4,4) M33(13.2,4) N1(-12.4,3.2) N2(-11.6,3.2) N3(-10.8,3.2) N4(-10,3.2) N5(-9.2,3.2) N6(-8.4,3.2) N7(-7.6,3.2) N8(-6.8,3.2) N9(-6,3.2) N10(-5.2,3.2) N11(-4.4,3.2) N12(-3.6,3.2) N13(-2.8,3.2) N14(-2,3.2) N15(-1.2,3.2) N16(-0.4,3.2) N17(0.4,3.2) N18(1.2,3.2) N19(2,3.2) N20(2.8,3.2) N21(3.6,3.2) N22(4.4,3.2) N23(5.2,3.2) N24(6,3.2) N25(6.8,3.2) N26(7.6,3.2) N27(8.4,3.2) N28(9.2,3.2) N29(10,3.2) N30(10.8,3.2) N31(11.6,3.2) N32(12.4,3.2) N33(13.2,3.2) P1(-12.4,2.4) P2(-11.6,2.4) P3(-10.8,2.4) P4(-10,2.4) P5(-9.2,2.4) P6(-8.4,2.4) P7(-7.6,2.4) P8(-6.8,2.4) P9(-6,2.4) P10(-5.2,2.4) P11(-4.4,2.4) P12(-3.6,2.4) P13(-2.8,2.4) P14(-2,2.4) P15(-1.2,2.4) P16(-0.4,2.4) P17(0.4,2.4) P18(1.2,2.4) P19(2,2.4) P20(2.8,2.4) P21(3.6,2.4) P22(4.4,2.4) P23(5.2,2.4) P24(6,2.4) P25(6.8,2.4) P26(7.6,2.4) P27(8.4,2.4) P28(9.2,2.4) P29(10,2.4) P30(10.8,2.4) P31(11.6,2.4) P32(12.4,2.4) P33(13.2,2.4) R1(-12.4,1.6) R2(-11.6,1.6) R3(-10.8,1.6) R4(-10,1.6) R5(-9.2,1.6) R6(-8.4,1.6) R7(-7.6,1.6) R8(-6.8,1.6) R9(-6,1.6) R10(-5.2,1.6) R11(-4.4,1.6) R12(-3.6,1.6) R17(0.4,1.6) R18(1.2,1.6) R19(2,1.6) R20(2.8,1.6) R21(3.6,1.6) R22(4.4,1.6) R23(5.2,1.6) R24(6,1.6) R25(6.8,1.6) R26(7.6,1.6) R27(8.4,1.6) R28(9.2,1.6) R29(10,1.6) R30(10.8,1.6) R31(11.6,1.6) R32(12.4,1.6) R33(13.2,1.6) T1(-12.4,0.8) T2(-11.6,0.8) T3(-10.8,0.8) T4(-10,0.8) T5(-9.2,0.8) T6(-8.4,0.8) T7(-7.6,0.8) T8(-6.8,0.8) T9(-6,0.8) T10(-5.2,0.8) T11(-4.4,0.8) T12(-3.6,0.8) T17(0.4,0.8) T18(1.2,0.8) T19(2,0.8) T20(2.8,0.8) T21(3.6,0.8) T22(4.4,0.8) T23(5.2,0.8) T24(6,0.8) T25(6.8,0.8) T26(7.6,0.8) T27(8.4,0.8) T28(9.2,0.8) T29(10,0.8) T30(10.8,0.8) T31(11.6,0.8) T32(12.4,0.8) T33(13.2,0.8) U1(-12.4,0) U2(-11.6,0) U3(-10.8,0) U4(-10,0) U5(-9.2,0) U6(-8.4,0) U7(-7.6,0) U8(-6.8,0) U9(-6,0) U10(-5.2,0) U11(-4.4,0) U12(-3.6,0) U17(0.4,0) U18(1.2,0) U19(2,0) U20(2.8,0) U21(3.6,0) U22(4.4,0) U23(5.2,0) U24(6,0) U25(6.8,0) U26(7.6,0) U27(8.4,0) U28(9.2,0) U29(10,0) U30(10.8,0) U31(11.6,0) U32(12.4,0) U33(13.2,0) V1(-12.4,-0.8) V2(-11.6,-0.8) V3(-10.8,-0.8) V4(-10,-0.8) V5(-9.2,-0.8) V6(-8.4,-0.8) V7(-7.6,-0.8) V8(-6.8,-0.8) V9(-6,-0.8) V10(-5.2,-0.8) V11(-4.4,-0.8) V12(-3.6,-0.8) V17(0.4,-0.8) V18(1.2,-0.8) V19(2,-0.8) V20(2.8,-0.8) V21(3.6,-0.8) V22(4.4,-0.8) V23(5.2,-0.8) V24(6,-0.8) V25(6.8,-0.8) V26(7.6,-0.8) V27(8.4,-0.8) V28(9.2,-0.8) V29(10,-0.8) V30(10.8,-0.8) V31(11.6,-0.8) V32(12.4,-0.8) V33(13.2,-0.8) W1(-12.4,-1.6) W2(-11.6,-1.6) W3(-10.8,-1.6) W4(-10,-1.6) W5(-9.2,-1.6) W6(-8.4,-1.6) W7(-7.6,-1.6) W8(-6.8,-1.6) W9(-6,-1.6) W10(-5.2,-1.6) W11(-4.4,-1.6) W12(-3.6,-1.6) W17(0.4,-1.6) W18(1.2,-1.6) W19(2,-1.6) W20(2.8,-1.6) W21(3.6,-1.6) W22(4.4,-1.6) W23(5.2,-1.6) W24(6,-1.6) W25(6.8,-1.6) W26(7.6,-1.6) W27(8.4,-1.6) W28(9.2,-1.6) W29(10,-1.6) W30(10.8,-1.6) W31(11.6,-1.6) W32(12.4,-1.6) W33(13.2,-1.6) Y1(-12.4,-2.4) Y2(-11.6,-2.4) Y3(-10.8,-2.4) Y4(-10,-2.4) Y5(-9.2,-2.4) Y6(-8.4,-2.4) Y7(-7.6,-2.4) Y8(-6.8,-2.4) Y9(-6,-2.4) Y10(-5.2,-2.4) Y11(-4.4,-2.4) Y12(-3.6,-2.4) Y17(0.4,-2.4) Y18(1.2,-2.4) Y19(2,-2.4) Y20(2.8,-2.4) Y21(3.6,-2.4) Y22(4.4,-2.4) Y23(5.2,-2.4) Y24(6,-2.4) Y25(6.8,-2.4) Y26(7.6,-2.4) Y27(8.4,-2.4) Y28(9.2,-2.4) Y29(10,-2.4) Y30(10.8,-2.4) Y31(11.6,-2.4) Y32(12.4,-2.4) Y33(13.2,-2.4)
