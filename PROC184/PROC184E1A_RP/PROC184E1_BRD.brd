# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
R_RGMII1_RD2: length 38.8
  TOP w0.127: R365.1 v2(81.99,85.9)
  L3-SIGNAL1 w0.089: v3(107.92,76.63) 107.58,76.63 106.76,75.82 103.32,75.82 102.6,75.1 101.42,75.1 101.05,75.47 99.29,75.47 89.57,85.19 88.07,85.19 87.46,84.58 85.5,84.58 84.79,83.87 80.84,83.87 80.6,84.11 80.6,84.35 79.59,85.37 79.59,86.08 79.82,86.31 81.58,86.31 v2(81.99,85.9)
  vias: v1(107.92,76.63)
R_RGMII1_RD3: length 38.8
  TOP w0.127: R367.1 v2(83.98,85.9)
  L3-SIGNAL1 w0.089: v2(83.98,85.9) 83.98,86.57 83.7,86.84 81.16,86.84 81.01,87 81.01,87.4 81.19,87.58 86.42,87.58 87.43,88.59 88.71,88.59 89.09,88.21 93.1,88.21 97.59,83.72 97.59,82.78 100.29,80.09 105.35,80.09 107.17,80.09 107.42,80.33 108.04,80.33 108.22,80.51 108.22,80.56 108.59,80.93 109.02,80.93 v3(109.52,81.43)
  vias: v1(109.52,81.43)
R_RGMII1_RX_CTL: length 38.7
  TOP w0.127: R364.1 v2(81,85.9)
  L3-SIGNAL1 w0.089: v3(107.92,77.43) 106.29,77.43 105.74,76.89 103.64,76.89 102.39,75.64 101.63,75.64 101.22,76.05 99.73,76.05 98.91,76.87 98.7,76.87 96.22,79.36 96.22,79.55 96.51,79.85 96.51,80.04 96.37,80.18 96.18,80.18 95.88,79.89 95.69,79.89 95.55,80.02 95.55,80.22 95.84,80.51 95.84,80.71 95.71,80.84 95.51,80.84 95.22,80.55 95.02,80.55 94.89,80.69 94.89,80.88 95.18,81.18 95.18,81.37 95.04,81.51 94.85,81.51 94.55,81.21 94.36,81.21 89.85,85.73 87.85,85.73 87.69,85.57 87.3,85.18 86.68,85.18 86.54,85.32 86.54,85.77 86.4,85.9 86.21,85.9 86.07,85.77 86.07,85.32 85.93,85.18 85.74,85.18 85.6,85.32 85.6,85.77 85.46,85.9 85.27,85.9 85.13,85.77 85.13,85.32 84.99,85.18 81.72,85.18 v2(81,85.9)
  vias: v1(107.92,77.43)
R_RGMII1_RXC: length 37.1
  TOP w0.127: R366.1 v2(82.98,85.9)
  L3-SIGNAL1 w0.089: v2(82.98,85.9) 83.41,85.47 84.18,85.47 85.25,86.54 87.59,86.54 88.12,86 90.03,86 91.93,84.1 93.45,84.1 93.71,83.85 93.71,82.78 94.03,82.46 94.46,82.46 97.11,79.82 97.11,79.62 96.92,79.44 96.92,79.24 97.06,79.1 97.25,79.1 97.44,79.29 97.64,79.29 97.77,79.15 97.77,78.96 97.59,78.77 97.59,78.58 97.72,78.44 97.92,78.44 98.11,78.63 98.3,78.63 98.44,78.49 98.44,78.29 98.25,78.11 98.25,77.91 98.39,77.77 98.58,77.77 98.77,77.96 98.97,77.96 99.1,77.82 99.1,77.63 98.91,77.44 98.91,77.25 99.71,76.45 102.39,76.45 103.09,77.15 105.63,77.15 106.21,77.73 107.55,77.73 108.64,77.73 109.02,78.11 109.02,78.53 v3(109.52,79.03)
  vias: v1(109.52,79.03)
R_RGMII1_TD0: length 47.5
  L3-SIGNAL1 w0.089: v3(109.52,77.43) v5(109.29,77.15)
  L4-GND2 w0.102: v5(109.29,77.15) v7(108.64,77.15)
  L12-SIGNAL5 w0.102: v7(108.64,77.15) 108.22,77.15 108.1,77.27 106.58,77.27 106.45,77.4 106.45,77.8 106.32,77.93 106.14,77.93 106.01,77.8 106.01,77.4 105.88,77.27 105.48,77.27 105.37,77.37 105.37,78 105.24,78.13 105.06,78.13 104.93,78 104.93,77.35 104.8,77.22 104.62,77.22 104.48,77.35 104.48,78 104.35,78.13 104.17,78.13 104.04,78 104.04,77.35 103.91,77.22 103.7,77.22 103.55,77.37 103.55,77.84 103.11,78.28 102.09,78.28 101.81,78 89.34,78 88.78,78.56 81.29,78.56 79.97,79.88 79.97,81.36 79.18,82.14 79.18,86.72 78.09,87.81 78.09,88.54 78.57,89.03 79.59,89.03 80.01,88.6 v2(80.01,88.18)
  vias: v1(109.52,77.43)
R_RGMII1_TD1: length 48.6
  TOP w0.127: R332.1 v2(79.02,88.18)
  L3-SIGNAL1 w0.089: v3(110.32,78.23) v5(110.19,77.9)
  L4-GND2 w0.102: v5(110.19,77.9) v7(109.79,77.93)
  L12-SIGNAL5 w0.102: v7(109.79,77.93) 109.63,78.08 107.07,78.08 106.26,78.89 101.61,78.89 101.33,78.61 100.04,78.61 99.91,78.74 99.91,79.37 99.78,79.5 99.59,79.5 99.46,79.37 99.46,78.74 99.33,78.61 99.15,78.61 99.02,78.74 99.02,79.37 98.89,79.5 98.7,79.5 98.57,79.37 98.57,78.74 98.44,78.61 98.26,78.61 98.13,78.74 98.13,79.37 98,79.5 97.81,79.5 97.68,79.37 97.68,78.74 97.55,78.61 97.37,78.61 97.24,78.74 97.24,79.37 97.11,79.5 96.93,79.5 96.8,79.37 96.8,78.74 96.67,78.61 96.48,78.61 96.35,78.74 96.35,79.37 96.22,79.5 96.04,79.5 95.91,79.37 95.91,78.74 95.78,78.61 95.39,78.61 95.28,78.72 95.28,79.07 95.18,79.17 82.51,79.17 82,79.68 82,80.47 80.42,82.04 80.42,82.56 80.29,82.69 79.97,82.69 79.84,82.82 79.84,83 79.97,83.13 80.29,83.13 80.42,83.26 80.42,86.39 79.02,87.79 v2(79.02,88.18)
  vias: v1(110.32,78.23)
R_RGMII1_TD2: length 48.5
  TOP w0.127: R334.1 v2(82.98,88.18)
  L3-SIGNAL1 w0.089: v5(107.45,80.72) 107.83,80.72 v3(107.92,80.63)
  L4-GND2 w0.102: v5(107.45,80.72) v7(107.15,80.42)
  L12-SIGNAL5 w0.102: v2(82.98,88.18) 82.98,87.96 82.71,87.68 81.98,87.68 81.85,87.54 81.85,87.3 81.95,87.2 84.08,87.2 84.18,87.1 84.18,86.89 84.08,86.79 81.88,86.79 81.78,86.69 81.78,86.41 81.88,86.31 82.28,86.31 82.53,86.06 82.53,84.23 82.28,83.97 82.28,83.69 84.67,81.3 84.67,81.13 84.39,80.85 84.21,80.85 81.76,83.3 81.58,83.3 81.39,83.11 81.39,82.45 83.52,80.32 83.52,80 83.74,79.78 88.58,79.78 89.36,80.57 106.99,80.57 v7(107.15,80.42)
  vias: v1(107.92,80.63)
R_RGMII1_TD3: length 48.6
  TOP w0.127: R335.1 v2(83.98,88.18)
  L3-SIGNAL1 w0.089: v3(108.72,76.63) 108.72,76.48 v5(108.42,76.18)
  L4-GND2 w0.102: v7(107.93,76.86) 108.42,76.38 v5(108.42,76.18)
  L12-SIGNAL5 w0.102: v2(83.98,88.18) 82.83,89.33 78.32,89.33 77.78,88.8 77.78,87.05 78.09,86.74 78.09,85.7 78.88,84.91 78.88,81.86 79.59,81.15 79.59,79.76 81.09,78.26 88.55,78.26 89.12,77.69 102.28,77.69 103.11,76.86 v7(107.93,76.86)
  vias: v1(108.72,76.63)
R_RGMII1_TX_CTL: length 48.7
  TOP w0.127: R333.1 v2(81.99,88.18)
  L3-SIGNAL1 w0.089: v3(110.32,79.03) v5(109.96,79.02)
  L4-GND2 w0.102: v5(109.96,79.02) v7(109.66,78.72)
  L12-SIGNAL5 w0.102: v2(81.99,88.18) 81.47,87.65 81.47,84 80.98,83.52 80.98,82.35 82.68,80.65 82.69,80.65 82.94,80.4 82.94,80.39 83.02,80.32 83.02,79.99 83.52,79.48 88.86,79.48 89.64,80.26 90.01,80.26 90.14,80.13 90.14,79.89 90.25,79.78 90.48,79.78 90.59,79.89 90.59,80.13 90.72,80.26 90.9,80.26 91.03,80.13 91.03,79.89 91.14,79.78 91.37,79.78 91.47,79.89 91.47,80.13 91.6,80.26 91.79,80.26 91.92,80.13 91.92,79.89 92.02,79.78 92.26,79.78 92.36,79.89 92.36,80.13 92.49,80.26 92.68,80.26 92.81,80.13 92.81,79.89 92.91,79.78 93.15,79.78 93.25,79.89 93.25,80.13 93.38,80.26 93.57,80.26 93.7,80.13 93.7,79.89 93.8,79.78 94.04,79.78 94.14,79.89 94.14,80.13 94.27,80.26 94.46,80.26 94.59,80.13 94.59,79.89 94.69,79.78 94.93,79.78 95.03,79.89 95.03,80.13 95.16,80.26 102.93,80.26 103.06,80.13 103.06,79.63 103.19,79.5 103.37,79.5 103.5,79.63 103.5,80.13 103.63,80.26 105.25,80.26 105.38,80.13 105.38,79.63 105.51,79.5 105.7,79.5 105.83,79.63 105.83,80.13 105.96,80.26 106.21,80.26 106.36,80.11 106.36,79.83 107.59,78.6 107.76,78.6 107.89,78.74 107.89,78.88 107.11,79.66 107.11,79.85 107.26,79.99 107.54,79.99 108.82,78.72 v7(109.66,78.72)
  vias: v1(110.32,79.03)
R_RGMII1_TXC: length 47.6
  L3-SIGNAL1 w0.089: v3(109.52,78.23) v5(109.29,77.95)
  L4-GND2 w0.102: v5(109.29,77.95) v7(108.98,77.65)
  L12-SIGNAL5 w0.102: v7(108.98,77.65) 107.07,77.65 106.13,78.59 101.96,78.59 101.69,78.31 94.97,78.31 94.84,78.44 94.84,78.69 94.71,78.82 94.53,78.82 94.4,78.69 94.4,78.44 94.27,78.31 94.08,78.31 93.95,78.44 93.95,78.69 93.82,78.82 93.64,78.82 93.51,78.69 93.51,78.44 93.38,78.31 93.19,78.31 93.06,78.44 93.06,78.69 92.93,78.82 92.75,78.82 92.62,78.69 92.62,78.44 92.49,78.31 92.3,78.31 92.17,78.44 92.17,78.69 92.04,78.82 91.86,78.82 91.73,78.69 91.73,78.44 91.6,78.31 91.41,78.31 91.28,78.44 91.28,78.69 91.15,78.82 90.97,78.82 90.84,78.69 90.84,78.44 90.71,78.31 90.53,78.31 90.4,78.44 90.4,78.69 90.27,78.82 90.08,78.82 89.95,78.69 89.95,78.44 89.82,78.31 89.47,78.31 88.91,78.87 82,78.87 80.96,79.91 80.96,80.92 79.48,82.4 79.48,86.87 78.39,87.96 78.39,88.42 78.68,88.7 79.27,88.7 79.48,88.49 79.48,87.83 79.64,87.68 80.5,87.68 v2(81,88.18)
  vias: v1(109.52,78.23)
R_SERDES0_REFCLK_N: length 113.6
  TOP w0.094: R168.2 134.84,134.5 135.7,134.5 136.07,134.13 136.54,134.13 v2(136.77,133.9)
  L5-SIGNAL2 w0.089: v2(32.63,144.13) 32.63,143.29 32.79,143.13 129.5,143.13 137.61,135.01 137.61,134.39 137.37,134.14 137.02,134.14 v2(136.77,133.9)
R_SERDES0_REFCLK_P: length 113.6
  TOP w0.094: R169.2 134.84,134.78 135.81,134.78 136.18,134.41 136.58,134.41 v2(136.77,134.61)
  L5-SIGNAL2 w0.089: v2(136.77,134.61) 137.02,134.36 137.28,134.36 137.4,134.48 137.4,134.92 129.41,142.91 32.89,142.91 32.63,142.66 v2(32.63,141.15)
R_SERDES1_REFCLK_N: length 128.5
  TOP w0.094: v2(140.27,135.56) 140.05,135.34 139.79,135.34 139.46,135.67 138.46,135.67 137.65,134.86 137.65,133.51 137.21,133.06 136.11,133.06 135.46,132.42 134.91,132.42 R167.2
  L5-SIGNAL2 w0.089: v2(35.77,161.3) 35.77,161.75 35.86,161.84 41.52,161.84 42.72,160.64 119.04,160.64 141.16,138.51 141.16,136.92 141.07,136.83 140.88,136.83 140.78,136.73 140.78,136.55 140.87,136.46 141.07,136.46 141.16,136.37 141.16,135.51 140.96,135.31 140.51,135.31 v2(140.27,135.56)
R_SERDES1_REFCLK_P: length 128.5
  TOP w0.094: v2(140.27,134.85) 140.05,135.06 139.67,135.06 139.34,135.39 138.58,135.39 137.93,134.75 137.93,133.39 137.33,132.78 136.22,132.78 135.58,132.14 134.89,132.14 R177.2
  L5-SIGNAL2 w0.089: v2(140.27,134.85) 140.51,135.09 141.05,135.09 141.38,135.42 141.38,138.6 119.13,160.85 42.81,160.85 41.61,162.06 35.87,162.06 35.77,162.16 v2(35.77,162.44)
R_SOC_SERDES0_REFCLK_N: length 44.5
  L3-SIGNAL1 w0.079: v3(122.32,91.83) v5(122.54,92.11)
  L4-GND2 w0.089: v5(122.54,92.11) v7(122.85,92.42)
  L10-SIGNAL4 w0.089: v7(138.17,124.48) 137.85,124.48 137.75,124.58 137.75,125.59 137.28,126.06 135.19,126.06 132.93,123.8 132.93,110.84 132.42,110.34 132.42,105.74 128,101.32 128,99.83 124.27,96.09 124.27,94.84 122.97,93.55 122.97,92.54 v7(122.85,92.42)
  L13-GND5 w0.089: v9(138.17,124.08) v7(138.17,124.48)
  L14-SIGNAL6 w0.079: v11(138.17,123.76) v9(138.17,124.08)
  vias: v1(122.32,91.83)
R_SOC_SERDES0_REFCLK_P: length 44.5
  L3-SIGNAL1 w0.079: v3(123.12,91.83) v5(123.34,92.11)
  L4-GND2 w0.089: v5(123.34,92.11) v7(123.65,92.42)
  L10-SIGNAL4 w0.089: v7(137.03,124.48) 137.03,124.12 137.15,123.99 137.36,123.99 137.45,124.08 137.45,125.46 137.16,125.76 135.31,125.76 133.23,123.67 133.23,110.72 132.72,110.21 132.72,105.61 128.3,101.19 128.3,99.7 124.56,95.96 124.56,94.72 123.27,93.43 123.27,92.79 v7(123.65,92.42)
  L13-GND5 w0.089: v9(137.03,124.08) v7(137.03,124.48)
  L14-SIGNAL6 w0.079: v11(137.03,123.76) v9(137.03,124.08)
  vias: v1(123.12,91.83)
R_SOC_SERDES1_REFCLK_N: length 40.4
  L3-SIGNAL1 w0.079: v3(130.32,94.23) v5(130.54,94.51)
  L4-GND2 w0.089: v5(130.54,94.51) v7(130.85,94.82)
  L10-SIGNAL4 w0.089: v7(130.85,94.82) 130.6,95.07 130.6,95.85 131.63,96.88 131.63,97.46 133.76,99.6 133.76,100.99 137.49,104.72 137.49,120.12 139.84,122.46 139.84,126.82 137.94,128.71 137.94,129.22 v2(138.3,129.57)
  vias: v1(130.32,94.23)
R_SOC_SERDES1_REFCLK_P: length 40.4
  L3-SIGNAL1 w0.079: v3(129.52,94.23) v5(129.74,94.51)
  L4-GND2 w0.089: v5(129.74,94.51) v7(130.05,94.82)
  L10-SIGNAL4 w0.089: v2(137.28,129.57) 137.64,129.21 137.64,128.59 139.54,126.69 139.54,122.59 137.19,120.24 137.19,104.84 133.46,101.11 133.46,99.72 131.33,97.59 131.33,97 130.3,95.98 130.3,95.07 v7(130.05,94.82)
  vias: v1(129.52,94.23)
R_SOC_SERDES4_REFCLK_N: length 45.3
  L3-SIGNAL1 w0.079: v3(117.52,91.83) v5(117.24,92.06)
  L4-GND2 w0.089: v5(117.24,92.06) v7(116.93,92.37)
  L10-SIGNAL4 w0.089: v7(116.93,92.37) 117.18,92.62 117.18,93.68 120.64,97.14 120.64,101.15 123.03,103.54 123.03,106.41 124.47,107.85 124.47,108.97 124.11,109.32 124.11,125.35 119.42,130.05 119.42,131.15 v2(119.09,131.48)
  vias: v1(117.51,91.83)
R_SOC_SERDES4_REFCLK_P: length 45.2
  L3-SIGNAL1 w0.079: v3(118.32,91.83) v5(118.04,92.06)
  L4-GND2 w0.089: v5(118.04,92.06) v7(117.73,92.37)
  L10-SIGNAL4 w0.089: v2(120,131.48) 119.72,131.2 119.72,130.17 124.41,125.48 124.41,109.45 124.77,109.09 124.77,107.72 123.33,106.29 123.33,103.42 120.94,101.02 120.94,97.01 117.48,93.55 117.48,92.62 v7(117.73,92.37)
  vias: v1(118.31,91.83)
R_SPI5_CLK: length 48.6
  TOP w0.127: U58.16 53.02,84.73 v2(53.27,84.98)
  L5-SIGNAL2 w0.102: v2(19.13,71.13) 19.13,73.8 19.13,73.81 19.13,74.14 19.13,74.15 19.13,74.75 21.08,76.7 21.42,76.7 21.66,76.46 22,76.46 24.15,78.62 26.79,78.62 27.42,79.26 35.61,79.26 36.48,78.39 38.27,78.39 38.94,79.06 45.57,79.06 48.35,81.85 48.35,83.45 50.4,85.5 52.75,85.5 v2(53.27,84.98)
  BOTTOM w0.127: R1059.1 17.37,71.49 17.72,71.84 19.01,71.84 19.13,71.72 v2(19.13,71.13)
R_SPI5_CS0: length 68.5
  TOP w0.127: v2(50.81,106.83) 51.06,107.08 U50.26
  L5-SIGNAL2 w0.102: v2(17.37,67.28) 16.96,67.68 16.96,73.87 22.66,79.57 25.99,79.57 27.46,81.03 35.8,81.03 36.39,81.62 40.54,81.62 40.58,81.57 46.74,81.57 47.18,82.01 47.18,88.44 46.61,89 46.61,102.63 v2(50.81,106.83)
R_SPI5_CS1: length 51.6
  TOP w0.127: U58.24 v2(50.83,88.73)
  L5-SIGNAL2 w0.102: v2(17.37,66.01) 17.6,66.01 18.73,67.13 18.73,74.67 22.94,78.88 26.61,78.88 27.21,79.48 35.71,79.48 36.57,78.62 38.18,78.62 38.85,79.29 45.43,79.29 45.84,79.7 47.86,81.72 47.86,85.76 v2(50.83,88.73)
R_SPI5_D0: length 67
  TOP w0.127: v2(50.81,107.83) 51.06,108.08 U50.28
  L5-SIGNAL2 w0.102: v2(50.81,107.83) 51.21,107.42 51.21,105.9 46.84,101.53 46.84,89.18 47.4,88.61 47.4,81.91 46.06,80.57 41.18,80.57 41.05,80.7 27.5,80.7 26.14,79.34 22.75,79.34 17.37,73.96 v2(17.37,69.82)
R_SPI5_D1: length 63.9
  TOP w0.127: U50.20 51.06,104.08 v2(50.81,103.83)
  L5-SIGNAL2 w0.102: v2(50.81,103.83) 48.34,101.36 48.34,96.52 47.63,95.81 47.63,81.82 46.16,80.34 45.39,79.58 38.42,79.58 37.88,80.12 36.4,80.12 35.99,79.71 27.05,79.71 26.45,79.11 22.85,79.11 17.78,74.04 17.78,68.96 v2(17.37,68.55)
R_USB0_DATA_N: length 2.1
  TOP w0.114: R29.2 138.68,170.8 138.68,170.1 138.68,169.94 138.56,169.82 U12.2
R_USB0_DATA_P: length 2.1
  TOP w0.114: R30.2 138.95,170.8 138.95,170.1 138.95,169.93 139.06,169.82 U12.1
R_USB1_HUB_XI: length 6.9
  TOP w0.127: R89.2 70.72,160.74 70.63,160.65 R94.1 70.63,159.58 70.77,159.44 C77.2 70.77,156.37 71.08,156.06 Y2.2
R_USB1_HUB_XO: length 6.6
  TOP w0.127: Y2.1 69.35,156.06 69.66,156.37 C76.2 69.66,159.49 69.79,159.62 R94.2 69.79,160.63 69.71,160.71 R88.2
RES_LM5140: length 1.5
  TOP w0.127: C217.1 U46.32
RES_LM5141: length 3.2
  TOP w0.127: C318.1 203.23,54.89 204.28,55.94 204.28,56.27 204.45,56.44 U81.24
RES_LM5143: length 1.5
  TOP w0.127: C117.1 U25.32
RESET_REQZ: length 122.8
  TOP w0.127: v2(117.92,73.03) 118.31,73.43 U59.G20 ; v2(23.83,49.07) 24.38,49.61 TP321.1
  L3-SIGNAL1 w0.089: v2(23.83,49.07) 24.38,49.61 34.69,49.61 37.27,52.2 56.68,52.2 60.13,55.66 72.27,55.66 73.13,54.79 103.03,54.79 105.53,52.29 111.52,52.29 115.44,56.21 v5(115.44,56.54)
  L4-GND2 w0.102: v6(115.43,56.87) 115.44,56.87 v5(115.44,56.54)
  L5-SIGNAL2 w0.102: v6(115.43,56.87) 113.27,59.03 113.27,61.21 114.99,62.93 114.99,63.52 116.95,65.48 116.95,70 117.28,70.33 117.28,72.4 v2(117.92,73.03)
  BOTTOM w0.127: U249.4 25.41,46.57 23.83,48.14 v2(23.83,49.07)
RESETSTATZ: length 353.5
  L3-SIGNAL1 w0.089: v2(42.57,42.63) 42.91,42.29 46.6,42.29 48.09,40.8 v2(53.36,40.8) 55.51,38.65 75.53,38.65 76.69,37.49 88.41,37.49 89.09,36.81 v2(90.31,36.81) ; v2(68.66,97.08) 69.72,96.03 74.06,96.03 78.55,91.54 89.29,91.54 90.78,90.05 93.35,90.05 101.26,82.14 101.99,82.14 102.75,81.38 106.07,81.38 106.07,81.37 106.31,81.37 106.84,81.9 108.01,81.9 108.22,82.11 108.22,82.53 108.72,83.03 v3(108.72,83.03)
  L12-SIGNAL5 w0.102: v2(183.55,96.12) 186.77,92.9 186.77,88.67 196.88,78.56 196.88,73.58 198.76,71.7 198.76,66.73 196.88,64.85 196.88,64.19 195.46,62.76 194.8,62.76 193.1,61.07 191.35,61.07 188.91,58.62 188.91,56.77 184.67,52.53 184.67,44.02 179,38.35 179,37.39 174.86,33.25 174.86,25.2 169.14,19.47 144.7,19.47 143.69,18.46 140.35,18.46 140.15,18.66 134.48,18.66 133.75,19.4 116.42,19.4 111.99,23.83 104.55,23.83 101.96,26.42 96.81,26.42 89.67,33.55 89.67,36.18 v2(90.31,36.81)
  L14-SIGNAL6 w0.089: v2(53.36,40.8) 60,40.8 61.7,42.5 61.7,90.47 67.83,96.61 68.19,96.61 v2(68.66,97.08)
  BOTTOM w0.127: v2(42.57,42.63) 42.07,43.13 J56.30
  vias: v1(108.71,83.03)
RGMII1_100MBPS: length 45
  L14-SIGNAL6 w0.089: v2(80.17,31.46) 80.61,31.01 80.61,24.61 79.58,23.58 79.58,19.97 78.3,18.7 67.05,18.7 64.93,16.59 64.93,7.02 68.1,3.85 J39.14
  BOTTOM w0.127: R1291.1 J39.14
RGMII1_1000MBPS: length 34.3
  L14-SIGNAL6 w0.089: J39.13 65.13,8.31 65.13,16.44 67.19,18.5 79.15,18.5 81.03,16.62 v2(82.3,16.62)
  BOTTOM w0.127: U272.3 v2(82.3,16.62) ; R1289.1 J39.13
RGMII1_ACT_LED: length 18.4
  L14-SIGNAL6 w0.089: v2(82.51,19.74) 84.39,17.86 84.39,6.14 J39.12
RGMII1_CLK_OUT: length 1.8
  TOP w0.127: TP229.1 v2(69.35,24.77)
  BOTTOM w0.127: v2(69.35,24.77) 70.21,24.77 U262.18
RGMII1_D0_N: length 9.7
  BOTTOM w0.094: U262.2 75.96,21.52 75.96,20.95 76.07,20.84 76.07,20.15 77.86,18.36 77.86,15.99 78.66,15.19 79.58,15.19 J39.10
RGMII1_D0_P: length 9.7
  BOTTOM w0.094: U262.1 76.46,21.52 76.46,21.52 76.46,20.95 76.35,20.84 76.35,20.27 78.14,18.47 78.14,16.11 78.78,15.47 79.79,15.47 79.92,15.6 79.92,16.12 J39.9
RGMII1_D1_N: length 9.4
  BOTTOM w0.094: J39.8 77.04,15.19 75.99,15.19 75.37,15.81 75.37,17.68 74.57,18.48 74.57,20.84 74.46,20.95 74.46,21.52 U262.5
RGMII1_D1_P: length 9.4
  BOTTOM w0.094: J39.7 77.38,16.12 77.38,15.6 77.25,15.47 76.1,15.47 75.65,15.92 75.65,17.79 74.85,18.6 74.85,20.84 74.96,20.95 74.96,21.52 U262.4
RGMII1_D2_N: length 9.1
  BOTTOM w0.094: J39.6 74.5,15.19 73.58,15.19 72.78,15.99 72.78,17.38 73.07,17.67 73.07,20.84 72.96,20.95 U262.8
RGMII1_D2_P: length 9.1
  BOTTOM w0.094: U262.7 73.46,20.95 73.35,20.84 73.35,17.55 73.06,17.27 73.06,16.11 73.7,15.47 74.71,15.47 74.84,15.6 74.84,16.12 J39.5
RGMII1_D3_N: length 9.5
  BOTTOM w0.094: U262.11 71.46,20.95 71.57,20.84 71.57,19.63 70.24,18.31 70.24,15.99 71.04,15.19 71.96,15.19 J39.4
RGMII1_D3_P: length 9.5
  BOTTOM w0.094: U262.10 71.96,21.52 71.96,20.95 71.85,20.84 71.85,19.52 70.52,18.19 70.52,16.11 71.16,15.47 72.17,15.47 72.3,15.6 72.3,16.12 J39.3
RGMII1_GPIO0_100: length 4.8
  TOP w0.127: v2(78.29,27.01) 78.67,26.63 R629.2 R621.1 U126.1
  BOTTOM w0.127: v2(78.29,27.01) 78.05,26.77 U262.39
RGMII1_GPIO1: length 3.3
  BOTTOM w0.127: R1232.1 R1235.2 79.01,26.42 78.11,26.42 77.96,26.27 U262.40
RGMII1_INT#: length 103.6
  L14-SIGNAL6 w0.089: v2(79.22,24.28) 77.78,24.28 76.21,22.72 65.9,22.72 63.02,25.59 63.02,33.75 58.72,38.06 52.26,38.06 47.78,42.54 47.78,62.39 48.8,63.42 48.8,97.37 v2(47.91,98.27)
  BOTTOM w0.127: U262.44 77.21,24.27 R1245.1
RGMII1_LED0: length 3.2
  TOP w0.127: R654.1 R649.2 78.45,23.13 v2(78.09,22.77)
  BOTTOM w0.127: U262.47 77.21,22.77 v2(78.09,22.77)
RGMII1_LED1_1000: length 8.7
  BOTTOM w0.127: U262.46 77.21,23.27 77.83,23.27 77.94,23.38 78.34,23.38 78.62,23.1 78.62,21.56 R1256.1 R1261.2 79.22,19.17 79.38,19.01 81.16,19.01 81.35,19.2 U272.1
RGMII1_LED2_ACT: length 9.2
  TOP w0.127: U140.1 v2(83.46,21.06)
  BOTTOM w0.127: v2(83.46,21.06) 82.95,21.57 79.36,21.57 79.22,21.71 R1254.1 R1249.2 78.57,23.77 77.21,23.77 U262.45
RGMII1_LED2_ANODE: length 2.2
  BOTTOM w0.127: R1288.1 J39.11
RGMII1_MDIO0_MDC: length 77.6
  TOP w0.127: R349.1 v2(73.93,87.45)
  L14-SIGNAL6 w0.089: v2(73.93,87.45) 70.88,87.45 62,78.57 62,35.48 63.66,33.81 63.66,25.47 65.78,23.35 68.92,23.35 v2(69.34,23.77)
  BOTTOM w0.127: U262.16 70.21,23.77 v2(69.34,23.77)
RGMII1_MDIO0_MDIO: length 87
  TOP w0.127: R344.1 v2(86.29,88.19)
  L14-SIGNAL6 w0.089: v2(86.29,88.19) 86.29,85.14 83.13,81.98 82.24,81.98 80.91,80.65 80.91,79.91 79.76,78.77 77.38,78.77 72.09,73.48 72.09,70.94 70.68,69.53 70.68,53.94 70.46,53.71 70.46,50.41 70.54,50.32 70.54,47.91 70.47,47.84 70.47,42.86 79.62,33.7 79.62,29.51 78.13,28.02 71.76,28.02 68.56,24.82 v2(68.56,24.27)
  BOTTOM w0.127: U262.17 70.21,24.27 v2(68.56,24.27)
RGMII1_RBIAS: length 1.9
  BOTTOM w0.127: U262.12 70.96,20.69 70.51,20.24 R1259.2
RGMII1_RD0: length 69.7
  L14-SIGNAL6 w0.089: v11(79.02,83.5) 78.71,83.19 75.94,83.19 74.55,81.8 71,81.8 69.18,79.98 69.05,79.98 68.55,80.49 68.41,80.49 68.32,80.4 68.32,80.26 68.83,79.76 68.83,79.63 68.14,78.93 68.01,78.93 67.43,79.51 67.3,79.51 67.21,79.42 67.21,79.28 67.78,78.71 67.78,78.58 67.69,78.49 67.56,78.49 66.98,79.06 66.85,79.06 66.76,78.97 66.76,78.83 67.33,78.26 67.33,78.13 66.82,77.61 66.82,71.29 66.12,70.6 66.12,57.4 66.54,56.98 66.54,48.3 67.52,47.32 67.52,42.04 72.88,36.69 72.88,33.8 v11(73.82,32.86)
  BOTTOM w0.127: R1011.2 v11(79.02,83.5)
  vias: v11(73.82,32.86)
RGMII1_RD0_R: length 5.5
  BOTTOM w0.127: R1202.2 74.96,32.2 ; 74.96,32.2 74.41,31.65 74.41,30.54 74.6,30.35 R1218.2 74.96,28.52 U262.33 ; 74.96,32.2 R1200.1
RGMII1_RD1: length 73.2
  L14-SIGNAL6 w0.089: v11(80.01,83.5) 80.01,83.19 79.15,82.32 75.59,82.32 74.74,81.48 71.34,81.48 67.28,77.42 67.28,75.08 67.38,74.99 67.91,74.99 68,74.89 68,74.76 67.91,74.67 67.38,74.67 67.28,74.58 67.28,74.45 67.38,74.35 67.91,74.35 68,74.26 68,74.13 67.91,74.04 67.38,74.04 67.28,73.94 67.28,73.81 67.38,73.72 67.91,73.72 68,73.62 68,73.49 67.91,73.4 67.38,73.4 67.28,73.31 67.28,73.18 67.38,73.08 67.91,73.08 68,72.99 68,72.86 67.91,72.77 67.38,72.77 67.28,72.67 67.28,71.26 67.5,71.04 67.5,70.42 66.41,69.33 66.41,57.49 67.14,56.76 67.14,48.81 68.44,47.51 68.44,42 74.4,36.05 74.4,32.73 v11(76.01,31.12)
  BOTTOM w0.127: v11(80.01,83.5) 79.56,83.95 79.56,84.79 R1010.2
RGMII1_RD1_R: length 2.2
  BOTTOM w0.127: U262.34 75.46,28.52 75.46,29.91 R1213.2
RGMII1_RD2: length 69.6
  L14-SIGNAL6 w0.089: v11(76.01,32.86) 76.88,31.99 78.2,31.99 78.68,32.47 78.68,33.24 75.66,36.27 75.12,36.27 69.04,42.34 69.04,48.34 68.41,48.97 68.41,51.1 68.28,51.23 68.28,65.02 69.19,65.94 69.19,70.15 69.59,70.55 69.59,75.31 71.97,77.68 71.97,78.38 74.38,80.8 75.08,80.8 76,81.71 79.82,81.71 81.6,83.5 v11(81.99,83.5)
  BOTTOM w0.127: v11(81.99,83.5) 81.52,83.97 81.52,84.76 R1008.2
  vias: v11(76.01,32.86)
RGMII1_RD2_R: length 5.9
  BOTTOM w0.127: U262.35 75.96,28.52 75.96,29.23 R1217.2 76.68,30.35 76.54,30.49 76.54,31.67 77.07,32.2 ; R1201.2 77.07,32.2 ; 77.07,32.2 R1199.1
RGMII1_RD3: length 72.4
  L14-SIGNAL6 w0.089: v11(83.93,83.5) 83.06,82.63 81.85,82.63 78.52,79.3 75.81,79.3 74.59,78.08 74.59,77.95 74.91,77.64 74.91,77.51 74.75,77.36 74.63,77.36 74.34,77.65 74.16,77.65 73.76,77.24 73.76,76.61 73.66,76.52 73.53,76.52 73.44,76.61 73.44,77.07 73.35,77.16 73.21,77.16 73.12,77.07 73.12,76.61 73.03,76.52 72.9,76.52 72.8,76.61 72.8,77.07 72.71,77.16 72.32,77.16 70.36,75.2 70.36,70.48 69.77,69.89 69.77,64.49 68.81,63.53 68.81,51.46 69.82,50.44 69.82,49.3 69.58,49.05 69.58,42.86 75.56,36.88 75.99,36.88 79.28,33.58 79.28,32.27 v11(78.14,31.12)
  BOTTOM w0.127: R1006.2 83.47,84.73 83.47,83.95 v11(83.93,83.5)
RGMII1_RD3_R: length 2.8
  BOTTOM w0.127: R1212.2 77.33,29.65 77,29.65 76.46,29.11 76.46,28.84 U262.36
RGMII1_RESET_N: length 17.3
  TOP w0.127: U107.4 v2(73.97,34.99)
  L7-SIGNAL3 w0.109: v2(73.97,34.99) 74.87,34.08 77.57,34.08 78.64,33.01 78.64,28.25 79.15,27.74 v2(79.15,25.14)
  BOTTOM w0.127: v2(79.15,25.14) 78.63,24.62 77.99,24.62 77.84,24.77 77.21,24.77 U262.43
RGMII1_RX_CTL: length 70.2
  L14-SIGNAL6 w0.089: v11(81,83.5) 81,83.3 79.72,82.02 75.7,82.02 74.83,81.15 71.43,81.15 68.45,78.17 68.45,69.41 67.41,68.37 67.41,49.43 68.71,48.13 68.71,42.29 75,36 75.45,36 76.49,34.96 76.49,32.76 76.99,32.25 78,32.25 v11(78.24,32.49)
  BOTTOM w0.127: R1009.2 80.55,84.79 80.55,83.95 v11(81,83.5) ; v11(78.24,32.49) 78.5,32.49 R1205.1
RGMII1_RX_CTL_R: length 5.1
  BOTTOM w0.127: R1205.2 R1221.2 R1224.1 78.43,28.13 78.43,27.86 77.84,27.27 U262.38
RGMII1_RXC: length 72.9
  L14-SIGNAL6 w0.089: v11(82.98,83.5) 82.55,83.06 81.67,83.06 79.41,80.8 77.86,80.8 76.84,79.78 75.52,79.78 73.4,77.67 72.37,77.67 70,75.3 70,70.58 69.48,70.06 69.48,64.71 68.54,63.77 68.54,51.34 68.72,51.17 68.72,49.2 69.31,48.6 69.31,42.45 75.23,36.53 75.9,36.53 79,33.43 79,32.36 78.12,31.48 77.93,31.48 76.96,30.51 74.49,30.51 v11(73.87,31.12)
  BOTTOM w0.127: R1007.2 82.51,84.76 82.51,83.97 v11(82.98,83.5)
RGMII1_RXC_R: length 2.3
  BOTTOM w0.127: U262.32 74.46,28.52 74.46,29.19 74.58,29.31 74.58,29.76 R1214.2
RGMII1_TD0: length 82.2
  L14-SIGNAL6 w0.089: v11(71.97,29.87) 71.03,30.81 71.03,34.43 63.31,42.15 63.31,46.13 63.86,46.68 63.86,48.88 63.31,49.43 63.31,71.61 63.9,72.21 63.9,79.66 69.92,85.67 71.06,85.67 71.18,85.78 71.18,86.38 71.29,86.49 71.45,86.49 71.57,86.38 71.57,85.78 71.68,85.67 71.85,85.67 71.96,85.78 71.96,86.38 72.08,86.49 72.24,86.49 72.36,86.38 72.36,85.78 72.47,85.67 73.62,85.67 73.73,85.78 73.73,86.27 73.85,86.39 74.01,86.39 74.13,86.27 74.13,85.78 74.24,85.67 74.41,85.67 74.52,85.78 74.52,86.27 74.64,86.39 74.8,86.39 74.92,86.27 74.92,85.78 75.03,85.67 75.19,85.67 75.31,85.78 75.31,86.27 75.42,86.39 75.59,86.39 75.7,86.27 75.7,85.78 75.82,85.67 76.52,85.67 76.7,85.48 79.17,85.48 79.19,85.5 79.45,85.76 79.45,86.56 80.01,87.12 v11(80.01,87.52)
  BOTTOM w0.127: v11(71.97,29.87) 72.34,29.49 72.34,28.97 72.46,28.85 U262.28
RGMII1_TD1: length 82.3
  L14-SIGNAL6 w0.089: v11(71.94,29.24) 70.58,30.6 70.58,34.49 63.04,42.04 63.04,42.08 62.92,42.2 62.92,71.61 63.52,72.21 63.52,79.65 70.83,86.96 74.21,86.96 75.36,88.1 77,88.1 77.1,88.01 77.1,87.42 77,87.33 76.55,87.33 76.46,87.24 76.46,87.11 76.55,87.01 77,87.01 77.1,86.92 77.1,86.59 77.19,86.5 77.34,86.5 77.43,86.59 77.43,88.01 77.53,88.1 77.73,88.1 77.82,88.01 77.82,86.83 77.91,86.74 78.05,86.74 78.14,86.83 78.14,88.01 78.23,88.1 78.44,88.1 78.55,87.99 78.55,87.02 78.65,86.92 78.88,86.92 79.02,87.06 v11(79.02,87.52)
  BOTTOM w0.127: v11(71.94,29.24) 71.96,29.23 U262.27
RGMII1_TD2: length 82.4
  L14-SIGNAL6 w0.089: v11(72.7,30.69) 72.18,31.21 72.18,36.5 65.47,43.22 65.47,46.14 64.99,46.62 64.99,46.97 65.64,47.62 65.64,51.31 65.13,51.82 65.13,56.11 64.4,56.84 64.4,71.49 64.99,72.08 64.99,75.14 65.09,75.23 65.66,75.23 65.76,75.33 65.76,75.46 65.66,75.55 65.09,75.55 64.99,75.65 64.99,75.78 65.09,75.87 65.66,75.87 65.76,75.96 65.76,76.09 65.66,76.19 65.09,76.19 64.99,76.28 64.99,76.41 65.09,76.5 65.66,76.5 65.76,76.6 65.76,76.73 65.66,76.82 65.09,76.82 64.99,76.92 64.99,79.39 68.81,83.21 74.93,83.21 75.54,83.82 78.37,83.82 79.23,84.68 81.79,84.68 82.54,85.42 82.54,87.07 v11(82.98,87.52)
  BOTTOM w0.127: v11(72.7,30.69) 71.74,30.69 71.46,30.41 U262.26
RGMII1_TD3: length 82.7
  L14-SIGNAL6 w0.089: v11(83.98,87.52) 83.55,87.1 83.55,85.44 82.56,84.45 82.56,84.24 82.17,83.85 78.88,83.85 78.55,83.52 75.82,83.52 74.48,82.18 68.3,82.18 66.22,80.1 66.22,79.25 66.13,79.15 65.48,79.15 65.39,79.06 65.39,78.93 65.48,78.84 66.13,78.84 66.22,78.74 66.22,78.61 66.13,78.52 65.48,78.52 65.39,78.43 65.39,78.3 65.48,78.2 66.13,78.2 66.22,78.11 66.22,77.98 66.13,77.88 65.48,77.88 65.39,77.79 65.39,77.66 65.48,77.57 66.13,77.57 66.22,77.47 66.22,71.58 65.31,70.67 65.31,56.87 65.59,56.59 65.59,52.04 66,51.64 66,47.61 66.61,47 66.61,43.99 66.45,43.83 66.45,42.66 72.45,36.65 72.45,31.63 v11(72.7,31.38)
  BOTTOM w0.127: U262.25 70.96,30.52 71.81,31.38 v11(72.7,31.38)
RGMII1_TX_CTL: length 82.6
  L14-SIGNAL6 w0.089: v11(77.96,28.51) 76.32,30.15 72.78,30.15 71.84,31.08 71.84,35.52 66.47,40.88 66.47,41.69 64.55,43.62 64.55,46.91 65.08,47.44 65.08,51.05 64.13,51.99 64.13,54.38 64.63,54.87 64.63,56.01 64.13,56.5 64.13,71.64 64.73,72.24 64.73,79.28 64.73,79.5 68.7,83.48 68.7,83.48 68.99,83.76 74.88,83.76 75.21,84.09 78.23,84.09 79.09,84.95 80.66,84.95 81.5,85.79 81.5,86.77 81.75,87.01 81.75,87.27 v11(81.99,87.52)
  BOTTOM w0.127: U262.37 77.78,27.77 77.96,27.95 v11(77.96,28.51)
RGMII1_TXC: length 82.3
  L14-SIGNAL6 w0.089: v11(72.72,29.81) 72.57,29.81 71.57,30.81 71.57,34.66 65.52,40.71 65.52,40.88 65.52,41.2 64.28,42.44 64.28,47.2 64.14,47.34 64.14,50.25 63.69,50.71 63.69,71.62 64.17,72.1 64.17,79.32 65.3,80.45 68.59,83.74 70.21,85.36 71.75,85.36 71.86,85.25 71.86,84.21 71.95,84.12 72.08,84.12 72.17,84.21 72.17,85.21 72.27,85.31 72.4,85.31 72.49,85.21 72.49,84.21 72.58,84.12 72.72,84.12 72.81,84.21 72.81,85.21 72.9,85.3 73.02,85.3 73.13,85.2 73.13,84.21 73.22,84.12 73.35,84.12 73.44,84.21 73.44,85.07 73.59,85.21 79.93,85.21 80.44,85.72 80.44,86.54 81,87.11 v11(81,87.52)
  BOTTOM w0.127: U262.29 72.96,29.22 72.72,29.45 v11(72.72,29.81)
RGMII1_XIN: length 6.5
  BOTTOM w0.127: Y13.2 65.07,23.74 65.24,23.58 C1208.2 68.28,23.58 68.59,23.27 70.21,23.27 U262.15
RGMII1_XOUT: length 6.5
  BOTTOM w0.127: U262.14 70.21,22.77 68.77,22.77 68.46,22.46 C1219.2 65.24,22.46 65.07,22.3 Y13.1
RGMII_REFCLK: length 66.8
  TOP w0.127: R126.2 v3(86.51,153.32)
  L3-SIGNAL1 w0.089: v3(86.51,153.32) 83,153.32 65.36,135.69 56.62,126.94 45.97,126.94 40.86,121.83 40.86,117.2 v2(41.55,116.51)
  BOTTOM w0.127: J54.106 v2(41.55,116.51)
RT_LM5141: length 1.8
  TOP w0.127: R492.1 U81.4
RTC_REF_CLK: length 7.1
  TOP w0.127: R613.2 137.04,29.52 137.58,28.99 R624.2 TP222.1 139.28,28.07 v2(138.67,28.68)
  BOTTOM w0.127: U256.7 v2(138.67,28.68)
RTC_XIN: length 5
  BOTTOM w0.127: Y11.2 137.7,36.58 137.88,36.41 137.88,34.98 137.52,34.63 C1173.1 137.52,33.99 137.4,33.87 U256.1
RTC_XOUT: length 5
  BOTTOM w0.127: Y11.1 138.36,36.58 138.18,36.41 138.18,34.98 138.54,34.63 C1172.1 138.54,33.99 138.67,33.87 U256.2
SEL_SDIO_3V3_1V8N: length 54.6
  TOP w0.127: U281.6 66.92,94.04 67.28,94.4 R316.1 69.49,94.4 69.96,94.87 72.32,94.87 72.99,94.2 v2(72.99,93.17)
  L3-SIGNAL1 w0.089: v3(109.52,79.83) 109.11,79.43 108.58,79.43 108.22,79.06 108.22,78.91 108.04,78.73 105.9,78.73 105.3,78.13 105.29,78.13 105.28,78.12 103.7,78.12 102.66,78.12 102.59,78.04 100.22,78.04 96.21,82.05 96.21,83 93.71,85.5 92.87,85.5 92.27,86.1 91.13,86.1 90.33,86.89 v5(88.53,86.89)
  L4-GND2 w0.102: v5(88.53,86.89) v6(88.2,86.89)
  L5-SIGNAL2 w0.102: v6(88.2,86.89) 88.2,87.35 87.51,88.04 87.51,90.05 84.75,92.81 74.84,92.81 74.04,93.61 73.43,93.61 v2(72.99,93.17)
  vias: v1(109.52,79.83)
SERDES0_REXT: length 43.8
  TOP w0.127: U59.AG7 128.72,89.43 v2(129.12,89.83)
  L12-SIGNAL5 w0.102: v2(162.31,104.12) 160.83,102.64 146.06,102.64 144.03,100.61 144.03,94.31 139.4,89.69 130.64,89.69 130.12,90.21 129.49,90.21 v2(129.12,89.83)
SERDES0_RX2_N: length 37.5
  L3-SIGNAL1 w0.091: v3(122.32,94.23) v5(122.54,94.51)
  L4-GND2 w0.108: v5(122.54,94.51) v7(122.85,94.82)
  L13-GND5 w0.108: v7(122.85,94.82) 123.06,95.03 v9(123.14,95.11)
  L14-SIGNAL6 w0.091: v11(131.6,126.57) 131.92,126.25 arc(131.97,126.16) 131.99,126.06 131.99,124.73 arc(132.05,124.46) 132.21,124.22 132.31,124.11 arc(132.43,123.94) 132.47,123.73 132.47,108.07 arc(132.42,107.8) 132.27,107.57 131.6,106.9 arc(131.4,106.61) 131.34,106.27 131.34,105.04 arc(131.31,104.9) 131.23,104.78 128.33,101.88 arc(128.12,101.57) 128.05,101.2 128.05,99.35 arc(128,99.09) 127.85,98.87 127.35,98.36 arc(127.18,98.25) 126.98,98.21 126.32,98.21 arc(126.1,98.17) 125.91,98.04 124.37,96.49 arc(124.21,96.39) 124.04,96.36 123.85,96.36 arc(123.55,96.23) 123.43,95.94 123.43,95.47 arc(123.41,95.4) 123.37,95.35 v9(123.14,95.11)
  vias: v1(122.32,94.23)
SERDES0_RX2_P: length 37.5
  L3-SIGNAL1 w0.091: v3(123.12,94.23) v5(123.34,94.51)
  L4-GND2 w0.108: v5(123.34,94.51) v7(123.65,94.82)
  L13-GND5 w0.108: v7(123.65,94.82) 123.86,95.03 v9(123.94,95.11)
  L14-SIGNAL6 w0.091: v11(132.61,126.57) 132.29,126.25 arc(132.23,126.16) 132.21,126.06 132.21,124.73 arc(132.25,124.54) 132.36,124.38 132.47,124.27 arc(132.63,124.02) 132.69,123.73 132.69,108.07 arc(132.62,107.72) 132.42,107.42 131.75,106.74 arc(131.61,106.53) 131.55,106.27 131.55,105.04 arc(131.51,104.82) 131.39,104.63 128.49,101.73 arc(128.33,101.49) 128.27,101.2 128.27,99.35 arc(128.2,99) 128.01,98.71 127.5,98.21 arc(127.26,98.05) 126.98,97.99 126.32,97.99 arc(126.19,97.97) 126.07,97.89 124.52,96.34 arc(124.3,96.19) 124.04,96.14 123.85,96.14 arc(123.7,96.08) 123.65,95.94 123.65,95.47 arc(123.66,95.4) 123.7,95.35 v9(123.94,95.11)
  vias: v1(123.12,94.23)
SERDES0_RX3_N: length 42.8
  L3-SIGNAL1 w0.091: v3(120.72,92.63) v5(120.94,92.91)
  L4-GND2 w0.108: v5(120.94,92.91) v7(121.25,93.21)
  L13-GND5 w0.108: v9(121.54,93.51) 121.46,93.43 v7(121.25,93.21)
  L14-SIGNAL6 w0.091: v11(129.91,129.58) 130.15,129.34 arc(130.27,129.17) 130.31,128.96 130.31,124.97 arc(130.38,124.59) 130.6,124.27 131.04,123.83 arc(131.26,123.5) 131.33,123.12 131.33,107.93 arc(131.28,107.65) 131.12,107.41 130.48,106.77 arc(130.22,106.39) 130.13,105.94 130.13,105.05 arc(130.09,104.82) 129.95,104.62 127.66,102.33 arc(127.41,101.95) 127.32,101.51 127.32,99.69 arc(127.29,99.52) 127.19,99.37 126.87,99.05 arc(126.74,98.96) 126.59,98.93 126.06,98.93 arc(125.79,98.88) 125.55,98.72 124.39,97.56 arc(124.2,97.43) 123.97,97.38 123.23,97.38 arc(122.92,97.32) 122.66,97.15 122.02,96.51 arc(121.88,96.29) 121.83,96.04 121.83,94.06 121.83,93.87 arc(121.81,93.8) 121.77,93.74 v9(121.54,93.51)
  vias: v1(120.72,92.63)
SERDES0_RX3_P: length 42.8
  L3-SIGNAL1 w0.091: v3(121.52,92.63) v5(121.74,92.91)
  L4-GND2 w0.108: v5(121.74,92.91) v7(122.05,93.22)
  L13-GND5 w0.108: v9(122.34,93.51) 122.26,93.43 v7(122.05,93.22)
  L14-SIGNAL6 w0.091: v11(130.93,129.58) 130.69,129.35 arc(130.57,129.17) 130.53,128.96 130.53,124.97 arc(130.58,124.68) 130.75,124.43 131.19,123.99 arc(131.46,123.59) 131.55,123.12 131.55,107.93 arc(131.48,107.56) 131.27,107.26 130.63,106.62 arc(130.42,106.31) 130.35,105.94 130.35,105.05 arc(130.29,104.74) 130.11,104.47 127.82,102.18 arc(127.61,101.87) 127.54,101.51 127.54,99.69 arc(127.49,99.43) 127.34,99.21 127.03,98.9 arc(126.83,98.76) 126.59,98.72 126.06,98.72 arc(125.87,98.68) 125.71,98.57 124.54,97.4 arc(124.28,97.23) 123.97,97.17 123.23,97.17 arc(123,97.12) 122.81,96.99 122.18,96.36 arc(122.08,96.21) 122.04,96.04 122.04,94.06 122.04,93.87 arc(122.06,93.8) 122.1,93.74 v9(122.34,93.51)
  vias: v1(121.52,92.63)
SERDES0_TX2_N: length 42.4
  L3-SIGNAL1 w0.091: v3(121.52,93.43) v5(121.74,93.71)
  L4-GND2 w0.108: v5(121.74,93.71) v7(122.05,94.02)
  L12-SIGNAL5 w0.108: v8(128,125.08) arc(128.03,124.93) 128.11,124.81 130.32,122.6 arc(130.52,122.3) 130.59,121.95 130.59,121.44 arc(130.51,121.06) 130.3,120.74 129.44,119.88 arc(129.22,119.56) 129.15,119.18 129.15,118.64 arc(129.03,118.08) 128.72,117.61 127.36,116.25 arc(126.99,115.69) 126.86,115.04 126.86,104.1 arc(126.75,103.57) 126.45,103.13 125.03,101.7 arc(124.73,101.26) 124.63,100.73 124.63,95.21 arc(124.55,94.83) 124.34,94.51 123.72,93.89 123.72,93.89 123.66,93.83 arc(123.55,93.75) 123.41,93.73 123.2,93.73 arc(123.08,93.71) 122.97,93.65 arc(122.9,93.61) 122.83,93.6 122.82,93.6 arc(122.65,93.63) 122.51,93.72 122.34,93.89 arc(122.21,93.99) v7(122.05,94.02)
  L13-GND5 w0.108: v9(127.77,125.31) v8(128,125.08)
  L14-SIGNAL6 w0.091: v11(127.55,129.58) 127.24,129.27 arc(127.18,129.18) 127.15,129.07 127.15,125.92 arc(127.18,125.8) 127.25,125.69 127.54,125.4 arc(127.64,125.33) v9(127.77,125.31)
  vias: v1(121.52,93.43)
SERDES0_TX2_P: length 42.4
  L3-SIGNAL1 w0.091: v3(122.32,93.43) v5(122.54,93.71)
  L4-GND2 w0.108: v5(122.54,93.71) v7(122.85,94.02)
  L12-SIGNAL5 w0.108: v8(127.59,124.67) 127.79,124.67 arc(127.91,124.64) 128.01,124.58 130.15,122.43 arc(130.3,122.21) 130.35,121.95 130.35,121.44 arc(130.3,121.15) 130.13,120.91 129.27,120.04 arc(129,119.65) 128.91,119.18 128.91,118.64 arc(128.82,118.17) 128.55,117.78 127.19,116.42 arc(126.77,115.78) 126.62,115.04 126.62,104.1 arc(126.53,103.66) 126.29,103.29 124.86,101.87 arc(124.51,101.35) 124.39,100.73 124.39,95.21 arc(124.33,94.92) 124.17,94.67 123.59,94.09 arc(123.55,94.06) 123.51,94.06 123.33,94.06 arc(123.26,94.09) 123.22,94.16 123.22,94.23 arc(123.19,94.32) 123.1,94.36 122.97,94.36 arc(122.88,94.33) 122.85,94.24 v7(122.85,94.02)
  L13-GND5 w0.108: v9(127.36,124.9) v8(127.59,124.67)
  L14-SIGNAL6 w0.091: v11(126.54,129.58) 126.54,129.7 arc(126.74,129.9) 126.93,129.7 126.93,125.92 arc(126.98,125.71) 127.09,125.54 127.36,125.27 arc(127.44,125.09) 127.36,124.9 v9(127.36,124.9)
  vias: v1(122.32,93.43)
SERDES0_TX3_N: length 47.8
  L3-SIGNAL1 w0.091: v3(119.92,91.83) v5(119.64,92.06)
  L4-GND2 w0.108: v5(119.64,92.06) v7(119.33,92.37)
  L12-SIGNAL5 w0.108: v7(119.33,92.37) 120.2,93.24 120.71,93.75 arc(120.87,93.99) 120.93,94.27 120.93,94.78 arc(121.04,95.33) 121.35,95.79 122.61,97.05 arc(122.95,97.56) 123.07,98.17 123.07,101.91 arc(123.19,102.52) 123.54,103.04 124,103.49 arc(124.17,103.76) 124.23,104.06 124.23,114.53 arc(124.42,115.46) 124.95,116.26 127.55,118.86 arc(127.8,119.23) 127.89,119.68 127.89,119.96 arc(127.96,120.29) 128.14,120.56 128.57,120.99 arc(128.69,121.17) 128.73,121.38 128.73,122.31 arc(128.66,122.48) 128.5,122.54 128.23,122.54 arc(128.08,122.48) 128.01,122.33 128.01,122.06 arc(128.06,121.84) v8(128.19,121.65)
  L13-GND5 w0.108: v8(128.19,121.65) v9(128.19,121.98)
  L14-SIGNAL6 w0.091: v11(129.26,132.58) 129.26,132.58 arc(129.06,132.78) 128.87,132.58 128.87,124.92 arc(128.82,124.69) 128.68,124.49 128.16,123.96 arc(128.05,123.79) 128.01,123.59 128.01,122.27 arc(128.03,122.16) 128.09,122.07 v9(128.19,121.98)
  vias: v1(119.91,91.83)
SERDES0_TX3_P: length 47.8
  L3-SIGNAL1 w0.091: v3(120.72,91.83) v5(120.44,92.06)
  L4-GND2 w0.108: v5(120.44,92.06) v7(120.13,92.37)
  L12-SIGNAL5 w0.108: v7(120.13,92.37) 120.13,92.66 arc(120.16,92.82) 120.26,92.96 120.37,93.07 120.88,93.58 arc(121.09,93.9) 121.17,94.27 121.17,94.78 arc(121.26,95.24) 121.51,95.62 122.77,96.88 arc(123.17,97.47) 123.31,98.17 123.31,101.91 arc(123.41,102.43) 123.71,102.87 124.16,103.33 arc(124.39,103.67) 124.47,104.06 124.47,114.53 arc(124.64,115.37) 125.11,116.09 127.72,118.69 arc(128.02,119.14) 128.13,119.68 128.13,119.96 arc(128.17,120.2) 128.31,120.4 128.74,120.83 arc(128.9,121.08) 128.96,121.38 128.96,122.31 arc(128.83,122.64) 128.5,122.78 128.23,122.78 arc(127.91,122.65) 127.78,122.33 127.78,122.06 arc(127.74,121.84) v8(127.61,121.65)
  L13-GND5 w0.108: v8(127.61,121.65) v9(127.61,121.98)
  L14-SIGNAL6 w0.091: v9(127.61,121.98) 127.71,122.07 arc(127.77,122.16) 127.79,122.27 127.79,123.59 arc(127.84,123.88) 128,124.11 128.53,124.64 arc(128.62,124.77) 128.65,124.92 128.65,131.98 arc(128.61,132.16) 128.51,132.32 v11(128.25,132.58)
  vias: v1(120.71,91.83)
SERDES1_REXT: length 50.8
  L3-SIGNAL1 w0.089: v3(127.12,90.23) v5(127.34,90.51)
  L4-GND2 w0.102: v5(127.34,90.51) 127.59,90.26 v7(127.59,89.87)
  L12-SIGNAL5 w0.102: v2(165.57,104.12) 165.04,104.65 165.04,105.25 164.54,105.75 161.62,105.75 160.52,104.65 148.85,104.65 147.07,102.87 145.93,102.87 143.77,100.71 143.77,94.46 139.28,89.97 130.79,89.97 130.28,90.48 129.44,90.48 129.28,90.32 128.05,90.32 v7(127.59,89.87)
  vias: v1(127.12,90.23)
SERDES4_REXT: length 25.3
  L3-SIGNAL1 w0.089: v3(115.92,90.23) v5(115.64,90.46)
  L4-GND2 w0.102: v5(115.64,90.46) v7(115.33,90.77)
  L10-SIGNAL4 w0.109: v2(120.2,112.42) 119.62,111.84 119.62,104.83 118.65,103.86 118.65,99.9 115.76,97 115.76,94.13 114.95,93.33 114.95,92.98 115.17,92.77 115.17,90.93 v7(115.33,90.77)
  BOTTOM w0.127: R938.1 120.2,112.42 v2(120.2,112.42)
  vias: v1(115.91,90.23)
SOC_EDP_IRQ: length 3.8
  BOTTOM w0.127: U227.3 27.32,81.96 27.44,82.07 R1017.2 27.44,83.42 27.38,83.48 U220.4
SOC_EMU0: length 164.3
  TOP w0.127: U47.9 28.87,101.58 29.04,101.4 29.03,101.39 TP78.1 29.03,99.1 v2(28.55,98.62) ; SW4.1 v2(18.05,112.43)
  L3-SIGNAL1 w0.089: v3(119.12,72.63) v5(118.89,72.36)
  L4-GND2 w0.102: v5(118.89,72.36) v6(118.58,72.05)
  L5-SIGNAL2 w0.102: v6(118.58,72.05) 118.19,71.66 118.19,64.67 115.99,62.47 115.99,56.64 114.81,55.45 113.09,55.45 111.94,56.6 105.81,56.6 102.36,53.15 98.47,53.15 87.61,64.01 87.61,66.22 86.16,67.67 81.06,67.67 80.3,68.43 74.1,68.43 72.17,70.36 63.08,70.36 60.99,72.45 59.81,72.45 59.47,72.11 59.47,71.92 59.18,71.64 58.48,71.64 v2(58.07,72.04)
  L7-SIGNAL3 w0.109: v2(28.55,98.62) 27.65,98.62 26.32,99.95 26.32,101.68 21.89,106.11 21.89,107.14 18.05,110.97 v2(18.05,112.43)
  L14-SIGNAL6 w0.089: v2(28.55,98.62) 30.8,100.87 33.21,100.87 34.53,99.55 44.95,99.55 45.59,98.9 48.09,98.9 57.39,89.61 57.39,72.73 v2(58.07,72.04)
  vias: v1(119.12,72.63)
SOC_EMU1: length 158.6
  TOP w0.127: SW4.2 v2(18.05,113.7) ; U47.12 29.53,103.53 v2(30.18,102.88)
  L3-SIGNAL1 w0.089: v3(120.72,71.83) v5(120.49,71.55)
  L4-GND2 w0.102: v5(120.49,71.55) v6(120.18,71.25)
  L5-SIGNAL2 w0.102: v6(120.18,71.25) 120.48,70.95 120.48,59.71 115.3,54.53 112.07,54.53 111.49,55.12 104.66,55.12 102.46,52.92 97.16,52.92 83.47,66.61 75.54,66.61 72.65,69.49 63.46,69.49 60.91,72.04 v2(59.97,72.04)
  L7-SIGNAL3 w0.109: v2(18.05,113.7) 18.47,113.28 18.47,111.25 22.57,107.16 22.57,105.9 23.64,104.83 28.24,104.83 v2(30.18,102.88)
  L14-SIGNAL6 w0.089: v2(59.97,72.04) 58.05,73.97 58.05,89.52 50.89,96.68 48.26,99.31 47.55,100.02 36.93,100.02 34.07,102.88 v2(30.18,102.88)
  vias: v1(120.72,71.83)
SOC_EXTINTN: length 124
  TOP w0.127: U92.4 66.07,48.35 v2(66.07,46.79)
  L3-SIGNAL1 w0.089: v3(111.12,83.83) v5(110.84,84.06)
  L4-GND2 w0.102: v5(110.84,84.06) v7(111.23,84.05)
  L12-SIGNAL5 w0.102: v2(66.07,46.79) 66.73,47.45 66.73,58.14 64.25,60.62 64.25,91.17 67.5,94.41 70.72,94.41 71.18,94.87 79.15,94.87 81.06,96.77 82.74,96.77 83.68,97.71 92.31,97.71 95.16,94.87 95.16,90.35 93.48,88.67 89.47,88.67 86.95,86.16 86.95,84.62 88.39,83.19 92.18,83.19 93.05,84.05 v7(111.23,84.05)
  vias: v1(111.11,83.83)
SOC_GPIO0_21_MUX: length 66.9
  TOP w0.127: v2(56.27,96.91) 56.24,96.88 R294.1
  L3-SIGNAL1 w0.089: v3(107.92,79.03) 107.51,79.03 107.43,78.96 105.82,78.96 105.21,78.35 105.2,78.35 105.19,78.33 103.79,78.33 102.57,78.33 102.5,78.26 100.31,78.26 96.43,82.14 96.43,83.08 93.79,85.73 92.95,85.73 92.36,86.31 91.22,86.31 90.05,87.48 v5(88.48,87.48)
  L4-GND2 w0.102: v5(88.48,87.48) 88.48,87.79 v6(88.47,87.79)
  L5-SIGNAL2 w0.102: v6(88.47,87.79) 88.47,90.52 87.42,91.57 86.32,91.57 84.85,93.04 74.96,93.04 74.15,93.85 60.26,93.85 58.99,92.58 56.43,92.58 55.86,93.15 55.86,96.5 v2(56.27,96.91)
  vias: v1(107.92,79.03)
SOC_I2C1_SCL_R: length 6
  TOP w0.127: R95.2 9.86,159.77 12.45,162.36 U19.4
SOC_I2C1_SDA_R: length 4.2
  TOP w0.127: R91.2 9.88,160.81 10.5,161.43 U19.7
SOC_I2C3_SDA_MUX: length 70.8
  TOP w0.127: R259.1 55.81,105.96 55.93,106.08 R258.1 v2(56.27,106.03)
  L3-SIGNAL1 w0.089: v5(91.35,86.67) 92.41,86.67 93.1,85.98 93.84,85.98 96.64,83.17 96.64,82.24 100.41,78.47 102.41,78.47 102.48,78.55 102.98,78.55 105.1,78.55 105.11,78.56 105.12,78.56 105.73,79.17 107.38,79.17 107.55,79.34 108.22,79.34 v3(108.72,79.83)
  L4-GND2 w0.102: v5(91.35,86.67) v6(91.02,86.67)
  L5-SIGNAL2 w0.102: v2(56.27,106.03) 59.09,103.21 59.09,98.8 60.27,97.61 61.04,97.61 62.16,96.5 73.68,96.5 74.91,95.28 86.05,95.28 90,91.33 90,87.68 v6(91.02,86.67)
  vias: v1(108.72,79.83)
SOC_MCAN5_RX_MUX: length 69.3
  TOP w0.127: v2(56.27,95.13) R302.1 55.84,95.18 55.72,95.07 R304.1
  L3-SIGNAL1 w0.089: v5(91.4,81.76) 91.78,81.38 91.78,80.67 92.71,79.74 93.4,79.74 98.47,74.67 98.47,73.96 99.35,73.08 102.05,73.08 103.86,74.89 107.06,74.89 107.51,75.34 109.02,75.34 v3(109.52,75.83)
  L4-GND2 w0.102: v5(91.4,81.76) v6(91.4,82.09)
  L5-SIGNAL2 w0.102: v2(56.27,95.13) 59.13,95.13 59.84,94.42 67.91,94.42 68.18,94.69 73.69,94.69 75.12,93.27 84.97,93.27 86.34,91.9 87.42,91.9 88.81,90.51 88.81,86.49 91.4,83.9 v6(91.4,82.09)
  vias: v1(109.52,75.83)
SOC_MCAN5_TX_MUX: length 64.2
  TOP w0.127: v2(56.27,93.31) R311.1 55.85,93.37 55.74,93.25 R315.1
  L3-SIGNAL1 w0.089: v2(56.27,93.31) 58.02,91.57 64.17,91.57 66.72,89.01 70.61,89.01 76.2,83.42 78.64,83.42 79.43,82.63 83.32,82.63 85.35,80.59 85.35,79.53 86.14,78.74 87.49,78.74 v5(87.87,79.12) ; v3(110.32,75.03) v5(110.09,74.75)
  L4-GND2 w0.102: v5(87.87,79.12) 88.1,78.89 v6(88.11,78.9) ; v5(110.09,74.75) v6(109.78,74.45)
  L5-SIGNAL2 w0.102: v6(109.78,74.45) 102.45,74.45 100.47,76.43 92.64,76.43 90.84,78.23 89.01,78.23 88.71,78.54 88.47,78.54 v6(88.11,78.9)
  vias: v1(110.32,75.03)
SOC_MCU_OSPI0_CLK: length 2.2
  TOP w0.127: U241.2 127.79,48.52 128.4,49.12 R1119.2
SOC_MCU_OSPI0_CLK_R: length 35.4
  TOP w0.127: R1119.1 130.34,50.38 v3(130.93,50.97)
  L3-SIGNAL1 w0.089: v3(127.92,71.03) v5(128.19,70.8) ; v5(130.6,50.97) v3(130.93,50.97)
  L4-GND2 w0.102: v5(130.6,50.97) v6(130.6,50.64) ; v5(128.19,70.8) v6(128.48,71.12)
  L5-SIGNAL2 w0.102: v6(130.6,50.64) 131.17,51.22 131.17,51.96 131.07,52.07 130.49,52.07 130.39,52.17 130.39,52.32 130.49,52.42 131.07,52.42 131.17,52.53 131.17,52.67 131.07,52.78 130.49,52.78 130.39,52.88 130.39,53.03 130.49,53.13 131.07,53.13 131.17,53.24 131.17,53.38 131.07,53.49 130.49,53.49 130.39,53.59 130.39,53.74 130.49,53.84 131.07,53.84 131.17,53.95 131.17,54.1 131.07,54.2 130.49,54.2 130.39,54.3 130.39,54.45 130.49,54.56 131.07,54.56 131.17,54.66 131.17,54.81 131.07,54.91 130.49,54.91 130.39,55.02 130.39,55.16 130.49,55.27 131.07,55.27 131.17,55.37 131.17,55.52 131.07,55.62 130.49,55.62 130.39,55.73 130.39,55.87 130.49,55.98 131.07,55.98 131.17,56.08 131.17,56.23 131.07,56.33 130.49,56.33 130.39,56.44 130.39,56.58 130.49,56.69 131.07,56.69 131.17,56.79 131.17,57.76 128.61,60.33 128.61,70.65 128.48,70.78 v6(128.48,71.12)
  vias: v1(127.92,71.03)
SOC_MCU_OSPI0_CS0#: length 30.6
  TOP w0.127: v3(127.49,50.35) 127.49,49.46 126.79,48.76 U241.4
  L3-SIGNAL1 w0.089: v3(124.72,72.63) v5(124.99,72.4) ; v5(123.29,51.27) 126.58,51.27 v3(127.49,50.35)
  L4-GND2 w0.102: v5(123.29,51.27) v6(123.06,51.5) ; v5(124.99,72.4) v6(125.3,72.1)
  L5-SIGNAL2 w0.102: v6(123.06,51.5) 123.06,65.98 124.7,67.62 124.7,69.47 124.42,69.75 124.42,71.43 125.09,72.1 v6(125.3,72.1)
  vias: v1(124.72,72.63)
SOC_MCU_OSPI0_D0: length 37.3
  TOP w0.127: U241.6 125.79,49.1 125.63,49.26 v6(125.63,49.73)
  L3-SIGNAL1 w0.089: v3(126.32,71.83) v5(126.59,71.6) ; v5(125.63,49.4) v6(125.63,49.73)
  L4-GND2 w0.102: v5(125.63,49.4) v6(125.63,49.73) ; v5(126.59,71.6) v6(126.9,71.3)
  L5-SIGNAL2 w0.102: v6(125.63,49.73) 124.44,49.73 124.21,49.96 124.21,53.83 124.11,53.93 123.88,53.93 123.77,53.83 123.77,50.57 123.67,50.47 123.53,50.47 123.43,50.57 123.43,65.81 125,67.39 125,69.62 124.72,69.9 124.72,71.3 125.15,71.73 126.47,71.73 v6(126.9,71.3)
  vias: v1(126.32,71.83)
SOC_MCU_OSPI0_D1: length 38
  TOP w0.127: U241.5 126.29,49.02 126.6,49.32 R1117.1 126.83,49.73 127.06,49.96 127.06,50.67 127.44,51.05 v3(129.09,51.05)
  L3-SIGNAL1 w0.089: v3(127.12,72.63) v5(127.34,72.37) ; v5(129.42,51.05) v3(129.09,51.05)
  L4-GND2 w0.102: v5(127.34,72.37) v6(127.7,72.1) ; v5(129.42,51.05) v6(129.42,50.72)
  L5-SIGNAL2 w0.102: v6(129.42,50.72) 129.42,54.53 129.32,54.63 128.59,54.63 128.48,54.74 128.48,54.89 128.59,54.99 129.34,54.99 129.45,55.09 129.45,55.24 129.34,55.34 128.59,55.34 128.48,55.45 128.48,55.6 128.59,55.7 129.34,55.7 129.45,55.8 129.45,55.95 129.34,56.06 128.59,56.06 128.48,56.16 128.48,56.31 128.59,56.41 129.34,56.41 129.45,56.52 129.45,56.66 129.34,56.77 128.59,56.77 128.48,56.87 128.48,57.02 128.59,57.12 129.34,57.12 129.45,57.23 129.45,57.37 129.34,57.48 128.59,57.48 128.48,57.58 128.48,57.73 128.59,57.83 129.34,57.83 129.45,57.94 129.45,58.29 127.8,59.94 127.8,70 128.13,70.33 128.13,71.67 v6(127.7,72.1)
  vias: v1(127.12,72.63)
SOC_MCU_OSPI0_D2: length 37.4
  TOP w0.127: v3(123.63,50.35) 123.63,49.58 122.79,48.74 U241.12
  L3-SIGNAL1 w0.089: v5(123.63,50.02) v3(123.63,50.35) ; v3(127.12,71.83) v5(127.39,71.6)
  L4-GND2 w0.102: v5(123.63,50.02) v6(123.63,49.69) ; v5(127.39,71.6) v6(127.7,71.3)
  L5-SIGNAL2 w0.102: v6(123.63,49.69) 123.63,49.4 122.94,48.72 122.94,48.21 123.3,47.85 125.56,47.85 126.81,49.1 126.81,51.05 125.54,52.32 125.54,64.88 125.43,64.98 125.2,64.98 125.08,64.85 125.08,64.14 124.98,64.04 124.72,64.04 124.62,64.14 124.62,65.61 126.17,67.16 126.17,69.77 v6(127.7,71.3)
  vias: v1(127.12,71.83)
SOC_MCU_OSPI0_D3: length 37.4
  TOP w0.127: U241.7 v6(125.29,48.51)
  L3-SIGNAL1 w0.089: v3(125.52,71.03) v5(125.79,70.8) ; v5(125.29,48.84) v6(125.29,48.51)
  L4-GND2 w0.102: v5(125.29,48.84) v6(125.29,48.51) ; v5(125.79,70.8) v6(126.1,70.5)
  L5-SIGNAL2 w0.102: v6(126.1,70.5) 125.83,70.76 125.26,70.76 125.03,70.54 125.03,70.05 125.41,69.67 125.41,67.36 123.73,65.68 123.73,54.46 123.88,54.31 124.04,54.31 124.19,54.46 124.19,58.57 124.32,58.7 124.61,58.7 124.71,58.59 124.71,51.22 125,50.93 125.85,50.93 126.12,50.66 126.12,49.34 v6(125.29,48.51)
  vias: v1(125.52,71.03)
SOC_MCU_OSPI0_D4: length 38.7
  TOP w0.127: v3(122.6,49.73) 122.6,49.23 122.29,48.93 U241.13
  L3-SIGNAL1 w0.089: v3(127.12,71.03) v5(127.39,70.8) ; v5(122.6,49.4) v3(122.6,49.73)
  L4-GND2 w0.102: v5(122.6,49.4) v6(122.31,49.12) ; v5(127.39,70.8) v6(127.71,70.52)
  L5-SIGNAL2 w0.102: v6(122.31,49.12) 122.31,47.65 122.77,47.19 126.63,47.19 127.72,48.29 127.72,51.17 127.82,51.27 128.3,51.27 128.41,51.38 128.41,51.53 128.3,51.63 127.82,51.63 127.72,51.73 127.72,51.88 127.82,51.99 128.3,51.99 128.41,52.09 128.41,52.24 128.3,52.34 127.82,52.34 127.72,52.45 127.72,52.59 127.82,52.7 128.3,52.7 128.41,52.8 128.41,52.95 128.3,53.05 127.82,53.05 127.72,53.16 127.72,53.3 127.82,53.41 128.3,53.41 128.41,53.51 128.41,53.66 128.3,53.76 127.82,53.76 126.96,54.63 126.96,69.76 v6(127.71,70.52)
  vias: v1(127.12,71.03)
SOC_MCU_OSPI0_D5: length 37.4
  TOP w0.127: U241.14 121.79,49.06 121.63,49.22 R1114.1 v6(121.64,49.73)
  L3-SIGNAL1 w0.089: v5(121.64,49.4) v6(121.64,49.73) ; v3(127.12,70.23) v5(126.89,69.95)
  L4-GND2 w0.102: v5(126.89,69.95) v6(126.58,69.65) ; v5(121.64,49.4) v6(121.64,49.73)
  L5-SIGNAL2 w0.102: v6(126.58,69.65) 126.58,67.01 125.87,66.29 125.87,65.58 125.97,65.48 126.24,65.48 126.35,65.37 126.35,65.23 126.24,65.12 125.97,65.12 125.87,65.02 125.87,64.87 125.97,64.77 126.24,64.77 126.35,64.66 126.35,64.52 126.24,64.41 125.97,64.41 125.87,64.31 125.87,64.16 125.97,64.06 126.24,64.06 126.35,63.95 126.35,63.8 126.24,63.7 125.97,63.7 125.87,63.6 125.87,63.45 125.97,63.34 126.24,63.34 126.35,63.24 126.35,63.09 126.24,62.99 125.97,62.99 125.87,62.88 125.87,62.74 125.97,62.63 126.24,62.63 126.35,62.53 126.35,62.38 126.24,62.28 125.97,62.28 125.87,62.17 125.87,52.48 127.14,51.21 127.14,48.92 127.13,48.91 127.12,48.91 125.71,47.5 123.07,47.5 122.64,47.93 122.64,48.95 123.03,49.34 123.03,49.5 122.64,49.89 121.79,49.89 v6(121.64,49.73)
  vias: v1(127.12,70.23)
SOC_MCU_OSPI0_D6: length 38.5
  TOP w0.127: U241.15 121.29,48.9 v6(120.81,49.38)
  L3-SIGNAL1 w0.089: v3(128.72,70.23) v5(128.49,69.95) ; v5(120.81,49.71) v6(120.81,49.38)
  L4-GND2 w0.102: v5(128.49,69.95) v6(128.18,69.65) ; v5(120.81,49.71) v6(120.81,49.38)
  L5-SIGNAL2 w0.102: v6(120.81,49.38) 120.33,48.9 120.33,48.16 122.61,45.87 127.69,45.87 128.56,46.74 128.56,48.34 129.85,49.63 129.85,58.47 128.18,60.14 v6(128.18,69.65)
  vias: v1(128.72,70.23)
SOC_MCU_OSPI0_D7: length 37.3
  TOP w0.127: v6(120.79,48.51) U241.16
  L3-SIGNAL1 w0.089: v5(120.46,48.51) v6(120.79,48.51) ; v3(127.92,70.23) v5(127.69,69.95)
  L4-GND2 w0.102: v5(127.69,69.95) v6(127.38,69.65) ; v5(120.46,48.51) v6(120.79,48.51)
  L5-SIGNAL2 w0.102: v6(120.79,48.51) 122.42,46.89 126.78,46.89 128.14,48.25 128.14,48.7 129.04,49.61 129.04,53.52 128.1,54.46 128.1,55.41 128,55.51 127.6,55.51 127.49,55.61 127.49,55.76 127.6,55.87 128,55.87 128.1,55.97 128.1,56.12 128,56.22 127.6,56.22 127.49,56.33 127.49,56.47 127.6,56.58 128,56.58 128.1,56.68 128.1,56.83 128,56.93 127.6,56.93 127.49,57.04 127.49,57.18 127.6,57.29 128,57.29 128.1,57.39 128.1,57.54 128,57.64 127.6,57.64 127.49,57.75 127.49,57.89 127.6,58 128,58 128.1,58.1 128.1,59.11 127.38,59.82 v6(127.38,69.65)
  vias: v1(127.92,70.23)
