# Allegro board PROC184E1_BRD.brd (continued)
## Nets (continued)
Pads without a net: F2 1 2; J4 A8 B8; J10 1 3 26 28; J14 A19 A32 B30; J17 A19 A32 B30; J23 10 11 14 22 24 26 28 30 32 34 36 42 44 46 48 50 52 54 56 59 60; J24 1; J39 2; J40 2; J48 4; J49 4; J50 4 5 6 8 9 10 11 12 13 14 15 17 18 19 20 21 22 23 24 29 35; J54 7 8 9 10 11 12 13 14 15 16 17 18 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 39 40 41 42 43 44 45 46 47 48 49 50 56 58 60 61 62 83 84 85 86 87 88 89 90 91 92 93 94 98 100 104 109 111 112 113 114 115 116 117; J55 6 25 26 27 28 29 31 33 35 37 39; J56 8 10 11 12 13 14 16 17 18 20 24 26 27 31 32 33 35 37 38 41 42 43 45 47 49 50 51 52 53 54 55 57 59 61 63 65 66 69 70 71 72 73 74 75 76 84 86 92 94 96 98 99 101 106 107 108 109 110 111 112; Q4 3 4 5; U1 9; U2 5; U3 2; U6 7; U8 7 8 17 18 19; U11 5 6 7 11 12 14 15 23 24 26 27 28 35 36 38 39 40 43 44 46 47 51 52 54 55 58 59 61 62; U13 2 4 5; U16 3 7 8; U18 5 7 8 9 10; U19 9 10 11 12 13 14; U22 5 6 9 10 13 14 21 22; U23 4 14 15; U26 A1 A2 A10 A11 A12 A13 A14 B1 B3 B10 B13 B14 C10 C13 C14 D4 E6 E7 E9 E10 E13 E14 F10 G5 G13 G14 J10 J13 J14 K9 K10 L13 L14 M6 M7 M8 M9 M10 M11 N1 N6 N7 N10 N13 N14 P1 P2 P3 P6 P7 P10 P13 P14; U31 A3 B2 C2; U32 3; U34 4; U40 5 6; U50 35 46; U52 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U54 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U56 3; U57 A3 B2 C2; U59 AK23 AK24 AL19 AL20 AM21 AM22 AN17 AN18; U60 3; U61 A3 B2 C2; U64 A3 B2 C2; U65 3; U67 2 5; U71 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U79 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U83 2 3; U84 A3 B2 C2; U93 A3 B2 C2; U94 3; U98 8 9 12 13; U99 A3 B2 C2; U100 3; U103 1; U105 A3 B2 C2; U106 3; U108 5 6 7 9 10 11 12 13 14; U109 6 11 12 14; U113 3; U114 A3 B2 C2; U115 3; U116 A3 B2 C2; U117 3; U118 3; U119 A3 B2 C2; U120 3; U121 A3 B2 C2; U123 4; U125 3; U128 3; U129 A3 B2 C2; U132 4 5 7 8 9 10; U134 1; U143 5 10; U144 19 21 22 23 24 26 27 28 29 30 32 33 34 43 44 45 46 48 52 53 54 55 57 58 59; U145 21 22 23 24 28 29 30 32 33 34 40 41 43 44 45 46 54 55 57 58 59; U147 7; U148 11; U154 9 10 17 18 19 20 21 22 23 24 25 26 27 28 38 39 40 55 56 57 58 61 62 63 64; U155 1; U156 2; U157 2; U167 1; U168 1; U169 3; U170 2 5 6 11 12 13 14 15 18 19 20 21 22 23 24 25 27 29 30 31 32 33 34 41 44 45 46 53 54 56 57 65 67 83 84 85 86 91 92 102 103 104 105 106 107 108 109 110 111 112 116 117 118 119 120 121 123 124 125 126 127 128; U171 A3 B2 C2; U172 3; U173 2 10 11 17 18 19 20 21; U174 3; U177 13 14; U184 3; U185 A3 B2 C2; U187 4 5 6 7 8 9 10 11 12 13; U188 A3 B2 C2; U189 3; U191 1 2 3; U192 A3 B2 C2; U193 3; U194 A3 B2 C2; U195 3; U197 1 2; U198 A3 B2 C2; U199 3; U200 2; U201 2 5; U202 1 2; U203 3; U204 A3 B2 C2; U206 13 14; U207 A3 B2 C2; U208 3; U209 3; U210 A3 B2 C2; U211 A3 B2 C2; U212 3; U213 1; U214 A3 B2 C2; U215 3; U218 3; U219 A3 B2 C2; U220 1; U221 3; U222 A3 B2 C2; U223 A3 B2 C2; U224 3; U225 A3 B2 C2; U226 3; U227 5 6 7 9 10 11 12 13 14; U228 10 11; U229 3; U230 A3 B2 C2; U231 A3 B2 C2; U232 3; U235 A3 B2 C2; U236 3; U238 A3 B2 C2; U239 3; U243 17 18 19 20 21 22 23 24; U245 A2 A3 A5 B1 B5 C5; U246 A2 A3 B1 B5 C5; U250 1; U257 1; U261 20 21 22 23; U262 20 21 22 23; U266 3; U270 5 10; U274 6; U275 7; U278 1

## Via types
v1: diameter 0.35, hole 0.127, TOP to L2-GND1, 1279 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 5407 vias
v3: diameter 0.325, hole 0.127, L2-GND1 to L3-SIGNAL1, 1044 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 870 vias
v5: diameter 0.325, hole 0.127, L3-SIGNAL1 to L4-GND2, 593 vias
v6: diameter 0.325, hole 0.127, L4-GND2 to L5-SIGNAL2, 342 vias
v7: diameter 0.457, hole 0.203, L4-GND2 to L13-GND5, 306 vias
v8: diameter 0.325, hole 0.127, L12-SIGNAL5 to L13-GND5, 618 vias
v9: diameter 0.325, hole 0.127, L13-GND5 to L14-SIGNAL6, 999 vias
v10: diameter 0.325, hole 0.127, L14-SIGNAL6 to L15-GND6, 1053 vias
v11: diameter 0.325, hole 0.127, L15-GND6 to BOTTOM, 410 vias
v12: diameter 0.914, hole 0.508, TOP to BOTTOM, 276 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 2457.9
  TOP w0.102: U52.N2 177.72,95.59 arc(177.7,95.56) 177.69,95.52 177.69,95.04 arc(177.7,95) 177.72,94.97 v2(177.94,94.75) 178.16,94.97 arc(178.18,95) 178.19,95.04 178.19,95.52 arc(178.18,95.56) 178.16,95.59 U52.N2
  TOP w0.127: v1(196.38,78.52) 196.29,78.6 arc(196.27,78.64) 196.26,78.69 U61.B3
  TOP w0.152: v2(173.94,96.81) 173.64,97.12 arc(173.59,97.15) 173.53,97.16 173.36,97.16 arc(173.3,97.15) 173.25,97.12 U52.C4 ; U52.A6 171.74,97.81 arc(171.68,97.82) 171.63,97.85 v2(171.43,98.05)
  TOP w0.203: U64.C3 195.86,74.85 195.7,74.68 arc(195.65,74.62) 195.64,74.54 195.64,74.18 arc(195.65,74.1) 195.7,74.03 195.83,73.9 arc(195.9,73.85) 195.98,73.84 196.42,73.84 arc(196.5,73.85) 196.56,73.9 196.98,74.31 arc(197.04,74.35) 197.12,74.37 U65.1 ; v2(145.84,153.77) U26.H14 U26.H13 U26.H12 ; U106.2 193.71,38.05 arc(193.63,38.03) 193.56,37.99 193.35,37.77 arc(193.28,37.73) 193.21,37.71 192.94,37.71 arc(192.86,37.73) 192.8,37.77 192.74,37.83 arc(192.69,37.9) 192.68,37.98 U105.B3 ; v1(195.64,82.51) 195.8,82.67 arc(195.84,82.73) 195.86,82.81 U57.C3 ; U119.C3 174.04,33.98 arc(173.96,33.96) 173.9,33.92 173.65,33.67 arc(173.61,33.61) 173.59,33.53 173.59,32.88 arc(173.61,32.81) 173.65,32.74 173.84,32.55 arc(173.88,32.49) 173.9,32.41 U118.1 ; U26.E3 U26.E2 U26.E1 v2(144.34,146.36) ; U26.E3 v1(143.84,147.82) U26.C3 U26.C2 U26.C1 143.34,146.26 arc(143.32,146.18) 143.28,146.12 v2(143.11,145.95) ; U26.E3 v1(144.84,147.82) U26.G3 ; U26.B11 v2(143.09,152.07) ; v2(143.09,152.07) U26.C12 ; v2(143.09,152.07) U26.B12 ; v2(143.09,152.07) U26.C11 ; U121.C1 179.76,33.98 arc(179.84,33.99) 179.91,34.04 180.01,34.14 arc(180.05,34.2) 180.07,34.28 180.07,34.53 arc(180.05,34.61) 180.01,34.67 179.77,34.91 arc(179.73,34.98) 179.71,35.05 U120.7 ; U128.7 155.34,29.4 arc(155.35,29.32) 155.4,29.25 155.63,29.02 arc(155.68,28.95) 155.69,28.87 155.69,28.62 arc(155.68,28.55) 155.63,28.48 155.53,28.38 arc(155.46,28.33) 155.39,28.32 U129.C1 ; U99.C1 192.28,43.29 arc(192.26,43.37) 192.22,43.43 192.12,43.53 arc(192.05,43.58) 191.97,43.59 191.72,43.59 arc(191.65,43.58) 191.58,43.53 191.34,43.3 arc(191.28,43.25) 191.2,43.24 U100.7 ; v2(147.84,153.77) U26.M14 U26.M13 U26.M12 ; U26.H12 U26.J12 U26.K12 ; U26.H12 U26.G12 U26.F12 ; U61.C3 195.86,78.39 arc(195.87,78.31) 195.92,78.25 196.01,78.16 arc(196.08,78.11) 196.15,78.1 196.95,78.1 arc(197.03,78.11) 197.1,78.16 197.28,78.34 arc(197.35,78.39) 197.42,78.4 U60.1 ; U26.K12 U26.L12 U26.M12 ; U26.K12 U26.K13 U26.K14 v2(146.84,153.77) ; U26.P11 v2(148.59,152.07) ; v2(148.59,152.07) U26.N12 U26.M12 ; v2(148.59,152.07) U26.N11 ; v2(148.59,152.07) U26.P12 ; U94.7 191.2,47.43 arc(191.28,47.45) 191.34,47.49 191.58,47.73 arc(191.65,47.77) 191.72,47.78 191.97,47.78 arc(192.05,47.77) 192.12,47.73 192.22,47.62 arc(192.26,47.56) 192.28,47.48 U93.C1 ; v2(143.84,153.77) U26.D14 U26.D13 U26.D12 U26.E12 U26.F12 ; v1(196.48,82.51) 196.32,82.67 arc(196.27,82.73) 196.26,82.81 U57.B3 ; U26.F12 U26.F13 U26.F14 v2(144.84,153.77) ; U26.G10 v2(145.59,151.57) U26.H10 ; U116.C1 171.13,33.98 arc(171.21,33.99) 171.27,34.04 171.37,34.14 arc(171.42,34.2) 171.43,34.28 171.43,34.53 arc(171.42,34.61) 171.37,34.67 171.14,34.91 arc(171.09,34.98) 171.08,35.05 U117.7 ; U32.7 202.67,134.8 arc(202.66,134.88) 202.61,134.94 202.29,135.26 arc(202.25,135.33) 202.23,135.41 202.23,135.68 arc(202.25,135.75) 202.29,135.82 202.35,135.88 arc(202.42,135.92) 202.5,135.94 U31.C1 ; 190.28,52.19 191.13,52.19 arc(191.21,52.2) 191.28,52.25 191.51,52.48 arc(191.58,52.53) 191.65,52.54 191.97,52.54 arc(192.05,52.53) 192.12,52.48 192.22,52.38 arc(192.26,52.32) 192.28,52.24 U84.C1 ; U26.G3 v1(145.84,147.82) U26.J3 ; U26.G3 U26.G2 U26.G1 ; v2(179.04,98.06) 178.85,97.87 arc(178.78,97.82) 178.71,97.81 U52.P6 U52.N5 ; U65.7 194.78,75.87 arc(194.86,75.89) 194.93,75.93 195.16,76.17 arc(195.23,76.21) 195.3,76.22 195.56,76.22 arc(195.63,76.21) 195.7,76.17 195.8,76.06 arc(195.84,76) 195.86,75.92 U64.C1 ; U26.J3 U26.J2 U26.J1 ; U26.J3 v1(146.84,147.82) U26.L3 U26.L2 U26.L1 ; U115.1 193.84,33.36 arc(193.77,33.34) 193.7,33.3 193.51,33.11 arc(193.45,33.07) 193.37,33.05 192.73,33.05 arc(192.65,33.07) 192.58,33.11 192.34,33.36 arc(192.29,33.42) 192.28,33.5 U114.C3 ; v2(174.56,98.67) 174.26,98.37 arc(174.19,98.32) 174.12,98.31 U52.E7 ; U52.G5 174.94,97.27 174.54,96.87 arc(174.48,96.82) 174.4,96.81 v2(173.94,96.81) ; U129.C3 153.98,28.32 arc(153.9,28.3) 153.84,28.26 153.59,28.01 arc(153.55,27.95) 153.53,27.87 153.53,27.23 arc(153.55,27.15) 153.59,27.08 153.78,26.9 arc(153.82,26.83) 153.84,26.75 U128.1 ; v2(179.04,97.06) 178.85,96.87 arc(178.78,96.82) 178.71,96.81 U52.P4 ; U52.J5 v2(175.94,98.06) ; U60.7 194.71,79.9 arc(194.79,79.92) 194.86,79.96 195.09,80.2 arc(195.16,80.24) 195.24,80.26 195.56,80.26 arc(195.63,80.24) 195.7,80.2 195.8,80.1 arc(195.84,80.03) 195.86,79.95 U61.C1 ; U114.C1 192.28,34.91 arc(192.26,34.99) 192.22,35.05 192.12,35.15 arc(192.05,35.2) 191.97,35.21 191.64,35.21 arc(191.56,35.2) 191.49,35.15 191.26,34.92 arc(191.19,34.87) 191.11,34.86 U115.7 ; U26.N3 v1(148.34,147.32) ; U118.7 175.4,35.12 arc(175.41,35.04) 175.46,34.97 175.69,34.74 arc(175.74,34.67) 175.75,34.6 175.75,34.28 arc(175.74,34.2) 175.69,34.14 175.59,34.04 arc(175.52,33.99) 175.45,33.98 U119.C1 ; U105.C1 192.28,39.1 arc(192.26,39.18) 192.22,39.24 192.12,39.34 arc(192.05,39.39) 191.97,39.4 191.65,39.4 arc(191.58,39.39) 191.51,39.34 191.28,39.11 arc(191.21,39.06) 191.13,39.05 U106.7 ; U56.7 194.77,83.93 arc(194.85,83.95) 194.91,83.99 195.17,84.25 arc(195.24,84.3) 195.32,84.31 195.57,84.31 arc(195.65,84.3) 195.71,84.25 195.74,84.23 arc(195.79,84.16) 195.8,84.08 195.8,83.95 195.86,83.89 U57.C1 ; v1(148.34,148.32) U26.M4 v1(147.84,148.82) U26.N5 v1(148.84,148.82) U26.P4 ; U94.2 193.71,46.43 arc(193.63,46.41) 193.56,46.37 193.34,46.14 arc(193.27,46.1) 193.19,46.08 192.95,46.08 arc(192.87,46.1) 192.8,46.14 192.74,46.21 arc(192.69,46.27) 192.68,46.35 U93.B3
  TOP w0.254: v2(50.81,98.33) 50.98,98.15 arc(51.06,98.1) 51.16,98.08 U50.8 ; v2(173.61,30.37) 173.82,30.58 arc(173.88,30.67) 173.9,30.76 U118.1 ; D13.2 v2(114.84,172.97) ; 155.99,83.57 155.98,83.57 v2(155.72,83.57) ; U104.2 83.37,39.07 arc(83.46,39.09) 83.55,39.15 83.6,39.2 arc(83.69,39.26) 83.78,39.28 v2(84.11,39.28) ; C428.2 191.34,27.58 v2(191.17,27.76) ; v2(74.08,40.56) 74.08,39.94 73.97,39.83 U107.3 ; C472.2 v2(101.11,19.11) ; v2(63.28,110.15) 64.17,110.15 R248.2 ; v2(192.23,80.26) 192.51,79.98 arc(192.6,79.92) 192.69,79.9 U60.7 ; U145.5 v2(214.64,14.67) ; U145.25 v2(223.4,19.43) ; J10.12 v2(73.08,182.16) ; v2(212.58,95.71) 212,96.29 arc(211.91,96.34) 211.82,96.36 v1(211.38,96.36) ; U12.5 v2(136.51,168.74) ; J8.19 98.59,178.42 v2(98.76,178.59) ; D25.2 v2(117.78,171.3) ; v2(199.02,21.87) 198.72,21.58 arc(198.64,21.53) 198.55,21.51 C458.2 ; v2(180.37,4.52) 180.37,4.52 R728.2 180.37,1.88 v2(180.3,1.8) ; R47.1 v2(59,168.54) R51.1 ; C436.2 76.1,26.09 arc(76.01,26.07) 75.92,26.02 v2(75.54,25.63) ; v2(188.65,43.59) 188.93,43.31 arc(189.01,43.26) 189.11,43.24 U100.7 ; U144.1 v1(186.54,14.69) ; D7.2 v2(150.5,179.78) ; v2(155.53,70.32) 156.03,70.32 156.04,70.33 ; U47.8 v2(23.57,101.58) ; U154.50 v2(50.01,15.71) ; v2(27.97,39.05) 27.72,38.8 arc(27.67,38.72) 27.65,38.62 U109.8 ; D22.2 94.45,171.88 v2(94.45,171.31) ; U94.2 v2(195.88,46.43) ; 181.62,50.88 181.95,51.21 arc(182.04,51.27) 182.13,51.29 v2(182.47,51.29) ; 181.62,50.88 181.95,50.55 arc(182.04,50.49) 182.13,50.47 v2(182.47,50.47) ; 181.62,50.88 U87.11 ; R190.2 v2(181.36,124.88) ; v2(135.47,21.61) v2(135.47,22.53) ; U25.35 206.19,150.1 arc(206.09,150.08) 206.01,150.03 205.9,149.92 arc(205.82,149.86) 205.72,149.84 v2(205.24,149.84) ; v3(148.73,67.39) 148.58,67.39 v1(147.93,66.74) 147.78,66.74 v1(147.13,67.39) ; U145.13 v2(218.64,14.67) ; U62.5 v1(81.73,81.95) ; v2(208.34,54.97) 208.09,55.22 arc(208.03,55.31) 208.01,55.4 U81.6 ; Q2.2 v2(231.18,31.94) ; U143.7 200.49,22.09 arc(200.48,21.99) 200.42,21.91 v2(200.18,21.67) 199.92,21.93 arc(199.86,22.02) 199.84,22.11 U143.8 ; U81.A4 v2(204.6,59.85) ; v2(86.25,173.16) 86.12,173.04 arc(86.06,172.95) 86.04,172.86 D17.2 ; v1(148.73,69.34) 148.58,69.34 v1(147.93,69.99) 147.78,69.99 v1(147.13,69.34) ; v2(187.87,56.77) 188.13,57.02 arc(188.21,57.08) 188.31,57.1 U80.14 ; v2(187.87,56.77) 188.12,56.52 arc(188.2,56.47) 188.3,56.45 U80.15 ; v2(187.87,56.77) C317.1 ; v2(106.68,151.77) 106.82,151.91 R130.2 ; v2(155.69,31.94) 155.41,31.67 arc(155.36,31.58) 155.34,31.49 U128.7 ; R40.1 v2(154.16,171.09) ; U46.17 219.81,105.54 v2(219.89,105.62) ; U8.A1 174.04,172.82 173.99,172.77 v2(173.41,172.77) ; U48.12 73.48,104.03 arc(73.46,104.12) 73.41,104.21 v2(73.16,104.45) ; U138.6 v2(114.86,24.65) ; v2(191.47,84.87) 192.06,84.29 C250.2 192.51,84.01 arc(192.6,83.95) 192.69,83.93 U56.7 ; v2(136.86,21.37) 137.26,21.37 arc(137.36,21.35) 137.44,21.3 137.53,21.21 arc(137.62,21.15) 137.71,21.13 U142.1 ; U36.13 v2(182.64,122.68) ; C362.2 C363.2 C364.2 81.97,43.61 arc(81.95,43.51) 81.9,43.43 TP192.1 ; v2(179.01,178.26) U8.A3 ; C426.1 v2(167.27,27.36) ; C49.2 v2(56.78,166.23) v2(55.86,166.23) ; C43.2 v2(11.04,168.53) ; U139.1 169.29,22.99 arc(169.19,23.01) 169.11,23.06 169.01,23.15 arc(168.93,23.21) 168.83,23.23 v2(168.44,23.23) ; C425.2 99.93,26.89 v2(99.97,26.85) ; J48.5 v2(186.83,5.43) ; C437.2 101.76,26.09 arc(101.66,26.07) 101.58,26.02 v2(101.19,25.63) ; U122.2 157.95,31.96 v2(157.92,31.93) ; v2(91.73,171.31) 91.73,171.88 D21.2 ; C306.2 201.46,58.15 201.28,58.32 v2(200.69,58.32) C305.2 ; U115.1 195.49,33.36 arc(195.59,33.34) 195.67,33.28 v2(195.88,33.07) ; R17.2 v2(29.24,176.06) 29.02,176.28 arc(28.94,176.33) 28.84,176.35 U6.6 ; U147.5 v1(179.64,19.07) v2(179.63,19.09) ; v2(130.87,22.96) 130.86,22.96 U137.2 ; R534.2 v1(159.36,48.22) ; v2(169.81,53.17) 169.67,53.02 C328.2 169.58,52.45 U89.11 ; U97.3 70.1,48.37 v4(70.1,48.37) ; U154.47 53.53,14.49 v2(53.68,14.64) 53.81,14.77 arc(53.89,14.82) 53.99,14.84 C507.2 ; U50.19 52.87,103.58 arc(52.97,103.6) 53.05,103.65 v2(53.22,103.83) ; U65.1 199.07,74.37 arc(199.17,74.35) 199.25,74.3 v2(199.47,74.08) ; U81.A2 v2(209.04,55.42) ; v2(147.89,81.66) 147.94,81.66 ; U43.9 v2(42.79,113.66) ; U144.25 v2(197.47,19.43) ; U75.5 v1(83.62,65.25) ; D36.2 88.48,63.23 v1(88.63,63.09) ; v3(148.73,88.73) 148.58,88.73 v1(147.93,88.08) 147.78,88.08 v1(147.13,88.73) ; D10.2 91.5,173.53 v2(91.5,172.96) ; U151.2 150.86,15.86 150.68,16.04 v2(150.68,16.54) ; J9.16 122.96,178.28 arc(122.94,178.38) 122.89,178.46 v2(122.76,178.59) ; U33.3 48.81,123.93 arc(48.71,123.95) 48.63,124 v2(48.34,124.29) ; J9.19 124.46,178.42 v2(124.64,178.59) ; 145.45,62.87 145.47,62.84 v1(146.33,62.84) ; v2(113.34,31.95) 113.34,32.26 arc(113.32,32.36) 113.27,32.44 113.21,32.5 arc(113.16,32.58) 113.14,32.68 C399.2 ; v2(26.83,173.23) C24.2 v2(26.83,174.73) ; D26.2 v2(120.14,171.3) ; U60.1 199.07,78.4 arc(199.17,78.38) 199.25,78.33 v2(199.47,78.11) ; U71.Y1 155.94,73.89 155.96,73.91 ; v2(127.17,24.2) 126.7,24.68 U134.3 ; v2(27.72,19.9) 27.59,19.77 arc(27.54,19.68) 27.52,19.59 U141.4 ; U42.2 73.48,112.16 arc(73.46,112.07) 73.41,111.98 73.19,111.77 v2(73.01,111.77) 71.89,110.65 arc(71.8,110.59) 71.71,110.57 C198.1 71.19,110.61 R247.1 ; U37.12 194.06,121.62 194.2,121.76 v2(194.2,122.04) ; U115.7 189.11,34.86 arc(189.01,34.88) 188.93,34.93 v2(188.65,35.21) ; D19.2 v2(111.92,171.55) ; U46.38 v2(212.23,103.54) 212.23,103.78 arc(212.31,103.96) 212.49,104.04 U46.37 ; v2(175.67,69.15) 175.83,69.3 U68.21 ; U69.2 v1(76.51,71.48) ; U103.3 v2(49.4,41.7) ; C266.2 83.04,79.69 v4(82.51,80.22) ; v2(188.65,52.54) 188.93,52.26 arc(189.01,52.21) 189.11,52.19 190.28,52.19 U83.7 ; U25.17 199.97,149.6 v2(199.88,149.51) ; U144.51 183.42,21.93 arc(183.33,21.91) 183.25,21.85 183.18,21.79 arc(183.1,21.74) 183,21.72 v2(182.67,21.72) ; U81.A1 v2(204.6,55.53) ; U48.2 73.48,100.78 73.29,100.59 v2(73.01,100.59) 72.72,100.3 70.7,100.3 70.34,100.66 C226.1 ; v2(130.83,162.98) 131.01,162.8 C64.1 ; C443.2 101.83,24.95 arc(101.74,24.93) 101.65,24.87 v2(101.19,24.41) ; C95.2 v2(206.31,156.55) ; U140.2 v2(81.56,21.06) ; C50.2 v2(19.14,165.74) 19.14,164.6 C54.2 ; U144.11 191.54,13.48 191.54,14.32 arc(191.52,14.42) 191.47,14.5 v2(191.29,14.68) 191.12,14.5 arc(191.06,14.42) 191.04,14.32 191.04,13.48 U144.10 ; v2(56.96,26.04) 56.8,26.2 arc(56.71,26.26) 56.62,26.28 U132.6 ; v2(211.23,49.13) 210.72,49.13 210.6,49.25 U88.1 ; 21.42,185.35 21.41,185.36 J1.5 ; U111.3 88.1,34.61 87.99,34.72 v2(87.37,34.72) ; R240.2 64.2,113.18 arc(64.18,113.27) 64.13,113.36 v2(63.83,113.66) ; J23.16 10.38,86.92 v2(8.82,86.92) ; U108.8 v2(62.75,36.23) ; U14.3 34.23,166.19 arc(34.25,166.28) 34.31,166.37 34.47,166.53 arc(34.55,166.58) 34.65,166.6 v2(34.87,166.6) ; U16.2 207.4,164.11 arc(207.39,164.21) 207.33,164.29 v2(207.2,164.42) ; U81.3 v2(206.51,54.97) ; v2(140.88,16.54) 140.88,16.04 141.05,15.86 U150.2 ; v2(113.34,24.51) 113.34,24.79 arc(113.32,24.89) 113.27,24.97 113.21,25.03 arc(113.16,25.11) 113.14,25.21 C439.2 ; v2(145.83,74.32) 145.45,74.32 145.45,74.32 ; D20.2 v2(114.27,171.55) ; U78.4 v2(27.07,64.63) ; J8.16 97.09,178.28 arc(97.07,178.38) 97.02,178.46 v2(96.88,178.59) ; v2(39.29,10.73) 39.65,10.73 arc(39.75,10.71) 39.83,10.65 39.94,10.55 arc(39.99,10.46) 40.01,10.37 40.01,10.3 arc(40.03,10.2) 40.09,10.12 40.14,10.06 arc(40.23,10.01) 40.32,9.99 U154.11 v2(42.3,9.99) ; U145.15 v2(219.64,14.67) ; R31.1 v2(59,171.41) R27.1 ; v2(49.77,27.95) 49.78,27.93 R628.1 ; C323.2 171.21,52.79 arc(171.23,52.88) 171.29,52.97 v2(171.41,53.09) ; U154.2 40.29,14.49 arc(40.2,14.51) 40.11,14.56 39.72,14.96 arc(39.63,15.02) 39.54,15.03 v2(39.29,15.03) ; U98.10 v2(228.81,48.22) ; U89.6 v1(172.19,49.64) ; v2(101.02,172.8) 100.57,172.8 arc(100.39,172.73) 100.32,172.55 D24.2 ; v2(24.11,178.68) v2(24.85,178.68) ; U144.15 193.54,13.48 v2(193.54,14.67) ; v2(54.24,7.2) 53.73,7.2 arc(53.64,7.21) 53.55,7.27 53.41,7.41 arc(53.33,7.47) 53.23,7.49 U154.33 ; R635.1 200.3,24.29 v2(200.31,24.28) ; v2(145.93,91.01) 145.48,91.01 145.47,91.01 ; v2(127.24,176.41) 127.24,175.7 arc(127.22,175.6) 127.16,175.52 127.13,175.49 arc(127.07,175.4) 127.05,175.31 C23.2 ; U34.2 v2(29.38,125.24) ; v2(74.32,26.85) 74.28,26.89 C423.2 ; R479.1 U82.2 ; R38.1 v2(151.62,171.09) ; v2(199.47,78.9) U60.2 ; D16.2 v2(123.14,172.97) ; v2(155.53,67.07) 155.98,67.07 155.99,67.08 ; U73.4 v2(22.43,72.18) ; U10.14 19.04,174.45 arc(19.06,174.36) 19.11,174.27 v2(19.36,174.02) 19.61,174.27 arc(19.67,174.35) 19.69,174.45 U10.13 ; C185.2 107.15,114.94 v4(107.14,114.94) ; J8.11 94.59,178.31 arc(94.57,178.41) 94.52,178.49 v2(94.39,178.62) ; U120.7 179.71,37.14 arc(179.73,37.24) 179.79,37.32 v2(180.07,37.6) ; U71.C1 155.99,62.84 155.99,62.84 ; v2(123.52,89.03) v3(123.12,89.43) ; v1(179.05,48.37) 179.21,48.53 U87.6 ; 145.4,71.3 145.4,71.29 v3(146.33,71.29) ; R32.1 v2(144,171.09) ; 156.02,87.1 156.01,87.11 v2(155.53,87.11) ; v2(178.63,172.32) 178.49,172.47 U8.A2 179.02,173.29 arc(179.11,173.27) 179.2,173.22 179.26,173.16 arc(179.31,173.07) 179.33,172.98 179.33,172.62 arc(179.35,172.52) 179.41,172.44 v2(179.56,172.29) ; U145.47 213.14,23.6 v2(213.05,23.52) ; U124.2 v2(165.85,31.45) ; R193.2 v2(192.74,124.83) ; 155.96,88.39 155.95,88.41 v2(155.53,88.41) ; C20.1 181.75,174.99 v2(181.71,174.95) ; v2(50.81,85.98) 50.98,86.16 arc(51.06,86.21) 51.16,86.23 U58.19 ; v2(145.93,66.42) 145.45,66.42 145.45,66.42 ; U46.35 214.17,105.04 arc(214.27,105.06) 214.35,105.11 v2(214.53,105.3) ; U25.3 v2(204.97,154.19) ; v2(214.96,96.02) 214.7,96.29 arc(214.61,96.34) 214.52,96.36 v1(213.72,96.36) ; J23.57 v2(14.56,97.42) ; D9.2 88.97,173.1 v2(89.09,172.98) ; U145.10 217.14,14.32 arc(217.16,14.42) 217.21,14.5 v2(217.39,14.68) 217.57,14.5 arc(217.62,14.42) 217.64,14.32 U145.11 ; v2(183.03,122.04) 183.03,121.76 182.88,121.62 U36.12 ; U148.2 v2(121.6,16.13) 121.45,16.28 C493.1 121.45,17.25 arc(121.47,17.35) 121.52,17.43 121.61,17.52 arc(121.67,17.6) 121.69,17.7 v2(121.69,18.16) ; v2(171.43,37.6) 171.15,37.32 arc(171.1,37.24) 171.08,37.14 U117.7 ; U143.9 v2(199.84,18.6) ; D11.2 94.74,173.53 v2(94.74,172.96) ; 145.47,87.76 145.48,87.75 v2(145.93,87.75) ; v2(97.93,173.08) 97.3,173.71 D12.2 ; U130.2 v2(226.27,27.97) ; U4.2 v2(154.44,179.94) ; v1(147.13,90.68) 147.78,91.33 v1(147.93,91.33) 148.58,90.68 v1(148.73,90.68) ; U144.35 193.04,24.88 v2(193.04,23.65) ; U122.4 v2(163.07,31.01) ; 173.12,176.27 U8.27 ; v2(192.54,14.67) 192.54,13.48 U144.13 ; J10.6 v1(75.08,182.16) ; R129.2 103.99,151.91 v2(104.14,151.77) ; R14.1 v2(141.59,176.88) ; U94.7 189.11,47.43 arc(189.01,47.45) 188.93,47.5 v2(188.65,47.78) ; U80.9 187.63,60.35 arc(187.53,60.37) 187.45,60.42 v2(187.33,60.54) R469.1 ; v2(43.31,103.33) 43.48,103.5 arc(43.56,103.56) 43.66,103.58 U50.38 ; J9.8 v2(118.96,178.62) ; U110.2 83.37,36.41 arc(83.46,36.42) 83.55,36.48 83.6,36.54 arc(83.69,36.59) 83.78,36.61 v2(84.11,36.61) ; U145.35 v2(219.14,23.65) ; v2(187.26,26.14) 187.12,26 arc(187.06,25.92) 187.04,25.82 U144.47 ; 145.5,95.35 v2(145.83,95.35) ; R20.1 v2(59,173.28) ; D15.2 v2(120.79,172.97) ; v2(46.31,175.65) v2(45.4,175.65) ; C166.1 v2(57.08,121.9) C164.2 ; U113.2 227.26,37.12 227.11,37.27 v2(226.78,37.27) 226.4,37.27 226.26,37.13 U113.4 ; R22.2 v2(10.56,174.26) ; v1(146.33,92.63) 145.45,92.63 145.45,92.63 ; C422.2 73.14,26.89 v2(73.1,26.85) ; C442.2 76.18,24.95 arc(76.08,24.93) 76,24.87 v2(75.54,24.41) ; R663.1 v2(225.57,20.23) ; U155.3 125.26,11.46 arc(125.24,11.56) 125.19,11.64 v2(125.02,11.81) ; J9.2 v2(115.96,178.62) ; U80.3 196.24,57.1 arc(196.33,57.08) 196.42,57.02 C316.1 196.4,56.52 arc(196.32,56.47) 196.22,56.45 U80.2 ; U128.1 153.84,25.11 arc(153.82,25.01) 153.76,24.93 v2(153.55,24.71) ; U143.14 203.09,18.23 arc(203.11,18.33) 203.17,18.41 v2(203.41,18.65) 203.67,18.39 arc(203.73,18.31) 203.74,18.21 U143.15 ; U71.A10 v2(147.93,60.32) ; U37.15 v2(192.26,123.03) ; U122.6 162.09,32.88 v2(163.51,32.88) ; R34.1 v2(146.54,171.09) R36.1 R37.1 ; U154.16 v2(42.3,7.49) ; U76.6 v2(193.1,68.42) ; C244.2 C242.2 C241.2 194.75,90.23 arc(194.66,90.21) 194.57,90.15 TP95.1 ; U106.7 189.11,39.05 arc(189.01,39.07) 188.93,39.12 v2(188.65,39.4) ; 155.94,91.67 155.93,91.66 v2(155.53,91.66) ; U37.13 v2(193.84,122.7) ; U152.2 160.66,15.86 160.49,16.04 v2(160.49,16.54) ; D27.2 123.83,171.22 v2(123.75,171.14) 123.58,170.96 R44.1 ; U125.6 v1(114.86,32.09) ; C449.1 207.48,23.26 arc(207.46,23.16) 207.41,23.08 207.29,22.96 ; v2(209.61,57.18) 209.43,57.36 arc(209.34,57.42) 209.25,57.44 U81.9 ; U79.B3 v2(138.1,45.23) ; v2(45.77,80.98) 45.6,80.8 arc(45.51,80.75) 45.42,80.73 U58.49 ; U48.13 v2(72.43,104.08) ; J8.5 v2(91.59,178.62) ; v2(152.64,179.78) D8.2 152.61,180.55 152.61,181.21 arc(152.59,181.3) 152.54,181.39 152.4,181.53 arc(152.34,181.61) 152.32,181.71 J4.A1 152.32,183.42 v2(152.34,183.44) 152.37,183.47 J4.B12 ; v2(88.58,171.55) 88.4,171.73 D18.2 ; v2(203.59,24.28) 203.59,24.29 C441.1 203.59,24.19 203.74,24.03 U143.2 ; U145.51 209.59,21.93 arc(209.49,21.91) 209.41,21.85 209.35,21.79 arc(209.26,21.74) 209.17,21.72 C457.2 208.42,21.72 arc(208.33,21.74) 208.24,21.79 v2(208.07,21.97) ; U112.8 55.26,37.2 arc(55.36,37.22) 55.44,37.27 v2(55.69,37.52) ; v2(200.51,4.54) R729.2 v2(200.51,1.87) ; v2(192.23,76.22) 192.51,75.94 arc(192.6,75.89) 192.69,75.87 U65.7 ; U46.14 219.81,104.04 v2(219.89,103.95) ; R42.1 97.7,170.89 arc(97.69,170.98) 97.63,171.07 v2(97.52,171.18) 97.89,171.55 arc(97.94,171.63) 97.96,171.73 D23.2 ; v2(53.27,80.98) 53.12,80.98 52.94,80.8 arc(52.86,80.75) 52.76,80.73 U58.8 ; U38.3 v2(47.47,121.81) ; D3.2 v2(142.82,183.57) ; R697.1 63.84,14 arc(63.82,14.1) 63.76,14.18 v2(63.28,14.66) ; v2(13.25,100.6) J23.64 v2(13.25,96.84) J23.63 v2(13.25,90.68) J23.62 v2(13.25,84.52) J23.61 ; v2(206.07,61.42) 206.07,61.3 206.44,60.94 arc(206.5,60.85) 206.51,60.76 U81.16 ; v2(61.26,183.46) v2(63.15,183.46) v2(66.15,183.46) v2(72.5,183.46) v2(75.53,183.46) v2(77.39,183.46) ; D1.2 v2(142.82,187.19) ; v2(202.32,132.31) 202.32,132.37 202.6,132.65 arc(202.65,132.73) 202.67,132.83 U32.7 ; C167.1 v2(62.92,120.63) C169.2 ; R26.2 v2(181.71,173.81) ; J4.B1 146.27,183.77 arc(146.29,183.68) 146.35,183.59 v2(146.5,183.44) 146.32,183.26 J4.A12 146.32,181.63 arc(146.3,181.53) 146.25,181.45 146.08,181.28 arc(146.02,181.2) 146,181.1 D5.2 v2(146,179.78) ; v1(126.85,156.78) 126.85,157.4 arc(126.87,157.5) 126.93,157.58 127.09,157.75 arc(127.15,157.83) 127.17,157.93 U20.1 ; C470.2 v2(98.11,19.11) ; 187.7,7.36 v2(186.93,7.36) ; U70.1 v2(72.15,67.88) ; U36.15 v2(181.09,123.03) ; C445.1 v2(181.9,25.35) ; U145.1 v1(212.64,14.62) ; 155.96,95.56 155.96,95.56 v2(155.53,95.56) ; 145.47,84.51 v2(145.93,84.51) ; C431.2 v2(214.87,27.58) ; U106.2 v2(195.88,38.05) ; v2(175.75,37.6) 175.47,37.32 arc(175.42,37.24) 175.4,37.14 U118.7 ; C15.2 v2(16.66,176.76) ; v4(69.99,53.3) 70.1,53.18 U86.3 ; U25.14 199.97,151.1 v2(199.88,151.19) ; v2(65.55,72.12) R423.1 ; D28.2 v2(126.19,172.8) ; U81.A3 v2(208.92,59.85) ; U58.38 v2(43.29,86.23) ; v2(155.53,93.61) 155.92,93.61 155.94,93.62 ; D6.2 148.14,180.1 arc(148.12,180) 148.07,179.92 v2(147.91,179.76) ; C318.2 v2(202.65,52.7) ; C88.2 v2(207.58,158.41) ; C351.2 166.23,45.28 TP184.1 ; U50.49 45.42,98.08 arc(45.51,98.1) 45.6,98.15 v2(45.77,98.33) ; U54.A10 C915.2 ; U18.6 v1(136.51,161.38) ; U144.5 188.54,14.34 arc(188.56,14.44) 188.62,14.52 v2(188.83,14.74) ; C1269.2 v1(73.01,65.83) ; v2(98.75,26.85) 98.79,26.89 C424.2 ; D33.2 v2(16.57,124.19) ; R637.1 v2(22.44,23.81) ; U157.4 v2(209.84,7.36) ; J8.2 v2(90.09,178.62) ; v2(86.22,28.15) 86.04,28.33 C409.2 ; C471.2 v2(99.61,19.11) ; U15.3 v2(32.11,167.91) ; U48.15 v2(71.99,102.52) ; U149.2 131.25,15.86 131.08,16.04 v2(131.08,16.54) ; D2.2 v2(156.56,186.45) ; J9.11 v2(120.46,178.62) ; J10.24 v2(68.58,178.87) ; D4.2 v2(156.56,184.31) ; U80.8 v2(196.12,60.35) ; J8.8 v2(93.09,178.62) ; J10.16 v2(71.58,182.16) ; D14.2 v2(117.19,172.97) ; J9.5 v2(117.46,178.62)
  TOP w0.305: U59.N7 128.72,78.23 v2(129.12,77.83) ; v2(113.12,73.83) 113.51,74.23 U59.H26 ; U59.F22 116.71,72.63 v2(116.32,72.23) ; v2(110.72,68.23) 111.11,68.63 U59.A29 ; U59.AA19 119.12,84.64 v2(118.72,85.03) ; v2(125.92,73.03) 125.52,73.43 U59.G11 ; U59.AH5 130.32,90.23 v2(129.92,89.83) 129.52,89.43 U59.AG6 ; v2(111.52,79.43) 111.91,79.83 U59.R28 ; U59.Y18 119.92,83.84 v2(119.52,84.23) ; v2(125.12,87.43) 124.72,87.03 U59.AD12 ; v2(111.52,69.03) 111.91,69.43 U59.B28 ; v2(155.53,95.56) 155.13,95.23 U54.Y1 ; v2(124.32,77.83) 123.92,78.23 U59.N13 ; v2(112.32,83.43) 112.72,83.04 U59.W27 ; v2(128.32,87.43) 127.92,87.03 U59.AD8 ; U71.AB10 147.93,75.19 v2(147.61,75.6) ; v2(117.92,89.03) 118.32,88.64 U59.AF20 ; U59.M24 115.11,77.43 v2(114.72,77.03) ; U59.AF18 119.92,88.64 v2(119.52,89.03) ; v2(125.12,85.83) 124.72,85.43 U59.AB12 ; U59.AA11 125.52,84.63 v2(125.92,85.03) ; U59.K22 116.71,75.83 v2(116.32,75.43) ; U59.W29 111.12,83.04 v2(110.72,83.43) ; v2(115.52,86.63) 115.92,86.24 U59.AC23 ; U59.U27 112.71,81.43 v2(112.32,81.03) ; U54.P1 155.13,91.33 v2(155.53,91.66) ; U59.AA15 v2(122.72,85.03) ; U54.D11 146.34,84.18 U54.C12 146.33,84.18 v2(145.93,84.51) ; U54.D4 v2(153.13,84.5) ; U71.AB3 153.53,75.2 v2(153.93,75.52) ; v2(120.32,81.03) 120.71,81.43 U59.U17 ; U54.A10 v2(148.33,83.2) ; U59.AC25 114.32,86.24 v2(113.92,86.63) ; v2(128.6,36.4) U246.B3 ; U54.AB5 v2(151.93,97.07) ; U71.J3 v2(153.93,67.07) U71.K2 ; U59.AE27 112.72,87.84 v2(112.32,88.23) ; v2(116.32,85.83) 116.72,85.44 U59.AB22 ; v2(113.12,84.23) 113.52,83.84 U59.Y26 ; v2(116.32,82.63) 116.72,82.24 U59.V22 ; U59.Y10 126.32,83.83 v2(126.72,84.23) ; v2(125.92,76.23) 125.52,76.63 U59.L11 ; v2(117.12,79.43) 117.51,79.83 U59.R21 ; v2(127.52,79.43) 127.12,79.83 U59.R9 ; U59.K20 118.31,75.83 v2(117.92,75.43) ; TP21.1 159.03,158 arc(158.97,158.1) 158.94,158.22 C68.2 C69.2 C70.2 ; U59.AE7 128.72,87.83 v2(129.12,88.23) ; v2(123.52,72.23) 123.12,72.63 U59.F14 ; v2(120.32,74.63) 120.71,75.03 U59.J17 ; v2(130.72,68.23) 131.13,68.63 131.12,68.63 U59.A4 ; v2(113.12,70.63) 113.51,71.03 U59.D26 ; v2(117.92,85.83) 118.32,85.44 U59.AB20 ; U71.D4 v2(153.13,63.17) ; U71.P3 v2(153.93,69.67) ; v2(113.12,85.83) 113.52,85.44 U59.AB26 ; v2(129.12,72.23) 128.72,72.63 U59.F7 ; U71.G5 v2(151.53,65.12) ; v2(149.13,92.31) 149.53,92.63 U54.T8 ; v2(152.33,88.41) U54.K4 ; U59.M8 127.92,77.43 v2(128.32,77.03) ; U54.W4 152.73,94.58 v2(153.13,94.91) ; v2(133.92,68.23) 133.52,68.63 U59.A1 ; v2(122.72,73.03) 122.32,73.43 U59.G15 ; U68.36 179.53,74.32 arc(179.41,74.3) 179.32,74.23 179.24,74.16 arc(179.15,74.1) 179.03,74.07 v4(178.11,74.07) v4(177.1,74.07) v4(176.08,74.07) ; v2(123.52,73.83) 123.12,74.23 U59.H14 ; v1(147.13,63.49) 146.34,62.84 v1(146.33,62.84) ; U59.AC27 112.72,86.24 v2(112.32,86.63) ; v2(120.32,73.03) 120.71,73.43 U59.G17 ; v2(124.32,88.23) 123.92,87.83 U59.AE13 ; U59.AF14 123.12,88.63 v2(123.52,89.03) ; v2(109.12,68.23) 109.51,68.63 U59.A31 ; v2(114.72,73.83) 115.11,74.23 U59.H24 ; U59.F24 115.11,72.63 v2(114.72,72.23) ; U59.P12 124.72,79.03 v2(125.12,78.63) ; v2(128.32,80.23) 127.92,80.63 U59.T8 ; v1(111.12,84.64) U59.AA29 111.52,84.23 v1(111.92,83.84) U59.Y28 ; v2(125.92,77.83) 125.52,78.23 U59.N11 ; U59.R23 115.91,79.83 v2(115.52,79.43) ; v2(147.53,70.97) 147.93,71.3 U71.T10 ; v2(115.52,83.43) 115.92,83.04 U59.W23 ; U59.AD18 119.92,87.04 v2(119.52,87.43) ; v2(117.92,72.23) 118.31,72.63 U59.F20 ; U59.T20 118.31,80.63 v2(117.92,80.23) ; U59.J21 117.51,75.03 v2(117.12,74.63) ; v2(113.92,71.43) 114.31,71.83 U59.E25 ; v2(126.72,82.63) 126.32,82.23 U59.V10 ; v2(119.52,78.63) 119.91,79.03 U59.P18 ; U59.W19 119.12,83.04 v2(118.72,83.43) ; U59.AG3 131.92,89.43 v2(131.52,89.03) ; v2(117.92,73.83) 118.31,74.23 U59.H20 ; U59.L9 127.12,76.63 v2(127.52,76.23) ; v2(113.92,73.03) 114.31,73.43 U59.G25 ; v2(126.72,73.83) 126.32,74.23 U59.H10 ; v2(114.72,89.03) 115.12,88.64 U59.AF24 ; U59.AA27 112.72,84.64 v2(112.32,85.03) ; v2(127.52,83.43) 127.12,83.03 U59.W9 ; U59.AD29 v2(111.52,87.43) 111.92,87.04 U59.AD28 ; U59.Y22 116.72,83.84 v2(116.32,84.23) ; v2(145.83,74.32) 146.33,73.9 U71.Y12 ; v3(153.53,61.54) v2(153.13,61.19) ; U59.M4 131.12,77.43 v2(130.72,77.83) 130.32,78.23 U59.N5 ; v2(117.12,77.83) 117.51,78.23 U59.N21 ; v2(127.52,81.03) 127.12,81.43 U59.U9 ; U59.AB18 119.92,85.44 v2(119.52,85.83) ; U54.C5 v2(151.53,83.85) ; U59.J19 119.11,75.03 v2(118.72,74.63) ; v2(126.72,80.23) 126.32,80.63 U59.T10 ; v2(119.52,82.63) 119.92,82.24 U59.V18 ; v2(125.92,89.03) 125.52,88.63 U59.AF11 ; v2(127.52,77.83) 127.12,78.23 U59.N9 ; U59.K8 127.92,75.83 v2(128.32,75.43) ; U59.AF28 111.92,88.64 v2(111.52,89.03) ; v2(129.12,74.63) 128.72,75.03 U59.J7 ; v2(121.92,73.83) 121.52,74.23 U59.H16 ; U59.Y12 124.72,83.83 v2(125.12,84.23) ; U59.G23 115.91,73.43 v2(115.52,73.03) ; v2(117.12,85.03) 117.52,84.64 U59.AA21 ; U59.AA23 115.92,84.64 v2(115.52,85.03) ; U245.B3 v4(119.85,36.4) ; U59.AC13 123.92,86.23 v2(124.32,86.63) ; v2(113.92,77.83) 114.31,78.23 U59.N25 ; U59.AF8 127.92,88.63 v2(128.32,89.03) ; U59.G21 117.51,73.43 v2(117.12,73.03) ; v2(118.72,88.23) 119.12,87.84 U59.AE19 ; U59.U25 114.31,81.43 v2(113.92,81.03) ; v2(111.52,73.83) 111.91,74.23 U59.H28 ; v2(126.72,87.43) 126.32,87.03 U59.AD10 ; U59.F16 121.52,72.63 v2(121.92,72.23) ; v2(128.32,84.23) 127.92,83.83 U59.Y8 ; U59.H8 v2(127.52,74.63) 127.12,75.03 U59.J9 ; v2(153.13,73.57) 152.73,73.25 U71.W4 ; U59.K29 111.11,75.83 v2(110.72,75.43) ; v2(114.72,85.83) 115.12,85.44 U59.AB24 ; v2(113.12,87.43) 113.52,87.04 U59.AD26 ; v2(128.32,82.63) 127.92,82.23 U59.V8 ; U59.W11 125.52,83.03 v2(125.92,83.43) ; U245.C1 v2(122.85,38.4) ; v2(123.52,77.03) 123.12,77.43 U59.M14 ; U59.M18 119.91,77.43 v2(119.52,77.03) ; v2(117.92,77.03) 118.31,77.43 U59.M20 ; v2(119.52,72.23) 119.91,72.63 U59.F18 ; v2(110.72,77.83) 111.11,78.23 U59.N29 ; v2(125.12,73.83) 124.72,74.23 U59.H12 ; v2(128.32,85.83) 127.92,85.43 U59.AB8 ; U54.D2 v2(154.73,84.51) 155.13,84.18 U54.C1 ; v2(118.72,79.43) 119.11,79.83 U59.R19 ; v2(118.72,86.63) 119.12,86.24 U59.AC19 ; v2(113.12,78.63) 113.51,79.03 U59.P26 ; v2(115.52,81.03) 115.91,81.43 U59.U23 ; U59.AD14 123.12,87.03 v2(123.52,87.43) ; v2(129.12,76.23) 128.72,76.63 U59.L7 ; U59.L19 119.11,76.63 v2(118.72,76.23) ; U59.V28 111.92,82.24 v2(111.52,82.63) ; v2(118.72,73.03) 119.11,73.43 U59.G19 ; U54.G1 v2(155.53,87.11) ; U71.C5 v2(151.53,62.52) ; U59.G9 127.12,73.43 v2(127.52,73.03) ; U59.N17 120.71,78.23 v2(120.32,77.83) ; U59.AF5 130.32,88.63 v2(130.72,88.23) 131.12,87.83 U59.AE4 ; U59.P24 115.11,79.03 v2(114.72,78.63) ; U54.A3 v2(153.13,82.53) ; v2(115.52,76.23) 115.91,76.63 U59.L23 ; v2(122.72,76.23) 122.32,76.63 U59.L15 ; v2(155.53,67.07) U71.J1 ; U59.K16 121.52,75.83 v2(121.92,75.43) ; U54.K2 v2(153.93,88.41) U54.J3 ; v2(147.61,96.93) 147.93,96.53 U54.AB10 ; v2(113.12,80.23) 113.51,80.63 U59.T26 ; v2(149.93,97.01) 149.53,96.53 U54.AB8 ; U59.K14 123.12,75.83 v2(123.52,75.43) ; U59.C27 112.71,70.23 v2(112.32,69.83) ; v2(155.53,65.77) U71.G1 ; U71.AB8 149.53,75.2 v2(149.93,75.67) ; v2(145.93,69.67) 146.33,70 U71.P12 ; v2(149.93,72.92) 149.53,72.6 U71.V8 ; U59.AC9 127.12,86.23 v2(127.52,86.63) ; U59.R11 125.52,79.83 v2(125.92,79.43) ; v2(114.72,87.43) 115.12,87.04 U59.AD24 ; U71.G10 v2(147.53,65.12) ; v2(112.32,73.03) 112.71,73.43 U59.G27 ; U59.AB10 126.32,85.43 v2(126.72,85.83) ; v2(123.52,78.63) 123.12,79.03 U59.P14 ; U59.U11 125.52,81.43 v2(125.92,81.03) ; C115.1 12.59,139.29 arc(12.66,139.39) 12.68,139.51 v2(12.68,139.75) ; v2(119.52,75.43) 119.91,75.83 U59.K18 ; v2(112.32,75.43) 112.71,75.83 U59.K27 ; v2(125.12,77.03) 124.72,77.43 U59.M12 ; U54.E1 v2(155.53,85.16) ; v2(120.32,86.63) 120.72,86.24 U59.AC17 ; U59.B30 110.31,69.43 v2(109.92,69.03) ; U59.P16 121.52,79.03 v2(121.92,78.63) ; U59.P10 126.32,79.03 v2(126.72,78.63) ; v2(119.52,73.83) 119.91,74.23 U59.H18 ; U245.E5 118.35,39.9 v2(117.85,40.4) ; U246.E5 v4(125.6,40.4) ; v2(117.12,89.03) 117.52,88.64 U59.AF21 ; U54.P3 v2(153.93,91) ; v3(149.53,85.48) v2(149.93,85.15) ; v2(147.53,92.31) 147.93,92.63 U54.T10 ; U59.Y20 118.32,83.84 v2(117.92,84.23) ; v2(111.52,85.83) 111.92,85.44 U59.AB28 ; U54.J12 v2(145.93,87.75) ; U54.Y12 146.33,95.23 v2(145.83,95.35) ; v2(111.52,70.63) 111.91,71.03 U59.D28 ; v2(129.12,81.03) 128.72,81.43 U59.U7 ; v2(119.52,80.23) 119.91,80.63 U59.T18 ; v2(155.53,93.61) 155.13,93.93 U54.V1 ; U59.AE25 114.32,87.84 v2(113.92,88.23) ; U59.R25 114.31,79.83 v2(113.92,79.43) ; v2(110.72,69.83) 111.11,70.23 U59.C29 ; v2(125.12,82.63) 124.72,82.23 U59.V12 ; v2(154.73,74.22) 155.13,73.9 U71.Y1 ; U59.AB14 123.12,85.43 v2(123.52,85.83) ; U59.M28 111.91,77.43 v2(111.52,77.03) ; v2(125.12,75.43) 124.72,75.83 U59.K12 ; U71.E1 v2(154.73,63.82) U71.D2 ; U54.P12 146.33,91.33 v2(145.93,91.01) ; v2(110.72,81.03) 111.11,81.43 U59.U29 ; v2(114.72,80.23) 115.11,80.63 U59.T24 ; U59.L17 120.71,76.63 v2(120.32,76.23) ; v2(116.32,80.23) 116.71,80.63 U59.T22 ; U71.T8 149.53,71.3 v2(149.13,70.97) ; v2(127.52,85.03) 127.12,84.63 U59.AA9 ; v2(153.22,96.98) 153.53,96.53 U54.AB3 ; U59.M22 116.71,77.43 v2(116.32,77.03) ; v2(124.32,73.03) 123.92,73.43 U59.G13 ; U59.AC21 117.52,86.24 v2(117.12,86.63) ; v2(113.92,85.03) 114.32,84.64 U59.AA25 ; v2(171.26,74.96) 171.39,74.82 U68.6 ; v2(120.32,83.43) 120.72,83.04 U59.W17 ; 21.42,185.35 v2(21.78,185) ; v2(117.92,82.63) 118.32,82.24 U59.V20 ; v2(120.32,85.03) 120.72,84.64 U59.AA17 ; U59.P20 118.31,79.03 v2(117.92,78.63) ; U59.AC15 v2(122.72,86.63) ; U59.J13 123.92,75.03 v2(124.32,74.63) ; v2(124.32,85.03) 123.92,84.63 U59.AA13 ; v2(121.92,77.03) 121.52,77.43 U59.M16 ; U59.AE17 120.72,87.84 v2(120.32,88.23) ; v2(116.32,73.83) 116.71,74.23 U59.H22 ; U59.N15 122.32,78.23 v2(122.72,77.83) ; v2(117.12,88.23) 117.52,87.84 U59.AE21 ; U59.L13 123.92,76.63 v2(124.32,76.23) ; v2(155.53,70.32) U71.P1 ; U59.R17 120.71,79.83 v2(120.32,79.43) ; v2(122.72,74.63) 122.32,75.03 U59.J15 ; U59.AD22 116.72,87.04 v2(116.32,87.43) ; v2(115.52,77.83) 115.91,78.23 U59.N23 ; U59.AE23 115.92,87.84 v2(115.52,88.23) ; U59.P22 116.71,79.03 v2(116.32,78.63) ; U54.J1 v2(155.53,88.41) ; U68.5 172.74,75.32 172.87,75.2 v2(172.88,75.2) ; v2(154.73,63.17) 155.13,62.85 U71.C1 ; U54.G10 v2(147.53,86.45) ; U54.V8 149.53,93.93 v2(149.93,94.26) ; U71.J12 v2(145.93,66.42) ; v2(152.33,67.07) U71.K4 ; v3(149.53,64.14) v2(149.93,63.82) ; v2(149.93,65.77) 149.53,65.45 U71.G8 ; U71.AB5 v2(151.93,75.74) ; U246.C1 v4(130.6,38.4)
  TOP w0.381: U3.1 v2(138.5,181.5) ; D37.1 20.19,58.87 v2(20.43,58.63) C303.2 ; C450.2 v2(20.62,24.43) ; C349.2 C350.2 C351.2 ; U153.2 170.47,15.86 170.29,16.04 v2(170.29,16.54) ; C224.2 C231.2 C233.2 64.67,99.91 arc(64.82,99.93) 64.94,100.02 TP77.1 ; v2(10.56,170.26) 10.69,170.39 C31.2 ; v2(29.49,28.3) 29.74,28.05 U135.4 ; U146.4 31.69,13.49 arc(31.72,13.34) 31.81,13.22 32.11,12.92 arc(32.19,12.79) 32.22,12.65 v2(32.22,12.11) ; U136.4 v2(39.57,25.26) ; R686.1 v2(22.44,17.63) ; TP205.1 161.62,40.11 arc(161.65,39.96) 161.73,39.84 162.04,39.53 arc(162.12,39.4) 162.15,39.26 162.15,38.71 C385.2 C384.2 C383.2 ; v2(42.52,167.9) 42.52,169.08 arc(42.55,169.23) 42.63,169.35 v2(42.96,169.68) 42.96,170.41 42.99,170.44 U9.2 ; J49.5 v2(207.44,5.27) ; C411.2 v2(36.89,28.62) ; C487.2 v2(20.62,17.01)
  L2-GND1 w0.254: v1(153.53,92.63) v3(153.86,93.08)
  L2-GND1 w0.305: v2(123.52,89.03) v3(123.12,89.43)
  L3-SIGNAL1 w0.127: v5(133.03,75.9) v3(132.73,75.83) ; v5(133.09,70.35) v3(132.73,70.23) ; v5(132.29,69.55) v3(131.93,69.43) ; v5(132.16,79.55) v3(131.93,79.83) ; v5(133.1,88.65) v3(132.72,88.63) ; v5(130.69,72.75) v3(130.33,72.63) ; v5(129.62,72.19) v3(129.53,71.83) ; v5(130.18,81.03) v3(130.33,80.63) ; v5(132.28,87.15) v3(131.92,87.03) ; v5(130.21,70.59) v3(130.33,70.23) ; v5(129.14,83.41) v3(129.52,83.83) ; v5(133.88,85.55) v3(133.52,85.43) ; v5(131.76,76.28) v3(131.93,76.63) ; v5(131.48,81.55) v3(131.12,81.43) ; v5(132.8,84.96) v3(132.72,84.63) ; v5(133.05,86.36) v3(132.72,86.23) ; v5(131.58,82.32) v3(131.92,82.23) ; v5(131.47,70.86) v3(131.13,71.03) ; v5(130.59,74.57) v3(130.33,74.23) ; v5(130.51,83.31) v3(130.32,83.03) ; v5(129.7,75.37) v3(129.53,75.03) ; v5(129.41,80.19) v3(129.53,79.83) ; v5(129.85,82.53) v3(129.52,82.23)
  L3-SIGNAL1 w0.14: v3(133.49,73.48) v5(133.84,73.56)
  L3-SIGNAL1 w0.254: v3(148.73,88.73) 149.24,89.24 149.24,89.24 149.31,89.31 v5(149.31,89.71) 149.31,90.1 149.18,90.22 149.18,90.23 v3(148.73,90.68) ; v3(148.73,69.35) 149.18,68.89 149.18,68.89 149.31,68.76 v5(149.31,68.37) 149.31,67.98 149.24,67.91 149.24,67.9 v3(148.73,67.39)
  L3-SIGNAL1 w0.305: v5(130.72,85.84) v3(131.12,85.43)
  L4-GND2 w0.127: v6(153.68,71.86) 153.68,71.66 arc(153.69,71.61) 153.72,71.57 154.3,70.98 arc(154.33,70.94) 154.34,70.89 154.34,70.86 arc(154.35,70.81) 154.38,70.77 154.4,70.74 arc(154.43,70.7) 154.44,70.65 154.44,70.18 ; v6(153.75,93.17) 154.29,92.63 arc(154.32,92.59) 154.33,92.54 154.33,91.45 arc(154.32,91.4) 154.29,91.36 v2(153.93,91)
  L4-GND2 w0.146: v6(133.36,88.39) v5(133.1,88.65) ; v6(131.94,76.61) v5(131.76,76.28) ; v5(133.05,86.36) 133.49,86.93 v6(133.49,87) ; v6(133.21,70) v5(133.09,70.35) ; v6(133.38,75.79) v5(133.03,75.9) ; v6(131.94,69.5) v5(132.29,69.55)
  L4-GND2 w0.185: v7(134.25,73.3) 134.22,73.3 134.22,73.3 134.17,73.41 arc(134.12,73.47) 134.05,73.51 v5(133.84,73.56) ; v5(130.69,72.75) v7(130.69,72.21) ; v7(131.71,79.4) v5(132.16,79.55) ; v7(131.83,81.9) v5(131.48,81.55) ; v7(130.69,80.99) v5(130.18,81.03) ; v7(132.88,84.53) v5(132.8,84.96) ; v7(130.83,83.03) v5(130.51,83.31) ; v5(133.88,85.55) 134.21,85.88 134.3,85.88 134.48,85.88 v7(134.48,85.9) ; v7(129.52,83.69) v5(129.85,82.53) ; v7(130.54,70.39) v5(130.21,70.59)
  L4-GND2 w0.203: v6(153.3,75.13) 153.46,75.13 arc(153.54,75.15) 153.6,75.19 v2(153.93,75.52) ; v2(152.33,88.41) 151.77,88.41 arc(151.69,88.39) 151.63,88.35 151.16,87.88 arc(151.12,87.81) 151.1,87.74 151.1,86.76 arc(151.12,86.68) 151.16,86.62 v6(151.34,86.44) ; v6(153.5,64.77) 154.2,65.47 arc(154.25,65.54) 154.26,65.62 154.26,66.65 arc(154.25,66.73) 154.2,66.8 v2(153.93,67.07)
  L4-GND2 w0.254: v5(149.31,68.37) v7(149.67,68.81)
  L4-GND2 w0.305: v2(153.93,69.67) 154.44,70.18 ; v6(153.27,96.49) 153.27,96.5 v2(153.22,96.98) ; v5(130.72,85.84) v6(131.12,85.75)
  L5-SIGNAL2 w0.127: v2(171.41,53.09) 171.41,53.44 arc(171.4,53.49) 171.37,53.53 171.24,53.66 arc(171.2,53.69) 171.15,53.7 168.26,53.7 arc(168.21,53.69) 168.17,53.66 167.33,52.82 arc(167.3,52.78) 167.29,52.73 167.29,51.9 arc(167.28,51.85) 167.26,51.81 162.39,46.94 147.07,46.94 143.55,43.42 131.19,43.42 130.62,43.99 100.08,43.99 96.21,47.87 82.34,47.87 v2(81.87,47.4) ; v2(73.01,100.59) 73.02,100.6 73.02,101.17 72.63,101.55 72.63,102.71 71.33,104 71.33,110.09 v2(73.01,111.77)
  L7-SIGNAL3 w0.127: v2(120.32,85.03) 120.77,85.49 arc(120.8,85.53) 120.81,85.58 120.81,85.95 arc(120.82,86) 120.85,86.04 121.18,86.37 arc(121.21,86.42) 121.22,86.46 121.22,90.08 arc(121.21,90.13) 121.18,90.17 120.57,90.78 arc(120.54,90.82) 120.53,90.87 120.53,91.83 arc(120.54,91.88) 120.57,91.92 120.72,92.07 arc(120.74,92.11) 120.75,92.16 120.75,92.61 arc(120.74,92.65) 120.72,92.7 120.57,92.84 arc(120.54,92.89) 120.53,92.93 120.53,95.91 117.77,98.66 arc(117.73,98.69) 117.68,98.7 115.28,98.7 arc(115.23,98.71) 115.19,98.74 114.31,99.62 arc(114.28,99.66) 114.27,99.71 114.27,102.69 arc(114.26,102.74) 114.23,102.78 113.41,103.6 arc(113.39,103.64) 113.38,103.69 113.38,111.72 arc(113.39,111.77) 113.41,111.81 116.1,114.5 arc(116.14,114.53) 116.19,114.54 116.55,114.54 arc(116.6,114.55) 116.64,114.57 120.72,118.66 arc(120.76,118.68) 120.81,118.69 158.03,118.69 arc(158.08,118.7) 158.12,118.73 161.97,122.58 arc(162.01,122.61) 162.06,122.62 163.36,122.62 arc(163.45,122.65) 163.49,122.74 v2(163.49,123.35) ; v2(120.32,86.63) 120.7,87.01 arc(120.72,87.06) 120.73,87.1 120.73,89.91 arc(120.72,89.96) 120.7,90 120.11,90.59 arc(120.08,90.63) 120.07,90.68 120.07,91.81 arc(120.06,91.86) 120.04,91.9 119.77,92.17 arc(119.75,92.21) 119.74,92.26 119.74,92.48 arc(119.75,92.53) 119.77,92.57 119.88,92.68 arc(119.91,92.72) 119.92,92.77 119.92,95.63 117.65,97.91 arc(117.61,97.93) 117.56,97.94 114.84,97.94 arc(114.79,97.95) 114.75,97.98 113.44,99.29 arc(113.42,99.33) 113.41,99.38 113.41,101.79 arc(113.4,101.84) 113.37,101.88 112.83,102.42 arc(112.81,102.46) 112.8,102.51 112.8,113.55 arc(112.81,113.6) 112.83,113.64 113.65,114.46 arc(113.69,114.48) 113.74,114.49 114.26,114.49 arc(114.31,114.5) 114.35,114.53 115.73,115.91 115.73,116.36 116.65,117.27 117.53,117.27 119.71,119.46 arc(119.76,119.49) 119.8,119.49 148.83,119.49 arc(148.88,119.5) 148.92,119.53 152.35,122.96 arc(152.37,123) 152.38,123.05 152.38,126.12 arc(152.37,126.17) 152.35,126.21 148.07,130.49 arc(148.04,130.53) 148.03,130.58 148.03,142.52 arc(148.04,142.57) 148.07,142.61 150.97,145.51 arc(151,145.55) 151.01,145.6 151.01,152.94 arc(151.02,152.99) 151.05,153.03 153.05,155.04 arc(153.1,155.06) 153.14,155.07 159.6,155.07 arc(159.64,155.08) 159.69,155.11 160.55,155.98 arc(160.58,156.02) 160.59,156.07 160.59,157.33 arc(160.58,157.37) 160.55,157.42 160.42,157.54 arc(160.38,157.57) 160.33,157.58 TP21.1
  L10-SIGNAL4 w0.127: v2(169.81,53.17) 169.81,53.49 arc(169.82,53.54) 169.85,53.58 169.93,53.66 arc(169.97,53.69) 170.02,53.7 172.19,53.7 arc(172.24,53.71) 172.28,53.73 175.54,56.99 arc(175.58,57.01) 175.63,57.02 182.71,57.02 arc(182.76,57.01) 182.8,56.99 184.27,55.51 arc(184.3,55.47) 184.31,55.42 184.31,48.01 arc(184.3,47.96) 184.27,47.92 180.87,44.51 arc(180.83,44.49) 180.78,44.48 170.7,44.48 arc(170.65,44.47) 170.61,44.44 168.3,42.13 arc(168.25,42.1) 168.21,42.09 146.85,42.09 141.79,47.14 136.33,47.14 117.51,65.96 117.51,74.24 v2(117.12,74.63) ; v2(128.32,82.63) 129.25,81.7 arc(129.29,81.67) 129.34,81.66 131.01,81.66 arc(131.06,81.65) 131.1,81.62 131.74,80.98 arc(131.79,80.95) 131.83,80.95 163.76,80.95 arc(163.81,80.95) 163.85,80.98 164.51,81.64 arc(164.55,81.67) 164.6,81.68 165.57,81.68 arc(165.62,81.67) 165.66,81.64 166.12,81.18 arc(166.16,81.15) 166.21,81.14 171.91,81.14 arc(171.96,81.15) 172,81.18 173.17,82.35 arc(173.21,82.38) 173.26,82.39 175.37,82.39 arc(175.41,82.4) 175.46,82.42 176.02,82.99 arc(176.05,83.03) 176.06,83.08 176.06,91.8 arc(176.07,91.85) 176.09,91.89 177.5,93.29 arc(177.54,93.32) 177.59,93.33 184.11,93.33 arc(184.16,93.32) 184.2,93.29 186.25,91.24 arc(186.28,91.2) 186.29,91.15 186.29,89.43 arc(186.3,89.38) 186.33,89.34 187.08,88.59 arc(187.12,88.56) 187.17,88.55 188.82,88.55 arc(188.86,88.56) 188.91,88.59 189.36,89.05 arc(189.41,89.08) 189.45,89.09 193.45,89.09 arc(193.5,89.09) 193.54,89.12 TP95.1 ; v2(164.33,122.51) 163.48,122.51 162.8,121.83 155.35,121.83 140.83,136.35 139.27,136.35 138.45,135.53 121.92,135.53 118.23,131.84 118.23,129.33 123.2,124.36 123.2,107.72 122.49,107.01 v4(122.49,105.7) ; v2(129.12,74.63) 130.12,75.64 134.58,75.64 136.61,73.61 150.81,73.61 151.75,72.67 159.75,72.67 160.33,72.09 166.3,72.09 166.92,72.7 170.75,72.7 arc(170.79,72.69) 170.84,72.67 173.22,70.28 arc(173.27,70.25) 173.31,70.24 175.75,70.24 arc(175.8,70.23) 175.84,70.2 175.96,70.09 arc(175.98,70.05) 175.99,70 175.99,69.52 arc(175.98,69.47) 175.96,69.43 v2(175.67,69.15) ; v2(182.47,50.47) 182.17,50.18 arc(182.13,50.15) 182.08,50.14 181.62,50.14 arc(181.57,50.13) 181.53,50.11 178.2,46.78 arc(178.16,46.75) 178.11,46.74 170.05,46.74 arc(170,46.73) 169.96,46.71 166.75,43.49 arc(166.7,43.46) 166.66,43.45 148.94,43.45 arc(148.89,43.46) 148.85,43.49 141.46,50.87 136.94,50.87 121.37,66.44 121.37,74.89 v2(121.92,75.43) ; v2(123.52,72.23) 122.07,70.78 arc(122.04,70.74) 122.03,70.69 122.03,66.95 136.53,52.45 141,52.45 148.26,45.19 arc(148.3,45.17) 148.35,45.16 157.78,45.16 arc(157.83,45.17) 157.87,45.19 158.91,46.24 arc(158.95,46.27) 159,46.28 164.07,46.28 arc(164.12,46.27) 164.16,46.24 164.55,45.85 arc(164.58,45.8) 164.59,45.76 164.59,44.9 arc(164.62,44.81) 164.71,44.77 TP184.1 ; v2(182.47,51.29) 182.72,51.54 arc(182.76,51.57) 182.81,51.58 183.18,51.58 arc(183.23,51.57) 183.27,51.54 183.34,51.48 arc(183.37,51.44) 183.37,51.39 183.37,48.31 arc(183.37,48.27) 183.34,48.22 180.77,45.66 arc(180.73,45.63) 180.68,45.62 170.81,45.62 arc(170.76,45.61) 170.72,45.58 168.02,42.88 arc(167.97,42.85) 167.93,42.84 147.59,42.84 arc(147.54,42.85) 147.5,42.88 141.05,49.33 137.37,49.33 120.73,65.96 120.73,74.21 v2(120.32,74.63)
  L12-SIGNAL5 w0.127: TP205.1 160.55,41.83 arc(160.53,41.87) 160.52,41.92 160.52,42.28 arc(160.51,42.33) 160.48,42.37 160.19,42.66 arc(160.15,42.69) 160.1,42.7 158.07,42.7 arc(158.03,42.69) 157.98,42.66 156.23,40.91 arc(156.19,40.88) 156.14,40.87 139.23,40.87 132.32,33.96 118.3,33.96 109.71,42.55 102.9,42.55 98.14,47.31 arc(98.11,47.35) 98.1,47.4 98.1,50.82 arc(98.11,50.87) 98.14,50.91 111.12,63.89 arc(111.16,63.92) 111.21,63.93 114.56,63.93 115.65,65.02 115.65,69.26 arc(115.66,69.31) 115.69,69.35 117.47,71.13 arc(117.5,71.18) 117.51,71.22 117.51,74.19 arc(117.5,74.24) 117.47,74.28 v2(117.12,74.63)
  L13-GND5 w0.203: v7(132.88,84.53) v9(132.88,84.05) ; v2(128.32,85.83) 129,85.15 arc(129.07,85.11) 129.15,85.09 v9(129.5,85.09)
  L13-GND5 w0.305: 134.22,73.3 134.22,73.35 134.69,73.82 arc(134.76,73.92) 134.78,74.04 134.78,74.72 arc(134.76,74.84) 134.69,74.93 v9(134.38,75.25) 134.23,75.4 132.71,75.4 v9(132.67,75.44) ; 134.22,73.3 134.22,73.3 v7(134.25,73.3) ; 134.22,73.3 134.13,73.48 v9(133.56,73.66) ; v7(132.65,72.31) v9(131.55,73)
  L14-SIGNAL6 w0.127: v4(87.5,73.18) 85.71,71.39 85.71,68.49 84.59,67.37 84.59,66.68 81.42,63.5 81.42,47.85 v2(81.87,47.4) ; v2(112.32,83.43) 111.37,84.38 arc(111.33,84.41) 111.28,84.42 108.86,84.42 102.26,84.42 arc(102.21,84.41) 102.17,84.38 101.3,83.51 arc(101.26,83.49) 101.21,83.48 93.27,83.48 arc(93.22,83.47) 93.18,83.44 92.7,82.96 arc(92.68,82.92) 92.67,82.87 92.67,78.16 arc(92.66,78.11) 92.63,78.07 91.69,77.13 arc(91.64,77.06) 91.63,76.98 91.63,75.86 arc(91.62,75.81) 91.59,75.77 90.76,74.94 arc(90.72,74.91) 90.67,74.91 90.15,74.91 arc(90.11,74.9) 90.06,74.87 88.48,73.28 arc(88.45,73.24) 88.44,73.19 88.44,72.92 arc(88.43,72.88) 88.4,72.83 87.1,71.53 arc(87.07,71.49) 87.06,71.44 87.06,67.88 arc(87.07,67.83) 87.1,67.79 88.03,66.86 88.79,66.1 88.79,53.84 arc(88.78,53.83) 88.78,53.81 88.78,47.39 arc(88.77,47.34) 88.74,47.3 86.89,45.44 arc(86.85,45.41) 86.8,45.4 80.86,45.4 arc(80.81,45.39) 80.77,45.37 80.44,45.04 arc(80.41,45) 80.4,44.95 80.4,44.16 arc(80.41,44.12) 80.44,44.07 TP192.1 ; v2(117.92,89.03) 117.52,89.43 110.2,89.43 108.14,87.36 91.42,87.36 88.69,90.1 88.69,97.24 86.98,98.95 84.72,98.95 83.52,100.14 78.57,100.14 77.62,101.09 73.51,101.09 v2(73.01,100.59)
  L14-SIGNAL6 w0.305: v9(134.02,95) 134.12,95.1 v10(134.37,95.1) ; v9(120.79,91.08) v10(120.55,91.32) ; v9(127.34,90.68) v10(127.57,90.91) ; v9(127.54,93.04) v10(127.54,93.37) ; v9(111.18,91.08) v10(111.51,91.08) ; v9(122.41,95.33) v10(122.41,95.65) ; v9(121.39,93.93) v10(121.39,94.26) ; v9(115.38,91.67) v10(115.05,91.67) ; v9(112.83,91.23) v10(113.06,91.47) ; v9(129.19,92.66) v10(129.52,92.66) ; v9(123.58,94.01) v10(123.58,94.34) ; v9(114.61,92.48) v10(114.84,92.71) ; v9(114.56,93.04) v10(114.23,93.04) ; v9(125.54,91.11) v10(125.77,91.34)
  L15-GND6 w0.305: 140.08,138.2 v10(140.33,138.3)
  BOTTOM w0.127: C866.2 115.02,83.03 U50124.2 ; C1006.2 112.72,75.79 arc(112.76,75.82) 112.81,75.83 C1005.2 ; TP77.1 68.28,100.52 75.8,92.99 84.11,92.99 91.27,85.83 92.85,85.83 94.55,84.13 111.62,84.13 v2(112.32,83.43)
  BOTTOM w0.203: U188.C1 59.34,124.66 arc(59.35,124.74) 59.4,124.81 59.45,124.86 arc(59.52,124.91) 59.6,124.92 60.05,124.92 arc(60.13,124.91) 60.2,124.86 60.39,124.67 arc(60.45,124.63) 60.53,124.61 U189.7 ; U207.C1 198.43,99.87 arc(198.51,99.86) 198.58,99.81 198.63,99.76 arc(198.68,99.69) 198.69,99.61 198.69,99.16 arc(198.68,99.08) 198.63,99.01 198.44,98.82 arc(198.4,98.76) 198.38,98.68 U208.7 ; v11(114.08,123.98) 113.81,124.25 arc(113.75,124.3) 113.67,124.31 U187.64 ; v2(10.56,170.26) 10.42,170.12 arc(10.35,170.07) 10.28,170.06 U170.48 ; U229.2 v11(60.75,74.1) ; U243.25 v11(55.96,59.2) ; U226.2 62.9,78.68 arc(62.98,78.67) 63.04,78.62 63.26,78.41 arc(63.33,78.36) 63.41,78.35 63.7,78.35 arc(63.84,78.41) 63.9,78.55 U225.B3 ; U221.7 65.5,84.73 arc(65.42,84.75) 65.35,84.79 65.16,84.98 arc(65.1,85.02) 65.02,85.04 64.56,85.04 arc(64.48,85.02) 64.42,84.98 64.36,84.92 arc(64.32,84.86) 64.3,84.78 U222.C1 ; U231.C1 64.3,69.64 arc(64.32,69.71) 64.36,69.78 64.42,69.83 arc(64.48,69.88) 64.56,69.89 65.02,69.89 arc(65.1,69.88) 65.16,69.83 65.35,69.65 arc(65.42,69.6) 65.5,69.59 U232.7 ; U187.23 v11(100.67,127.31) ; C606.2 151.76,154.03 arc(151.77,153.95) 151.82,153.88 C608.2 151.02,153.7 arc(150.94,153.69) 150.88,153.64 v2(150.76,153.53) ; U171.B3 188.86,170.25 arc(188.72,170.31) 188.66,170.45 188.66,170.75 arc(188.68,170.82) 188.72,170.89 188.94,171.11 arc(188.98,171.17) 189,171.25 U172.2 ; U211.C1 195.86,82.4 arc(195.84,82.32) 195.8,82.25 195.75,82.2 arc(195.68,82.16) 195.6,82.14 195.14,82.14 arc(195.07,82.16) 195,82.2 194.81,82.39 arc(194.74,82.43) 194.67,82.45 U212.7 ; v2(143.84,153.77) 143.84,153.56 C610.2 ; J54.20 v11(41.47,90.01) ; U210.B3 192.41,100.02 arc(192.27,100.08) 192.21,100.22 192.21,100.52 arc(192.23,100.59) 192.27,100.66 192.49,100.88 arc(192.53,100.94) 192.55,101.02 U209.2 ; v2(10.56,174.26) 10.42,174.12 arc(10.35,174.07) 10.28,174.06 U170.58 ; v2(10.55,176.23) 10.38,176.4 arc(10.32,176.44) 10.24,176.46 U170.64 ; v2(179.04,100.08) C785.2 v2(179.04,99.06) ; J54.19 v11(32.74,90.01) ; U239.7 238.3,65.04 arc(238.29,64.96) 238.24,64.89 238.05,64.71 arc(238.01,64.64) 237.99,64.56 237.99,64.1 arc(238.01,64.03) 238.05,63.96 238.11,63.91 arc(238.17,63.86) 238.25,63.85 U238.C1 ; U236.7 65.5,64.77 arc(65.42,64.78) 65.35,64.83 65.16,65.01 arc(65.1,65.06) 65.02,65.07 64.56,65.07 arc(64.48,65.06) 64.42,65.01 64.36,64.96 arc(64.32,64.89) 64.3,64.82 U235.C1 ; U170.66 11.26,177.96 v2(11.26,179.14) ; 153,131.61 v11(153.04,131.65) ; 153,131.61 153,131.08 arc(152.98,131) 152.94,130.93 152.75,130.74 arc(152.7,130.68) 152.69,130.6 U184.7 ; 153,131.61 152.87,131.73 arc(152.81,131.78) 152.73,131.79 U185.C1 ; U218.7 65.5,89.78 arc(65.42,89.79) 65.35,89.84 65.16,90.03 arc(65.1,90.07) 65.02,90.09 64.56,90.09 arc(64.48,90.07) 64.42,90.03 64.36,89.97 arc(64.32,89.91) 64.3,89.83 U219.C1 ; J54.52 41.22,98.01 arc(41.29,97.99) 41.36,97.95 v11(41.56,97.75) ; U244.8 55.28,52.92 v11(55.2,52.99) ; 63.84,93.05 64.23,93.44 arc(64.29,93.52) 64.3,93.62 U214.C3 ; D41.2 205.57,148.42 arc(205.55,148.49) 205.51,148.56 v2(205.24,148.83) ; U217.2 v2(171.05,90.66) ; U199.7 88.41,118.07 arc(88.33,118.08) 88.27,118.13 88.08,118.32 arc(88.01,118.36) 87.93,118.38 87.48,118.38 arc(87.4,118.36) 87.33,118.32 87.28,118.26 arc(87.23,118.2) 87.22,118.12 U198.C1 ; v2(16.66,176.76) 16.81,176.9 arc(16.85,176.97) 16.86,177.05 U170.80 ; C617.2 145.85,151.74 arc(145.77,151.73) 145.71,151.68 v2(145.59,151.57) 145.47,151.68 arc(145.41,151.73) 145.33,151.74 C618.2 ; U194.B3 151.98,120.51 arc(151.92,120.36) 151.78,120.3 v11(151.4,120.3) 151.12,120.58 arc(151.06,120.62) 150.98,120.64 U195.2 ; J54.5 v11(32.74,86.51) ; C1097.2 v2(57.95,56.2) ; U170.55 v2(10.55,172.86) ; v2(143.09,152.07) 143.35,151.8 arc(143.42,151.76) 143.5,151.74 C619.2 ; U170.17 16.86,161.64 arc(16.85,161.56) 16.81,161.49 16.68,161.36 arc(16.63,161.3) 16.62,161.22 v2(16.62,160.69) ; U194.C1 152.38,121.69 arc(152.4,121.77) 152.44,121.83 v11(152.57,121.96) 152.58,121.95 153.1,121.95 arc(153.18,121.93) 153.24,121.89 153.43,121.7 arc(153.5,121.65) 153.58,121.64 U195.7 ; v11(151.36,151.74) v11(150.09,151.74) ; v2(60.93,53.33) 61.29,52.98 arc(61.35,52.93) 61.43,52.92 U244.9 ; U171.C1 190.05,169.85 arc(190.13,169.83) 190.19,169.79 190.24,169.74 arc(190.29,169.67) 190.3,169.59 190.3,169.13 arc(190.29,169.05) 190.24,168.99 190.06,168.8 arc(190.01,168.73) 190,168.66 U172.7 ; U216.2 v2(174.14,92.23) ; J54.1 v11(32.74,85.51) ; J54.37 v11(32.74,94.51) ; U214.C1 64.3,94.88 arc(64.32,94.95) 64.36,95.02 64.42,95.07 arc(64.48,95.12) 64.56,95.13 65.02,95.13 arc(65.1,95.12) 65.16,95.07 65.35,94.89 arc(65.42,94.84) 65.5,94.83 U215.7 ; C569.2 71.49,173.68 arc(71.41,173.66) 71.35,173.62 v2(71.21,173.49) ; U223.C1 233.55,79.97 arc(233.54,79.89) 233.49,79.82 233.44,79.77 arc(233.38,79.73) 233.3,79.71 232.96,79.71 arc(232.88,79.73) 232.82,79.77 232.64,79.94 arc(232.58,79.99) 232.5,80 U224.7 ; U204.C1 65.07,111.19 arc(64.99,111.2) 64.92,111.25 64.87,111.3 arc(64.82,111.37) 64.81,111.45 64.81,111.91 arc(64.82,111.98) 64.87,112.05 65.06,112.24 arc(65.1,112.3) 65.12,112.38 U203.7 ; U225.C1 64.3,79.73 arc(64.32,79.81) 64.36,79.88 64.42,79.93 arc(64.48,79.97) 64.56,79.99 65.02,79.99 arc(65.1,79.97) 65.16,79.93 65.35,79.74 arc(65.42,79.7) 65.5,79.68 U226.7 ; J54.51 v11(32.74,98.01) ; R816.2 203.64,155.98 arc(203.62,156.06) 203.58,156.12 v2(203.31,156.4) ; U209.7 193.55,98.43 arc(193.56,98.5) 193.61,98.57 193.8,98.76 arc(193.84,98.82) 193.86,98.9 193.86,99.36 arc(193.84,99.44) 193.8,99.5 193.74,99.56 arc(193.68,99.6) 193.6,99.62 U210.C1 ; U193.7 88.15,123.1 arc(88.08,123.11) 88.01,123.16 87.82,123.34 arc(87.76,123.39) 87.68,123.4 87.22,123.4 arc(87.14,123.39) 87.07,123.34 87.02,123.29 arc(86.98,123.22) 86.96,123.15 U192.C1 ; U248.8 v11(55.36,48.17) ; U230.C1 64.3,75.15 arc(64.31,75.23) 64.36,75.29 64.41,75.35 arc(64.48,75.39) 64.56,75.41 65.01,75.41 arc(65.09,75.39) 65.16,75.35 65.35,75.16 arc(65.41,75.12) 65.49,75.1 U229.7 ; J54.3 v11(32.74,86.01) ; J54.38 v11(41.47,94.51) ; U218.1 62.71,88.28 arc(62.78,88.26) 62.85,88.22 v11(63.09,87.98) 63.18,87.89 arc(63.24,87.85) 63.32,87.83 64.03,87.83 arc(64.11,87.85) 64.18,87.89 64.24,87.96 arc(64.29,88.03) 64.3,88.1 U219.C3 ; U187.26 v11(100.67,128.81)
  BOTTOM w0.254: U251.2 v2(23.95,43.79) ; C563.2 v2(65.91,174.45) ; J54.96 v2(38.4,114.01) ; v2(88.35,14.69) 88.9,14.14 arc(88.95,14.06) 88.97,13.96 C1247.1 ; U269.7 v2(236.2,23.48) ; U264.2 215.25,22.59 215.13,22.71 v2(214.62,22.71) ; U220.3 27.38,85.83 v2(27.82,86.27) ; v11(67.93,65.12) 67.89,65.12 67.62,64.84 arc(67.53,64.79) 67.44,64.77 U236.7 ; C1235.2 v2(197.71,15.07) ; v2(213.67,14.66) 213.92,14.41 arc(213.98,14.33) 214,14.23 C1244.1 ; v2(37.11,49.55) v2(37.11,51.45) v2(37.11,53.39) v2(37.11,55.32) v2(37.11,57.22) ; R1088.1 v2(22.08,67.85) ; C1254.2 v2(223.71,9.76) ; v2(67.93,69.94) 67.89,69.94 67.62,69.66 arc(67.53,69.61) 67.44,69.59 U232.7 ; R895.2 139.01,124.34 v2(139.02,124.33) ; v2(122.72,73.03) 122.49,73.26 U50163.2 ; C1255.2 v2(200.42,8.37) ; R1244.2 v2(86.74,23.99) ; C1185.1 160.79,28.5 v2(160.79,27.63) ; U50183.2 120.1,73.25 v2(120.32,73.03) ; R758.2 96.93,178.55 v2(96.88,178.59) 96.93,178.64 v11(96.93,179.23) ; v2(57.68,67.5) 57.42,67.23 arc(57.34,67.17) 57.24,67.16 C1056.2 ; v2(37.11,94.92) v2(37.11,92.76) v2(37.11,90.6) ; C846.2 145.62,87.55 arc(145.72,87.57) 145.8,87.63 v2(145.93,87.75) ; U273.8 215.6,20.41 arc(215.51,20.43) 215.42,20.48 v2(215.22,20.68) ; v2(15.43,146.1) J50.25 ; U50188.2 v2(122.72,74.63) U50188.4 ; v2(124.64,178.59) 124.64,178.59 R759.1 ; U187.52 113.98,130.31 v11(114.1,130.43) ; v2(37.11,106.6) v2(37.11,104.7) v2(37.11,102.76) v2(37.11,100.83) v2(37.11,98.93) ; v2(200.55,69.2) 200.19,69.56 arc(200.11,69.61) 200.01,69.63 R1079.1 ; v2(90.59,123.45) 90.55,123.45 90.27,123.17 arc(90.19,123.12) 90.09,123.1 U193.7 ; v2(190.86,58.71) 190.75,58.82 U242.11 ; U172.7 190,166.72 arc(190.02,166.62) 190.07,166.54 190.35,166.26 v11(190.35,166.22) ; v2(66.41,165.41) 66.22,165.23 arc(66.17,165.14) 66.15,165.05 C591.2 ; U227.8 v2(30.57,81.69) ; v2(214.55,16.63) 215.06,16.63 215.18,16.51 U273.2 ; U173.25 155.91,170.64 155.63,170.93 arc(155.55,170.98) 155.45,171 v2(155.26,171) R773.2 ; U195.7 155.52,121.64 arc(155.61,121.66) 155.7,121.71 155.97,121.99 v11(156.01,121.99) ; v2(15.47,151.11) 15.47,150.93 15.21,150.67 arc(15.13,150.62) 15.04,150.6 J50.34 ; C817.2 156.09,92.11 arc(155.99,92.09) 155.91,92.03 v2(155.53,91.66) ; v11(67.92,75.45) 67.89,75.45 67.61,75.17 arc(67.53,75.12) 67.43,75.1 U229.7 ; v2(183.7,32.42) 183.57,32.28 U259.2 ; v2(29.47,142.58) 29.09,142.2 arc(29.04,142.12) 29.02,142.02 C654.2 ; C1011.2 134.45,90.11 v2(134.74,90.4) 134.73,90.4 134.73,90.4 ; v2(57.71,66.27) 57.55,66.1 C1064.2 ; U215.7 67.44,94.83 arc(67.53,94.85) 67.62,94.9 67.89,95.18 v2(67.93,95.18) ; J57.24 v2(206.69,34.91) ; C1209.2 117.34,23.57 arc(117.25,23.59) 117.16,23.65 v2(116.82,23.99) ; J56.77 v2(32.66,60.13) ; v2(125.92,73.03) 125.69,73.26 U50187.2 ; U259.8 v2(187.47,29.28) ; C573.2 v2(63.15,172.65) ; v11(153.04,128.17) 153.04,128.2 152.76,128.48 arc(152.71,128.56) 152.69,128.66 U184.7 ; v2(60.75,92.99) 60.75,93.15 60.93,93.33 U215.1 62.69,93.33 arc(62.78,93.31) 62.87,93.25 63,93.12 arc(63.08,93.07) 63.18,93.05 63.84,93.05 ; C327.2 117.86,40.41 v2(117.85,40.4) ; v2(122.72,85.03) 122.18,84.5 FL137.4 FL137.2 ; C571.2 181.72,173.8 v2(181.71,173.81) ; C792.2 149.99,97.07 v2(149.93,97.01) ; C572.2 v2(105.29,172.37) U169.6 ; v2(129.12,76.23) 128.89,76.46 U50184.2 ; U50186.2 128.53,75.22 v2(128.32,75.43) ; v2(44.19,59.72) v2(45.11,59.72) ; v2(37.11,120.83) v2(37.11,116.95) J54.127 v2(37.11,114.92) v2(37.11,112.76) v2(37.11,110.6) J54.126 ; J57.16 v2(209.69,34.91) ; v2(125.12,73.83) 125.33,73.62 U50187.4 ; U277.2 v2(216.39,7.63) ; U221.7 67.44,84.73 arc(67.53,84.75) 67.62,84.81 67.89,85.08 v2(67.93,85.08) ; U253.3 v2(50.53,39.05) ; U264.9 v2(220.91,26.49) ; R543.2 v4(129.6,34.79) ; U186.6 v2(88.73,130.77) C686.2 ; C1196.2 v2(86.88,26.19) U260.6 ; J54.67 v2(35.81,107.01) ; U158.10 180.58,183.68 arc(180.49,183.66) 180.4,183.6 v2(180.25,183.45) ; U50183.4 119.74,73.61 v2(119.52,73.83) ; C1252.2 v2(200.42,10.98) ; v2(60.75,78.68) U226.2 ; U197.4 v2(24.73,121.15) ; U273.15 221.23,16.51 arc(221.13,16.53) 221.05,16.58 v2(220.84,16.8) 221.12,17.08 arc(221.21,17.14) 221.3,17.16 U273.14 ; v2(32.65,67.13) J56.105 ; J57.SH4 v2(201.3,33.66) v2(207.39,33.66) J57.SH2 v2(213.87,33.66) J57.SH1 ; U176.3 v2(31.2,169.24) ; v2(37.11,41.23) v2(37.11,43.39) v2(37.11,45.55) ; v2(69.41,174.45) C562.2 ; U233.13 50.55,67.34 v2(50.66,67.22) ; v2(238.87,16.7) 238.72,16.85 arc(238.66,16.93) 238.64,17.03 U274.3 ; v2(37.11,88.57) v2(37.11,84.7) ; v2(172.45,124.8) 172.45,124.59 C705.2 ; R757.2 122.8,178.55 v2(122.76,178.59) 122.8,178.64 R754.2 ; R533.2 122.68,36.4 ; 122.68,36.4 122.68,36.43 ; 122.68,36.4 v2(122.68,35.42) ; J56.68 v11(41.46,57.63) ; v2(212.45,137.29) 212.26,137.1 arc(212.21,137.02) 212.19,136.92 C666.2 ; J55.16 v2(212.68,88.6) ; R1228.1 216.85,27.6 arc(216.83,27.51) 216.77,27.42 v2(216.56,27.21) U264.8 ; U228.2 19.29,77.72 arc(19.31,77.82) 19.37,77.9 v2(19.52,78.06) 19.72,77.87 arc(19.77,77.78) 19.79,77.69 U228.3 ; v2(63.28,14.66) 63.83,14.12 arc(63.88,14.03) 63.9,13.94 C1248.1 ; v2(206.78,136.66) 206.78,136.66 R849.2 ; C793.2 151.87,97.13 v2(151.93,97.07) ; J50.16 v2(13.14,141.6) ; C804.2 177.35,94.93 177.53,94.75 v2(177.94,94.75) 178.49,95.3 C803.2 178.66,95.33 arc(178.76,95.31) 178.84,95.26 v2(179.04,95.06) 179.24,95.26 arc(179.32,95.31) 179.42,95.33 C802.2 ; C1131.1 v2(53.74,44.71) ; C808.2 v2(172.94,93.83) C807.2 ; v2(124.32,73.03) 124.09,73.26 U50169.2 ; U50186.4 128.89,74.86 v2(129.12,74.63) ; J56.79 32.99,60.63 arc(32.89,60.65) 32.81,60.71 v2(32.65,60.87) 32.84,61.06 arc(32.92,61.11) 33.02,61.13 J56.81 ; C1066.2 156.1,70.78 arc(156,70.76) 155.92,70.71 v2(155.53,70.32) ; 178.98,23.64 v2(178.41,23.64) ; v2(7.82,120.94) 7.82,121.39 arc(7.84,121.49) 7.89,121.57 J53.13 8.76,121.57 arc(8.81,121.49) 8.83,121.39 v2(8.83,120.94) ; v2(192.55,103.17) U209.2 ; v2(32.65,70.63) J56.119 ; v2(183.93,23.65) 184.15,23.87 arc(184.2,23.95) 184.22,24.05 U259.14 ; U228.6 21.52,76.16 arc(21.61,76.14) 21.7,76.08 v2(21.83,75.95) 21.61,75.73 arc(21.53,75.68) 21.43,75.66 U228.7 ; v2(138.55,175.46) v2(137.66,175.46) ; J54.120 v2(38.39,120.01) ; U276.2 v2(193.79,8.11) ; U179.2 205.61,151.61 arc(205.51,151.63) 205.43,151.69 v2(205.24,151.87) ; R769.2 v2(105.43,174.58) ; U264.15 223.01,22.59 arc(223.11,22.61) 223.19,22.66 223.62,23.09 ; R917.2 62.66,120.27 arc(62.68,120.36) 62.73,120.45 v2(62.92,120.63) ; v2(94.74,172.96) 94.86,172.83 C1267.2 ; v2(64.76,114.81) 64.76,114.78 65.04,114.5 arc(65.1,114.42) 65.12,114.32 U203.7 ; C567.2 62.42,174.51 v2(62.45,174.54) ; C847.2 123.52,89.47 v2(123.52,89.03) 123.36,88.88 C867.2 ; v2(149.93,75.67) 149.99,75.74 C1083.2 ; U168.3 98.1,175.71 arc(98.12,175.61) 98.18,175.53 98.39,175.31 v2(98.59,175.31) ; v2(43.83,61.12) v2(44.74,61.12) ; U233.12 50.55,65.84 v2(50.66,65.95) ; U170.10 19.66,163.61 v2(19.49,163.79) ; 117.94,82.38 117.94,81.92 arc(117.96,81.82) 118.01,81.74 118.22,81.53 FL154.4 FL154.2 ; 117.94,82.38 117.94,82.61 v2(117.92,82.63) U50125.4 ; 117.94,82.38 U50125.2 ; J56.39 v2(32.66,45.63) ; U226.7 67.44,79.68 arc(67.53,79.7) 67.62,79.76 67.89,80.04 v2(67.93,80.04) ; C322.2 125.61,40.41 v4(125.6,40.4) ; v2(41.55,105.09) 41.77,105.09 R941.2 ; U50169.4 123.73,73.62 v2(123.52,73.83) ; v2(26.75,169.89) 26.38,169.89 arc(26.28,169.87) 26.2,169.81 26.12,169.73 arc(26.04,169.68) 25.94,169.66 U170.114 ; v2(191.35,81.39) 191.35,81.57 191.8,82.02 arc(191.88,82.08) 191.98,82.1 C800.2 192.27,82.1 192.55,82.37 arc(192.63,82.43) 192.73,82.45 U212.7 ; C592.2 65.01,165.23 64.83,165.41 v2(64.41,165.41) 64.41,165.41 63.99,165.41 63.86,165.29 C593.2 ; C1084.2 151.87,75.8 v2(151.93,75.74) ; v11(148.83,120.64) U195.2 ; J54.119 v2(35.83,120.01) ; v2(126.72,73.83) 126.72,73.83 U50189.4 ; v2(136.18,124.33) 136.19,124.34 R896.2 ; v2(193.9,95.99) 193.9,96.03 193.62,96.31 arc(193.57,96.39) 193.55,96.49 U209.7 ; U273.9 v2(223.42,20.41) ; v2(15.4,154.08) 15.4,153.75 15.24,153.6 J50.40 ; U233.11 v2(50.24,63.96) ; v2(188.42,17.6) 188.89,17.6 189.01,17.48 U270.2 ; 116.79,115.03 v2(116.65,115.17) ; U275.5 v2(206.19,6.97) ; U255.2 v2(160.59,32.12) ; C816.2 v2(201.22,92.57) ; J54.82 v2(38.4,110.51) ; FL141.2 FL141.4 123.78,84.5 v2(124.32,85.03) ; FL122.2 FL122.4 ; R1132.1 v2(57.95,57.2) ; C1256.2 v2(223.02,7.86) ; C1246.2 v2(216.64,14.67) ; v2(30.79,25.2) 31.02,24.97 arc(31.08,24.89) 31.1,24.79 C1211.2 ; C564.2 64.75,174.9 arc(64.73,174.8) 64.68,174.72 v2(64.41,174.45) ; U182.6 v2(209.12,143.98) ; C1268.2 v2(131.4,27) ; U218.7 67.44,89.78 arc(67.53,89.8) 67.62,89.85 67.89,90.13 v2(67.93,90.13) ; C588.2 130.1,165.56 arc(130.12,165.65) 130.18,165.74 v2(130.38,165.94) 130.18,166.14 arc(130.12,166.22) 130.1,166.32 U174.6 ; v2(224.18,23.09) 223.62,23.09 ; 223.62,23.09 223.48,23.24 U264.14 ; C789.2 171.58,98.05 v2(171.43,98.05) ; U270.7 191.29,20.73 arc(191.39,20.75) 191.47,20.81 v2(191.71,21.05) 191.46,21.31 arc(191.38,21.36) 191.28,21.38 U270.8 ; v2(187.26,26.14) 187.4,26.01 arc(187.45,25.92) 187.47,25.83 U259.9 ; U189.7 62.47,124.61 arc(62.57,124.63) 62.65,124.69 62.93,124.97 v11(62.96,124.97) ; v2(145.83,74.32) C1074.2 ; C590.2 v2(67.91,165.41) ; J55.24 v2(209.68,88.6) ; C1117.2 v2(53.88,49.38) ; J56.120 41.19,70.63 arc(41.29,70.65) 41.37,70.71 v11(41.74,71.08) ; R790.2 v2(152.1,165.66) ; J54.68 v2(38.4,107.01) ; v2(63.38,48.44) 63.3,48.44 63.1,48.24 arc(63.02,48.19) 62.92,48.17 U248.9 ; U266.6 v2(61.58,20.27) C1220.2 ; U181.7 v2(23.15,146.46) ; J54.107 v2(35.83,117.01) ; U239.7 238.3,66.98 arc(238.28,67.08) 238.23,67.16 237.95,67.44 v2(237.95,67.47) ; R845.2 v2(206.09,139.99) ; v2(9.33,154.86) 10.3,154.86 arc(10.4,154.88) 10.48,154.94 J50.42 10.48,156.06 arc(10.4,156.11) 10.3,156.13 v2(9.33,156.13) ; v2(121.92,73.83) 122.13,73.62 U50163.4 ; U257.3 61.98,28.88 arc(61.88,28.86) 61.8,28.81 v2(61.58,28.58) ; U206.8 21.4,106.13 arc(21.3,106.15) 21.22,106.2 v2(20.99,106.43) ; v2(198.74,96.25) 198.74,96.28 198.46,96.56 arc(198.4,96.64) 198.38,96.74 U208.7 ; v11(110.65,120.17) 110.81,120.01 v11(111.8,120.01) ; R760.1 98.73,178.56 v2(98.76,178.59) ; U252.2 v2(13.46,43.79) ; v2(37.11,39.2) v2(37.11,35.32) ; U50172.4 112.1,83.21 v2(112.32,83.43) 112.48,83.59 U50171.2 ; v2(58.3,118.51) 58.17,118.51 R920.2 ; U202.4 v2(24.07,111.91) ; v2(124.44,175.31) 124.31,175.45 arc(124.26,175.53) 124.24,175.63 U167.3 ; J53.12 v2(11.93,120.94) ; U200.4 v2(25.85,115.6) ; J54.95 v2(35.81,114.01) ; U270.14 195.16,18.13 arc(195.06,18.11) 194.98,18.06 v2(194.75,17.82) 195.01,17.56 arc(195.09,17.5) 195.19,17.48 U270.15 ; R1189.1 23.27,35.5 v2(23.87,36.1) ; C1175.1 v2(165.85,31.45) ; U249.2 v2(26.06,42.64) ; U224.7 230.5,80 arc(230.41,79.98) 230.32,79.93 229.98,79.59 v2(229.93,79.59) ; C594.2 v2(70.91,165.41) ; U278.3 127.68,24.6 arc(127.58,24.58) 127.5,24.53 v2(127.17,24.2) ; C809.2 v2(209.28,94.11) ; v2(42.96,65.62) C1063.2 v2(42.96,66.64) ; U254.3 v2(83.13,40.47) ; v2(37.11,71.45) v2(37.11,67.58) J56.127 v2(37.11,65.55) v2(37.11,63.39) v2(37.11,61.23) J56.126 ; v2(163.86,29.4) 163.71,29.24 arc(163.63,29.19) 163.53,29.17 U258.2 ; U50185.4 U50185.2 ; v2(9.33,131.56) 10.3,131.56 arc(10.4,131.58) 10.48,131.64 J50.41 10.48,132.76 arc(10.4,132.81) 10.3,132.83 v2(9.33,132.83) ; J54.81 v2(35.81,110.51) ; U191.4 v2(26.09,122.6) ; J50.7 v2(15.42,137.1) ; R1087.1 v2(24.79,67.85) ; J57.12 v2(211.19,34.91) ; J55.12 v2(214.18,88.6) ; U256.4 v2(141.21,34.58) ; C1251.2 v2(197.75,11.18) ; v2(12,159.81) C599.2 ; J56.67 v2(32.66,57.63) ; C701.1 90,126.81 arc(89.98,126.71) 89.93,126.63 v2(89.57,126.27) ; U196.3 v2(46.13,120.9) ; U50184.4 128.53,76.82 v2(128.32,77.03) ; U175.3 v2(34.83,169.24) ; v2(190.79,40.62) 190.97,40.62 191.39,41.05 arc(191.44,41.13) 191.46,41.23 U250.4 ; J56.40 v2(41.55,45.63) ; U268.8 v2(225.65,15.53) ; U190.3 v2(46.13,124.53) ; v2(189,173.4) U172.2 ; J54.108 v2(38.4,117.01)
  BOTTOM w0.305: R540.2 v2(122.68,35.42) ; C1044.2 145.73,66.21 v2(145.93,66.42) ; C1120.2 v4(71.94,50.5) ; v2(112.71,100.54) 112.84,100.42 C826.2 ; v2(173.4,65.51) v2(173.4,66.28) ; v2(178.76,65.51) v2(178.76,66.28) ; C786.2 178.92,99.07 C785.2 ; v2(144.31,68.75) C1051.2 ; U50140.4 120.37,88.18 v2(120.32,88.23) ; C1135.2 v4(72.83,44.84) ; C769.2 v2(179.04,101.09) ; C917.1 v4(186.62,80.55) C941.1 ; v2(37.11,98.93) v2(37.11,96.95) J54.123 ; 178.41,184.9 v2(178.44,184.9)
  BOTTOM w0.381: C1243.1 v2(187.9,14.76) ; v2(33.43,18.52) 33.43,17.77 arc(33.32,17.5) 33.05,17.39 C1230.2 ; C1245.2 v2(190.54,14.69) ; C601.2 v2(139.29,158.67) ; v2(218.49,87.34) v2(216.58,87.34) v2(213.6,87.34) v2(210.42,87.34) v2(207.25,87.34) v2(204.26,87.34) J55.SH4 ; C1237.2 v2(22.98,15.22) ; C632.2 v2(149.94,148.14) ; v2(25.02,116.54) C721.2 v2(25.02,115.06) ; U267.4 v2(28.49,22.21) ; J53.6 v2(23.55,118)
  vias: v1(7.47,146.86) v1(7.47,146.1) v1(9.85,163.57) v1(11.25,177.13) v1(11.73,153.51) v1(12.84,177.95) v1(14.1,178.14) v1(18.39,169.52) v1(18.82,178.41) v1(18.89,147.65) v1(19.04,184.35) v1(19.04,169.52) v1(19.69,169.52) v1(20.09,178.41) v1(21.36,178.42) v1(33.77,76.41) v1(41.08,76.51) v1(54.2,40.8) v1(56.81,178.8) v1(59.26,54.63) v1(59.26,53.36) v1(59.26,52.09) v1(59.26,50.82) v1(59.26,49.55) v1(59.26,48.28) v1(59.26,47.01) v1(59.26,45.74) v1(61.35,58.28) v1(63.35,94.03) v1(63.35,93.09) v1(65.12,129.85) v1(66.06,50.96) v1(66.17,66.91) v1(67.88,91.74) v1(67.99,184.71) v1(68.74,158.91) v1(69.58,184.82) v1(69.58,180.82) v1(71.23,184.51) v1(71.18,180.11) v1(71.6,39.83) v1(71.69,158.91) v1(72.18,177.96) v1(72.58,184.51) v1(72.89,176.23) v1(73.5,162.07) v1(74.08,184.51) v1(74.62,176.28) v1(75.58,184.51) v1(75.75,63.68) v1(77.88,161.86) v1(77.91,66.93) v1(79.36,66.33) v1(82.23,82.74) v1(83.4,80.79) v1(84.51,152.34) v1(84.51,151.71) v1(84.51,151.07) v1(84.66,81.32) v1(85.35,76.92) v1(85.49,156.75) v1(86.24,168.35) v1(87.05,150.24) v1(87.18,155.44) v1(87.44,161.7) v1(87.61,159.16) v1(87.61,158.02) v1(87.61,156.88) v1(88.07,161.7) v1(88.2,168.35) v1(88.32,155.44) v1(88.32,150.24) v1(88.71,161.7) v1(89.16,169.75) v1(89.29,91.31) v1(89.29,90.55) v1(90.12,154.79) v1(90.12,152.19) v1(90.05,91.31) v1(90.05,90.55) v1(91.12,169.75) v1(91.07,90.53) v1(91.55,158.86) v1(92.11,168.1) v1(92.82,91.47) v1(92.85,90.4) v1(93.58,91.47) v1(93.61,90.4) v1(94.07,168.1) v1(94.34,91.47) v1(94.37,90.4) v1(94.5,158.86) v1(95.11,169.75) v1(95.92,154.79) v1(96.12,90.42) v1(96.12,89.66) v1(96.88,90.42) v1(96.91,87.93) v1(96.95,85.55) v1(97.07,169.75) v1(97.52,112.42) v1(97.65,90.42) v1(97.65,89.66) v1(98.16,166.47) v1(98.65,154.72) v1(98.69,152.43) v1(100.12,166.47) v1(101.01,90.17) v1(101.11,124.81) v1(101.15,160.14) v1(101.15,156.71) v1(101.79,160.14) v1(101.79,156.71) v1(102.03,131.58) v1(102.03,123.8) v1(102.02,86.98) v1(102.42,160.14) v1(102.42,156.71) v1(103.52,133.3) v1(103.69,159.91) v1(103.69,156.95) v1(104.83,159.91) v1(104.83,156.95) v1(105.03,133.3) v1(105.98,159.91) v1(105.98,156.95) v1(106.88,133.3) v1(107.27,166.11) v1(107.92,93.43) v1(107.92,92.63) v1(107.92,89.43) v1(107.92,87.03) v1(107.92,84.63) v1(107.92,81.43) v1(107.92,70.23) v1(108.02,133.3) v1(108.63,159.7) v1(108.63,159.06) v1(108.63,158.43) v1(108.63,157.79) v1(108.63,157.16) v1(108.72,94.23) v1(108.72,93.43) v1(108.72,91.03) v1(108.72,87.83) v1(108.72,85.43) v1(108.72,71.03) v1(108.72,69.43) v1(109.17,133.3) v1(109.26,159.7) v1(109.26,159.06) v1(109.26,158.43) v1(109.26,157.79) v1(109.26,157.16) v1(109.52,94.23) v1(109.52,91.83) v1(109.52,89.43) v1(109.52,87.03) v1(109.52,84.63) v1(109.52,71.83) v1(109.52,70.23) v1(109.9,159.7) v1(109.9,159.06) v1(109.9,158.43) v1(109.9,157.79) v1(109.9,157.16) v1(109.85,114.95) v1(110.15,149.74) v1(110.32,92.63) v1(110.32,90.23) v1(110.32,87.83) v1(110.32,85.43) v1(110.32,71.03) v1(110.53,159.7) v1(110.53,159.06) v1(110.53,158.43) v1(110.53,157.79) v1(110.53,157.16) v1(110.59,113.44) v1(111.02,133.3) v1(111.12,93.43) v1(111.12,91.03) v1(111.12,89.43) v1(111.12,71.83) v1(111.17,159.7) v1(111.17,159.06) v1(111.17,158.43) v1(111.17,157.79) v1(111.17,157.16) v1(111.67,115.42) v1(111.67,114.63) v1(111.67,104.98) v1(111.92,94.23) v1(111.92,91.83) v1(111.92,90.23) v1(111.92,89.43) v1(112.07,164.36) v1(112.16,166.24) v1(112.43,104.98) v1(112.51,131.81) v1(112.51,129.81) v1(112.51,126.81) v1(112.51,125.63) v1(112.51,124.49) v1(112.51,123.35) v1(112.72,92.63) v1(112.72,71.83) v1(112.72,68.63) v1(112.97,133.93) v1(113.17,154.95) v1(113.17,153.81) v1(113.17,152.66) v1(113.25,151.27) v1(113.25,150.63) v1(113.25,150) v1(113.22,104.98) v1(113.52,93.43) v1(113.52,91.03) v1(113.52,90.23) v1(113.52,69.43) v1(114.04,166.24) v1(114.32,94.23) v1(114.32,91.83) v1(114.32,89.43) v1(114.32,70.23) v1(114.32,68.63) v1(114.44,160.79) v1(114.44,159.65) v1(114.44,158.51) v1(114.52,163.46) v1(114.52,162.82) v1(114.52,162.19) v1(114.49,157.31) v1(114.49,154.49) v1(115.08,167.64) v1(115.12,92.63) v1(115.12,90.23) v1(115.12,69.43) v1(115.25,17.69) v1(115.92,93.43) v1(115.92,91.03) v1(115.92,71.83) v1(115.92,70.23) v1(115.92,68.63) v1(116.72,94.23) v1(116.72,91.83) v1(116.72,69.43) v1(116.8,60) v1(116.97,167.7) v1(117.52,92.63) v1(117.52,90.23) v1(117.52,70.23) v1(118.02,165.17) v1(118.32,93.43) v1(118.32,91.03) v1(118.32,89.43) v1(119.12,94.23) v1(119.12,91.83) v1(119.9,165.17) v1(119.92,92.63) v1(119.91,90.23) v1(119.92,89.43) v1(120.72,93.43) v1(120.72,91.03) v1(120.72,70.23) v1(121.03,165.99) v1(121.52,94.23) v1(121.52,91.83) v1(122.22,123.11) v1(122.32,92.63) v1(122.32,90.23) v1(122.32,70.23) v1(122.9,165.99) v1(123.12,93.43) v1(123.12,91.03) v1(123.92,94.23) v1(123.92,91.83) v1(123.92,70.23) v1(124.07,163.49) v1(124.72,92.63) v1(124.72,90.23) v1(125.52,93.43) v1(125.52,91.03) v1(125.52,70.23) v1(125.95,163.49) v1(126.32,94.23) v1(126.32,91.83) v1(127.12,92.63) v1(127.12,89.43) v1(127.92,93.43) v1(127.92,91.03) v1(127.92,71.83) v1(128.72,94.23) v1(128.72,91.83) v1(128.72,71.03) v1(128.72,68.63) v1(129.52,92.63) v1(129.52,91.03) v1(129.52,87.03) v1(129.53,76.63) v1(129.53,69.43) v1(130.32,93.43) v1(130.32,86.23) v1(130.32,84.63) v1(130.33,75.83) v1(130.97,158.19) v1(131.12,94.23) v1(131.12,91.83) v1(131.13,73.43) v1(131.92,92.63) v1(131.93,79.03) v1(131.93,71.83) v1(132.72,93.43) v1(132.72,83.03) v1(132.73,80.63) v1(132.73,78.23) v1(132.73,74.23) v1(132.73,72.63) v1(133.52,94.23) v1(133.52,87.83) v1(133.52,83.83) v1(133.52,81.43) v1(133.53,77.43) v1(133.54,75.06) v1(133.53,71.03) v1(137.93,152) v1(137.93,149.08) v1(137.93,146.9) v1(140.52,169.66) v1(142.84,147.32) v1(145.84,148.82) v1(146.34,148.82) v1(146.34,93.92) v1(146.33,86.78) v1(146.34,85.47) v1(146.33,72.59) v1(146.33,65.44) v1(146.34,64.14) v1(146.84,148.82) v1(147.13,94.58) v1(147.13,73.24) v1(147.84,147.82) v1(148.74,94.57) v1(148.73,84.83) v1(148.73,73.24) v1(148.73,63.49) v1(149.35,179.17) v1(149.54,95.22) v1(149.53,86.78) v1(149.53,84.18) v1(149.53,73.89) v1(149.53,62.84) v1(151.94,95.22) v1(151.94,93.92) v1(151.93,92.63) v1(151.93,86.78) v1(151.93,85.48) v1(151.94,73.88) v1(151.94,72.58) v1(151.93,71.29) v1(151.93,64.14) v1(152.73,90.68) v1(152.73,69.34) v1(153.43,173.98) v1(153.53,86.78) v1(153.53,71.29) v1(153.53,65.44) v1(154.33,94.57) v1(154.33,90.68) v1(154.33,73.24) v1(154.33,69.34) v1(155.13,92.63) v1(155.13,72.59) v1(155.13,71.29) v1(156.08,46.93) v1(165.45,79.85) v1(165.45,78.84) v1(165.88,49.87) v1(168.21,46.3) v1(169.36,46.3) v1(170.37,46.3) v1(171.39,46.3) v1(173.06,48.77) v1(175.44,99.81) v1(175.73,52.06) v1(175.72,51.2) v1(175.73,50.34) v1(175.73,49.47) v1(176.44,98.81) v1(176.67,46.67) v1(180.07,46.56) v1(181.49,46.37) v1(182.02,188.91) v1(182.48,170.57) v1(198.26,82.93) v1(198.26,82.43) v1(200.1,99.89) v1(205.1,15.46) v1(211.27,96.37) v1(225.6,22.23) v2(6.5,178.72) v2(6.5,176.44) v2(6.5,173.01) v2(6.64,109.68) v2(6.64,108.21) v2(6.95,84.78) v2(7.96,109.66) v2(7.96,108.21) v2(8.99,125.38) v2(9.59,151.58) v2(9.66,115.98) v2(9.66,110.14) v2(10.47,41.34) v2(11.02,104.94) v2(11.24,180.88) v2(11.38,41.34) v2(12.35,62.09) v2(12.3,41.34) v2(12.62,180.88) v2(12.97,182.02) v2(13.35,49.18) v2(13.36,132.47) v2(13.85,40.56) v2(13.85,39.54) v2(14.28,132.47) v2(14.49,125.38) v2(14.65,155.22) v2(14.86,40.56) v2(14.86,39.54) v2(15.19,132.47) v2(15.42,166.14) v2(15.5,80.1) v2(15.85,21.72) v2(15.85,19.72) v2(16.33,74.63) v2(17.27,80.42) v2(17.43,46.36) v2(17.71,155.07) v2(17.85,62.09) v2(17.93,150.41) v2(17.97,135.13) v2(17.99,128.84) v2(17.99,127.95) v2(17.98,44.71) v2(18.13,122) v2(18.33,140.19) v2(18.37,152.46) v2(18.76,179.66) v2(18.79,79.44) v2(18.9,128.84) v2(18.9,127.95) v2(19.01,181.27) v2(19.26,123.76) v2(19.4,44.71) v2(19.81,128.84) v2(19.81,127.95) v2(20.09,100.3) v2(20.57,12.1) v2(20.57,5.75) v2(20.73,128.84) v2(20.73,127.95) v2(20.66,86.49) v2(20.7,66.17) v2(20.81,10.57) v2(20.81,7.27) v2(21.21,182.87) v2(21.36,150.41) v2(21.53,73.62) v2(21.72,179.66) v2(21.69,168.08) v2(22.33,110.6) v2(22.79,165.3) v2(23.16,11.56) v2(23.16,10.55) v2(23.16,4.96) v2(23.16,3.94) v2(23.46,24.19) v2(23.6,9.41) v2(23.6,6.1) v2(23.87,37.25) v2(24.21,33.45) v2(24.3,180.67) v2(24.4,40.56) v2(24.74,78.1) v2(24.74,75.43) v2(24.79,37.25) v2(24.79,36.1) v2(25.1,73.01) v2(25.28,142.2) v2(25.46,82.84) v2(25.65,129.43) v2(25.7,37.25) v2(25.7,36.1) v2(26.05,40.56) v2(26.06,48.1) v2(26.36,184.82) v2(26.37,177.69) v2(26.37,176.68) v2(26.37,175.66) v2(26.61,37.25) v2(26.61,36.1) v2(27.01,166.93) v2(27.02,149.89) v2(27.02,129.57) v2(27.28,100.3) v2(27.32,40.56) v2(27.38,177.69) v2(27.38,176.68) v2(27.38,175.66) v2(27.43,107.44) v2(27.53,37.25) v2(27.53,36.1) v2(27.85,70.9) v2(28.15,24.36) v2(28.38,164.16) v2(28.64,127.07) v2(28.64,126.31) v2(28.57,58.4) v2(29.02,162.12) v2(29.17,33.45) v2(29.53,189.06) v2(29.53,186.4) v2(29.61,107.05) v2(29.98,21.17) v2(30.29,149.5) v2(30.54,103.95) v2(30.58,101.58) v2(30.66,19.77) v2(30.88,42.27) v2(30.88,39.99) v2(32.01,185.49) v2(32.01,119.65) v2(32.01,118.64) v2(32.56,183.07) v2(32.57,36.89) v2(32.57,35.97) v2(32.61,21.22) v2(33.85,169.65) v2(33.85,164.16) v2(35.65,164.08) v2(35.87,36.89) v2(35.87,35.97) v2(37.11,108.57) v2(37.11,59.2) v2(37.11,47.58) v2(37.44,5.93) v2(37.52,173.8) v2(37.52,171.21) v2(38.02,15.03) v2(37.95,12.99) v2(38.02,7.7) v2(38.65,23.26) v2(39.18,28.86) v2(39.29,7.7) v2(41.52,19.5) v2(42.44,120.71) v2(42.48,28.86) v2(42.55,122.16) v2(42.76,34.85) v2(43,15.45) v2(43.21,19.82) v2(43.21,18.8) v2(43.29,84.97) v2(43.46,14.29) v2(43.46,12.76) v2(43.46,11.24) v2(43.46,9.71) v2(43.46,8.06) v2(43.67,34.85) v2(43.87,28.62) v2(44.56,114.48) v2(44.56,113.41) v2(44.56,112.34) v2(45.02,70.75) v2(45.02,69.45) v2(45.02,68.18) v2(45.11,14.29) v2(45.11,12.76) v2(45.11,11.24) v2(45.11,9.71) v2(45.11,8.06) v2(45.26,118.11) v2(45.53,41.75) v2(45.63,114.48) v2(45.63,113.41) v2(45.63,112.34) v2(45.73,123.55) v2(45.71,40.64) v2(46.45,38.71) v2(46.69,114.48) v2(46.69,113.41) v2(46.69,112.34) v2(46.82,31.63) v2(46.76,14.29) v2(46.76,12.76) v2(46.76,11.24) v2(46.76,9.71) v2(46.76,8.06) v2(48.42,14.29) v2(48.42,12.76) v2(48.42,11.24) v2(48.42,9.71) v2(48.42,8.32) v2(48.42,2.37) v2(48.45,116.71) v2(48.62,109.51) v2(48.75,19.49) v2(48.94,115.18) v2(49.13,167.27) v2(49.73,113.09) v2(50.07,14.29) v2(50.07,12.76) v2(50.07,11.24) v2(50.07,9.71) v2(50.11,2.37) v2(50.96,31.31) v2(50.96,26.53) v2(51.21,123.55) v2(51.24,19.8) v2(51.3,125.34) v2(51.35,58.72) v2(51.35,57.45) v2(51.35,56.18) v2(51.58,67.22) v2(51.58,65.95) v2(51.8,117.95) v2(51.8,116.81) v2(51.8,113.76) v2(51.8,112.62) v2(51.79,2.37) v2(52.13,119) v2(52.11,31.31) v2(52.38,19.8) v2(52.49,67.22) v2(52.49,65.95) v2(52.62,58.72) v2(52.62,57.45) v2(52.62,56.18) v2(53.4,121.98) v2(53.41,67.22) v2(53.41,65.95) v2(53.65,20.62) v2(53.89,58.72) v2(53.89,57.45) v2(53.89,56.18) v2(54.09,27.03) v2(54.09,26.02) v2(54.32,67.22) v2(54.32,65.95) v2(54.41,121.98) v2(54.42,16.82) v2(54.59,26.53) v2(54.67,20.62) v2(55.1,27.03) v2(55.1,26.02) v2(55.51,7.2) v2(55.59,71.04) v2(55.69,170.29) v2(55.8,13.9) v2(55.8,12.38) v2(56.2,181.35) v2(56.38,109.63) v2(56.38,108.62) v2(56.82,113.57) v2(56.82,112.43) v2(56.82,111.28) v2(56.8,6.65) v2(57.16,118.51) v2(57.16,117.36) v2(57.16,116.22) v2(57.28,42.21) v2(57.49,21.14) v2(57.45,17.36) v2(57.47,15.1) v2(57.82,6.65) v2(57.94,30.92) v2(57.89,25.48) v2(57.89,24.21) v2(57.89,19.01) v2(58.1,176.62) v2(58.1,175.71) v2(58.3,117.36) v2(58.3,116.22) v2(59.01,176.62) v2(59.01,175.71) v2(59.09,22.23) v2(59.09,21.11) v2(59.26,68.18) v2(59.26,66.91) v2(59.26,65.64) v2(59.26,64.37) v2(59.26,63.1) v2(59.26,61.83) v2(59.26,60.56) v2(59.26,59.29) v2(59.41,121.95) v2(59.44,118.51) v2(59.44,117.36) v2(59.44,116.22) v2(59.78,113.57) v2(59.78,112.43) v2(59.78,111.28) v2(59.91,109.63) v2(59.91,108.62) v2(60,22.23) v2(60,21.11) v2(60.08,165.34) v2(60.09,42.2) v2(60.5,25.8) v2(60.51,8.72) v2(60.92,22.23) v2(60.92,21.11) v2(60.96,164.94) v2(61.44,18.75) v2(61.43,8.72) v2(61.82,162.62) v2(62.24,121.95) v2(63.32,176.15) v2(63.86,44.3) v2(64.1,173.49) v2(64.1,171.71) v2(64.1,169.93) v2(64.1,168.15) v2(64.1,166.37) v2(64.19,118.47) v2(64.19,115.78) v2(64.27,14.69) v2(64.42,29.66) v2(64.65,49.61) v2(65.59,120.71) v2(65.71,30) v2(65.88,173.49) v2(65.88,171.71) v2(65.88,169.93) v2(65.88,168.15) v2(65.88,166.37) v2(65.89,45.22) v2(66.12,29.17) v2(66.61,120.71) v2(66.62,30) v2(66.87,41.05) v2(67.04,46.82) v2(67.66,173.49) v2(67.66,171.71) v2(67.66,169.93) v2(67.66,168.15) v2(67.66,166.37) v2(67.66,24.5) v2(67.66,21.54) v2(67.8,27.77) v2(67.8,25.71) v2(67.9,31.23) v2(69.06,31.55) v2(69.25,20.24) v2(69.44,173.49) v2(69.44,171.71) v2(69.44,169.93) v2(69.44,168.15) v2(69.44,166.37) v2(69.68,178.21) v2(69.97,31.55) v2(70.23,66.83) v2(70.3,117.13) v2(70.3,114.84) v2(70.38,104.81) v2(70.38,103.66) v2(71.21,171.71) v2(71.21,169.93) v2(71.21,168.15) v2(71.21,166.37) v2(71.88,26.85) v2(71.88,25.63) v2(71.88,24.41) v2(71.88,23.19) v2(72.35,64.31) v2(72.46,19.11) v2(73.1,25.63) v2(73.1,24.41) v2(73.1,23.19) v2(73.42,118.9) v2(73.71,78.67) v2(73.96,19.11) v2(74.32,25.63) v2(74.32,24.41) v2(74.32,23.19) v2(74.95,35) v2(74.96,33.04) v2(75.05,171.51) v2(75.08,75.85) v2(75.54,26.85) v2(75.54,23.19) v2(75.46,19.11) v2(75.82,168.18) v2(76.49,171.3) v2(76.51,169.57) v2(77.07,33.04) v2(78.82,81.27) v2(79.33,38.31) v2(79.37,40.6) v2(79.63,169.07) v2(80.06,28.91) v2(80.06,27.77) v2(80.06,22.11) v2(80.06,20.97) v2(80.17,34.8) v2(80.55,77.8) v2(81.12,29.16) v2(81.82,164.65) v2(82.01,35.34) v2(82.75,23.78) v2(82.75,22.77) v2(83.19,31.4) v2(83.19,30.13) v2(83.19,24.92) v2(83.32,126.84) v2(83.27,19.77) v2(83.84,163.57) v2(83.77,41.78) v2(84.39,28.15) v2(84.39,27.03) v2(84.72,127.08) v2(85.14,34.72) v2(85.3,28.15) v2(85.3,27.59) v2(85.3,27.03) v2(86.22,27.03) v2(86.42,166.87) v2(86.77,130.11) v2(86.77,129.19) v2(86.77,128.28) v2(87.89,130.11) v2(87.89,129.19) v2(87.89,128.28) v2(88.03,166.87) v2(88.84,43.68) v2(89.34,168.26) v2(89.34,14.71) v2(90.08,29.66) v2(90.25,130.63) v2(90.83,118.19) v2(90.95,168.26) v2(91.14,126.64) v2(91.23,29.98) v2(92.15,29.98) v2(92.16,126.64) v2(92.28,166.61) v2(92.94,35.59) v2(93.32,24.5) v2(93.32,21.54) v2(93.45,27.77) v2(93.45,25.71) v2(93.56,31.23) v2(93.71,51.05) v2(93.9,166.61) v2(94.17,68.61) v2(94.17,67.85) v2(94.71,31.55) v2(94.9,20.24) v2(95.29,168.26) v2(95.27,73.18) v2(95.63,31.55) v2(96.33,68.61) v2(96.33,67.85) v2(96.9,168.26) v2(97.53,26.85) v2(97.53,25.63) v2(97.53,24.41) v2(97.53,23.19) v2(98.33,164.98) v2(98.75,25.63) v2(98.75,24.41) v2(98.75,23.19) v2(99.88,173.04) v2(99.95,164.98) v2(99.97,25.63) v2(99.97,24.41) v2(99.97,23.19) v2(100.61,33.04) v2(101.19,26.85) v2(101.19,23.19) v2(101.31,174.84) v2(101.46,138.01) v2(102.4,137.35) v2(102.73,33.04) v2(103.72,128.06) v2(103.72,126.28) v2(104.02,71.53) v2(104.66,138.18) v2(104.81,167.48) v2(105.5,131.62) v2(105.5,129.84) v2(105.5,128.06) v2(105.5,126.28) v2(105.5,124.51) v2(105.71,27.77) v2(105.71,22.11) v2(105.71,20.97) v2(105.95,171.53) v2(105.95,170.42) v2(106.13,138.18) v2(106.37,166.82) v2(106.87,171.53) v2(106.87,170.42) v2(107.14,24.89) v2(107.27,131.62) v2(107.27,129.84) v2(107.27,128.06) v2(107.27,126.28) v2(107.27,124.51) v2(107.47,25.9) v2(107.78,171.53) v2(107.78,170.42) v2(108.11,138.1) v2(108.48,165.64) v2(108.91,19.88) v2(108.98,173.64) v2(108.98,168.43) v2(108.98,167.16) v2(109.05,131.62) v2(109.05,129.84) v2(109.05,128.06) v2(109.05,126.28) v2(109.42,175.8) v2(109.42,174.78) v2(109.66,100.54) v2(109.84,138.13) v2(110.57,105.48) v2(110.63,58.8) v2(110.83,131.62) v2(110.83,129.84) v2(110.83,128.06) v2(110.83,126.28) v2(110.83,124.51) v2(111.06,100.54) v2(111.31,165.64) v2(111.67,137.92) v2(111.72,109.85) v2(111.95,27.96) v2(111.95,20.52) v2(112.14,165.16) v2(113.09,11.41) v2(113.44,66.74) v2(113.44,65.19) v2(113.6,28.4) v2(113.6,20.96) v2(114.27,165.43) v2(114.28,66.74) v2(114.28,65.19) v2(115.1,166.44) v2(115.38,100.54) v2(115.71,31.43) v2(115.71,30.51) v2(115.71,29.6) v2(115.71,23.99) v2(115.71,23.07) v2(115.71,22.16) v2(116.1,117.74) v2(116.23,133.56) v2(116.48,18.16) v2(116.65,116.19) v2(116.65,113.75) v2(116.65,111.45) v2(116.65,109.85) v2(116.72,16.89) v2(116.82,31.43) v2(116.82,30.51) v2(116.82,29.6) v2(116.82,23.07) v2(116.82,22.16) v2(117.16,166.85) v2(117.24,117.74) v2(117.23,36.3) v2(117.79,105.48) v2(117.79,100.54) v2(117.79,99.62) v2(117.79,6.78) v2(117.89,164.21) v2(118.93,28.4) v2(118.93,20.96) v2(119.08,48.89) v2(119.44,100.54) v2(120.12,164.28) v2(120.2,28.4) v2(120.2,20.96) v2(120.39,31.01) v2(121.34,105.48) v2(121.34,100.54) v2(121.29,82.19) v2(121.29,80.62) v2(121.29,79.65) v2(121.39,164.46) v2(122.02,82.19) v2(122.49,100.54) v2(123.11,165.17) v2(123.15,41.03) v2(123.53,83.23) v2(123.53,82.43) v2(123.53,81.83) v2(123.53,81.03) v2(123.53,80.44) v2(123.53,79.64) v2(123.73,100.54) v2(123.88,162.67) v2(124.49,7.57) v2(124.9,109.61) v2(124.9,105.48) v2(125.71,36.4) v2(126.15,162.64) v2(126.62,27.67) v2(126.74,100.54) v2(127.19,170.1) v2(127.85,6.81) v2(127.87,175.47) v2(128.22,20.82) v2(128.74,97.65) v2(128.84,169.66) v2(129.6,121.83) v2(130.01,29.42) v2(130.64,97.65) v2(130.95,168.46) v2(130.95,167.55) v2(130.95,166.63) v2(131.27,133.4) v2(132.01,120.57) v2(132.06,168.46) v2(132.06,167.55) v2(132.06,166.63) v2(132.55,97.65) v2(132.9,179.89) v2(132.9,178.52) v2(133.36,6.46) v2(133.79,162.19) v2(133.82,161.07) v2(134.04,169.66) v2(134.15,30.4) v2(134.35,161.63) v2(134.6,47.61) v2(134.91,162.19) v2(134.91,161.07) v2(135,165.49) v2(135.08,45.23) v2(135.08,44.09) v2(135.31,169.66) v2(135.63,167.05) v2(136,171.58) v2(136.03,49.56) v2(136.1,25.53) v2(136.18,123.1) v2(136.43,28.25) v2(136.55,132.27) v2(136.6,34.58) v2(137.42,172.9) v2(137.65,6.81) v2(137.98,56.13) v2(139.02,123.1) v2(139.15,21.12) v2(139.15,20.48) v2(139.15,19.85) v2(139.28,183.84) v2(139.28,182.82) v2(139.3,23.68) v2(139.3,22.51) v2(139.46,34.58) v2(139.63,181.1) v2(140.54,153.17) v2(140.54,152.03) v2(140.54,149.74) v2(141.25,178.73) v2(141.15,166.96) v2(141.23,165.32) v2(141.23,163.93) v2(141.23,162.66) v2(141.84,181.03) v2(141.77,158.43) v2(142.58,57.31) v2(142.58,56.42) v2(142.71,178.7) v2(142.69,100.13) v2(142.81,99.09) v2(142.81,55.53) v2(142.81,54.77) v2(142.81,54.13) v2(142.81,53.37) v2(143.16,6.46) v2(144.31,90.2) v2(144.46,179.14) v2(144.97,75.18) v2(145.35,57.18) v2(145.35,56.42) v2(145.39,99.3) v2(145.45,81.65) v2(145.86,174.68) v2(146.15,80.25) v2(147.08,78.34) v2(147.33,174.55) v2(147.46,6.81) v2(147.55,99.3) v2(147.78,59.34) v2(148.44,80.25) v2(149.11,101.25) v2(149.11,57.06) v2(149.44,20.4) v2(149.49,78.34) v2(150.6,80.25) v2(150.88,175.18) v2(151.44,20.4) v2(151.65,78.34) v2(152.31,163.88) v2(153.03,175.62) v2(153.01,80.25) v2(152.97,6.46) v2(153.81,98.9) v2(153.94,79.28) v2(153.94,78.34) v2(153.91,58.75) v2(154.11,81.66) v2(154.06,60.32) v2(154.41,97.79) v2(154.41,76.45) v2(154.49,101.25) v2(154.49,57.06) v2(155.95,101.25) v2(155.95,56.93) v2(156.14,169.43) v2(156.14,167.9) v2(156.14,166.38) v2(156.07,58.75) v2(156.4,89.33) v2(156.37,68.04) v2(157.08,79.53) v2(157.18,179.97) v2(157.26,6.81) v2(157.41,68.19) v2(157.63,29.41) v2(157.66,169.43) v2(157.66,167.9) v2(157.66,166.38) v2(158.04,92.89) v2(158.21,76.43) v2(158.41,75.09) v2(158.41,71.91) v2(158.41,68.74) v2(158.41,65.17) v2(158.68,89.32) v2(158.68,86.14) v2(158.68,82.97) v2(158.72,44.28) v2(158.76,81.77) v2(158.91,172.55) v2(158.99,181.59) v2(159.06,189.16) v2(159.09,188.02) v2(159.18,177.72) v2(159.19,169.43) v2(159.19,167.9) v2(159.19,166.38) v2(160.97,96.09) v2(160.97,74.76) v2(161.5,175.92) v2(162.16,27.13) v2(162.65,175.92) v2(162.77,6.46) v2(163.92,175.92) v2(164.39,158.25) v2(164.79,79.85) v2(164.97,188.24) v2(165.08,119.22) v2(165.19,175.92) v2(165.85,119.22) v2(166.33,175.92) v2(166.43,30.09) v2(166.48,119.22) v2(166.66,23.74) v2(167.06,6.81) v2(167.24,119.22) v2(167.27,26.18) v2(167.7,30.09) v2(167.86,177.09) v2(167.86,175.82) v2(168.46,178.76) v2(168.46,178.1) v2(169.13,177.09) v2(169.13,175.82) v2(169.2,50.55) v2(169.2,49.28) v2(169.45,178.76) v2(169.45,178.1) v2(169.83,49.89) v2(170.15,177.09) v2(170.15,175.82) v2(170.16,124.8) v2(170.44,50.53) v2(170.44,49.26) v2(170.49,178.76) v2(170.49,178.1) v2(170.53,25.82) v2(170.71,24.52) v2(170.72,22.97) v2(170.72,22.34) v2(170.72,21.7) v2(171.16,177.09) v2(171.16,175.82) v2(171.48,178.76) v2(171.48,178.1) v2(171.48,70.25) v2(172.07,119.22) v2(172.54,178.36) v2(172.54,177.09) v2(172.58,6.46) v2(172.83,119.22) v2(173.36,185.18) v2(173.36,184.16) v2(173.36,183.15) v2(173.36,182.13) v2(173.4,87.79) v2(173.4,87.03) v2(173.47,119.22) v2(173.8,50.83) v2(174.02,185.18) v2(174.02,184.16) v2(174.02,183.15) v2(174.02,182.13) v2(174.09,159.68) v2(174.09,158.54) v2(174.09,157.4) v2(174.09,156.26) v2(174.09,152.06) v2(174.09,150.92) v2(174.09,149.78) v2(174.09,148.64) v2(174.09,10.7) v2(174.17,144.44) v2(174.17,143.3) v2(174.17,142.16) v2(174.17,141.02) v2(174.23,119.22) v2(174.24,52.03) v2(174.74,177.04) v2(174.74,176.03) v2(174.74,175.01) v2(174.74,173.99) v2(175.23,159.68) v2(175.23,158.54) v2(175.23,157.4) v2(175.23,156.26) v2(175.23,152.06) v2(175.23,150.92) v2(175.23,149.78) v2(175.23,148.64) v2(175.31,144.44) v2(175.31,143.3) v2(175.31,142.16) v2(175.31,141.02) v2(175.65,93.58) v2(175.75,177.04) v2(175.75,176.03) v2(175.75,175.01) v2(175.75,173.99) v2(176.11,23.79) v2(176.38,161.97) v2(176.38,159.68) v2(176.38,158.54) v2(176.38,157.4) v2(176.38,156.26) v2(176.38,152.06) v2(176.38,150.92) v2(176.38,149.78) v2(176.38,148.64) v2(176.45,144.44) v2(176.45,143.3) v2(176.45,142.16) v2(176.45,141.02) v2(176.45,138.73) v2(176.51,119.22) v2(176.77,177.04) v2(176.77,176.03) v2(176.77,175.01) v2(176.77,173.99) v2(176.75,19.38) v2(177.28,119.22) v2(177.52,161.97) v2(177.52,159.68) v2(177.52,158.54) v2(177.52,157.4) v2(177.52,156.26) v2(177.52,152.06) v2(177.52,150.92) v2(177.52,149.78) v2(177.52,148.64) v2(177.57,185.47) v2(177.57,184.81) v2(177.6,144.44) v2(177.6,143.3) v2(177.6,142.16) v2(177.6,141.02) v2(177.6,138.73) v2(177.69,23.48) v2(177.79,177.04) v2(177.79,176.03) v2(177.79,175.01) v2(177.79,173.99) v2(177.85,171.66) v2(177.91,119.22) v2(178.66,161.97) v2(178.66,159.68) v2(178.66,158.54) v2(178.66,157.4) v2(178.66,156.26) v2(178.66,152.06) v2(178.66,150.92) v2(178.66,149.78) v2(178.66,148.64) v2(178.74,144.44) v2(178.74,143.3) v2(178.74,142.16) v2(178.74,141.02) v2(178.74,138.73) v2(178.67,119.22) v2(178.76,87.79) v2(178.76,87.03) v2(178.82,51.29) v2(178.82,50.02) v2(179.26,77.25) v2(179.41,54.68) v2(179.46,50.63) v2(179.48,27.76) v2(180.07,51.26) v2(180.07,49.99) v2(180.63,27.8) v2(180.95,160.83) v2(180.95,159.68) v2(180.95,158.54) v2(180.95,157.4) v2(180.95,156.26) v2(181.03,144.44) v2(181.03,143.3) v2(181.03,142.16) v2(181.03,141.02) v2(181.03,139.87) v2(181.7,15.63) v2(181.83,19.43) v2(182.09,160.83) v2(182.09,159.68) v2(182.09,158.54) v2(182.09,157.4) v2(182.09,156.26) v2(182.06,97.56) v2(182.17,144.44) v2(182.17,143.3) v2(182.17,142.16) v2(182.17,141.02) v2(182.17,139.87) v2(183.24,161.97) v2(183.24,160.83) v2(183.24,159.68) v2(183.24,158.54) v2(183.24,157.4) v2(183.24,156.26) v2(183.31,144.44) v2(183.31,143.3) v2(183.31,142.16) v2(183.31,141.02) v2(183.31,139.87) v2(183.31,138.73) v2(183.39,180.92) v2(183.36,101.92) v2(183.5,119.22) v2(184.26,119.22) v2(184.38,161.97) v2(184.38,160.83) v2(184.38,159.68) v2(184.38,158.54) v2(184.38,157.4) v2(184.38,156.26) v2(184.45,144.44) v2(184.45,143.3) v2(184.45,142.16) v2(184.45,141.02) v2(184.45,139.87) v2(184.45,138.73) v2(184.9,119.22) v2(185.52,161.97) v2(185.52,160.83) v2(185.52,159.68) v2(185.52,158.54) v2(185.52,157.4) v2(185.52,156.26) v2(185.6,144.44) v2(185.6,143.3) v2(185.6,142.16) v2(185.6,141.02) v2(185.6,139.87) v2(185.6,138.73) v2(185.66,119.22) v2(185.89,10.76) v2(185.87,7.8) v2(186.66,161.97) v2(186.66,160.83) v2(186.66,159.68) v2(186.66,158.54) v2(186.66,157.4) v2(186.66,156.26) v2(187.69,119.22) v2(187.9,10.76) v2(188.42,20.92) v2(188.45,119.22) v2(188.63,151.34) v2(188.63,150.32) v2(189.04,10.8) v2(189.09,119.22) v2(189.54,152.36) v2(189.54,151.34) v2(189.54,150.32) v2(189.54,149.31) v2(189.54,27.58) v2(189.85,119.22) v2(190.46,152.36) v2(190.46,151.34) v2(190.46,150.32) v2(190.46,149.31) v2(190.54,10.72) v2(190.64,177.86) v2(190.65,185.5) v2(190.86,57.44) v2(191.37,152.36) v2(191.37,151.34) v2(191.37,150.32) v2(191.37,149.31) v2(191.63,8.55) v2(191.73,58.71) v2(191.73,57.44) v2(192.04,10.72) v2(192.29,151.34) v2(192.29,150.32) v2(192.29,149.31) v2(192.29,66.68) v2(192.29,65.56) v2(192.54,8.55) v2(192.59,58.71) v2(192.59,57.44) v2(192.85,66.12) v2(192.85,62.49) v2(193.2,151.34) v2(193.2,150.32) v2(193.2,149.31) v2(193.19,10.72) v2(193.4,66.68) v2(193.4,65.56) v2(193.41,53.55) v2(193.45,58.71) v2(193.45,57.44) v2(194.12,151.34) v2(194.12,150.32) v2(194.12,149.31) v2(194.12,148.29) v2(194.67,119.22) v2(195.03,151.34) v2(195.03,150.32) v2(195.03,149.31) v2(195.03,148.29) v2(195.04,62.19) v2(195.44,119.22) v2(196.07,119.22) v2(196.66,56.78) v2(196.83,119.22) v2(197.71,17.59) v2(198.51,151.83) v2(198.51,148.87) v2(198.65,64.32) v2(198.67,41.35) v2(198.67,40.43) v2(198.67,39.59) v2(198.91,38.89) v2(200.19,27.92) v2(200.96,95.03) v2(200.96,94.11) v2(201.69,27.9) v2(201.77,56.75) v2(202.19,151.87) v2(202.19,150.86) v2(202.19,149.84) v2(202.19,148.83) v2(203.21,151.87) v2(203.21,150.86) v2(203.21,149.84) v2(203.21,148.83) v2(203.21,117.29) v2(203.21,116.15) v2(203.21,115.01) v2(203.21,113.86) v2(203.21,112.72) v2(203.19,27.9) v2(203.3,6.35) v2(203.49,61.53) v2(203.79,126.2) v2(204.22,151.87) v2(204.22,150.86) v2(204.22,149.84) v2(204.22,148.83) v2(204.43,50.82) v2(204.48,117.29) v2(204.48,116.15) v2(204.48,115.01) v2(204.48,113.86) v2(204.48,112.72) v2(204.63,39.04) v2(204.69,27.9) v2(205.24,150.86) v2(205.51,53.14) v2(205.53,42.26) v2(205.53,41.35) v2(205.62,58.83) v2(205.62,57.69) v2(205.62,56.55) v2(205.75,117.29) v2(205.75,116.15) v2(205.75,115.01) v2(205.75,113.86) v2(205.75,112.72) v2(206.08,25.88) v2(206.19,39.73) v2(206.19,39.16) v2(206.19,27.9) v2(206.76,58.83) v2(206.76,57.69) v2(206.76,56.55) v2(207.02,117.29) v2(207.02,116.15) v2(207.02,115.01) v2(207.02,113.86) v2(207.02,112.72) v2(207.01,53.14) v2(207.12,144.84) v2(207.45,142.85) v2(207.54,25.58) v2(207.91,58.83) v2(207.91,57.69) v2(207.91,56.55) v2(207.93,19.43) v2(207.93,15.43) v2(208.21,135.38) v2(208.29,117.29) v2(208.29,116.15) v2(208.29,115.01) v2(208.29,113.86) v2(208.29,112.72) v2(208.39,105.7) v2(208.39,104.79) v2(208.39,103.87) v2(208.75,79.2) v2(208.83,92.57) v2(209.14,151.49) v2(209.18,150.38) v2(209.18,148.6) v2(209.2,26.72) v2(209.25,105.7) v2(209.25,104.79) v2(209.25,103.87) v2(209.28,95.03) v2(209.48,153.65) v2(209.56,117.29) v2(209.56,116.15) v2(209.56,115.01) v2(209.56,113.86) v2(209.56,112.72) v2(210.33,56.66) v2(210.44,11.77) v2(210.42,8.81) v2(210.52,77.42) v2(210.6,78.64) v2(210.67,106.54) v2(210.67,104.54) v2(210.83,117.29) v2(210.83,116.15) v2(210.83,115.01) v2(210.83,113.86) v2(210.83,112.72) v2(210.93,25.4) v2(212.1,117.29) v2(212.1,116.15) v2(212.1,115.01) v2(212.1,113.86) v2(212.1,112.72) v2(212.2,81.84) v2(212.2,29.29) v2(212.63,78.26) v2(212.65,19.77) v2(213.37,117.29) v2(213.37,116.15) v2(213.37,115.01) v2(213.37,113.86) v2(213.37,112.72) v2(213.62,80.37) v2(213.72,27.99) v2(213.69,26.23) v2(214,10.76) v2(214.23,8.07) v2(214.53,106.31) v2(214.53,104.28) v2(214.53,103.26) v2(214.64,117.29) v2(214.64,116.15) v2(214.64,115.01) v2(214.64,113.86) v2(214.64,112.72) v2(215.14,10.8) v2(215.15,8.07) v2(215.32,81.53) v2(215.27,80.16) v2(215.55,106.31) v2(215.55,105.3) v2(215.55,104.28) v2(215.55,103.26) v2(215.91,117.29) v2(215.91,116.15) v2(215.91,115.01) v2(215.91,113.86) v2(215.91,112.72) v2(216.09,65.41) v2(216.09,64.4) v2(216.44,81.56) v2(216.39,29.45) v2(216.57,106.31) v2(216.57,105.3) v2(216.57,104.28) v2(216.57,103.26) v2(216.64,10.72) v2(217.1,72.52) v2(217.1,71.51) v2(217.1,70.49) v2(217.1,69.48) v2(217.1,68.46) v2(217.1,67.44) v2(217.1,66.43) v2(217.1,65.41) v2(217.1,64.4) v2(217.13,31.76) v2(217.18,117.29) v2(217.18,116.15) v2(217.18,115.01) v2(217.18,113.86) v2(217.18,112.72) v2(217.58,106.31) v2(217.58,105.3) v2(217.58,104.28) v2(217.58,103.26) v2(217.76,31.76) v2(218.12,72.52) v2(218.12,71.51) v2(218.12,70.49) v2(218.12,69.48) v2(218.12,68.46) v2(218.12,67.44) v2(218.12,66.43) v2(218.12,65.41) v2(218.12,64.4) v2(218.14,27.58) v2(218.14,10.72) v2(219.13,72.52) v2(219.13,71.51) v2(219.13,70.49) v2(219.13,69.48) v2(219.13,68.46) v2(219.13,67.44) v2(219.13,66.43) v2(219.13,65.41) v2(219.28,10.72) v2(219.89,28.28) v2(220.36,9.96) v2(220.53,74.84) v2(220.53,73.57) v2(220.79,82.07) v2(220.79,80.63) v2(220.79,79.71) v2(221.12,47.38) v2(221.12,41.45) v2(221.26,106.26) v2(221.26,103.31) v2(221.5,82.07) v2(221.5,80.63) v2(221.5,79.71) v2(221.8,74.84) v2(221.8,73.57) v2(223.33,72.52) v2(223.33,71.51) v2(223.33,70.49) v2(223.33,69.48) v2(223.33,68.46) v2(223.33,67.44) v2(223.33,66.43) v2(223.33,65.41) v2(223.71,32.88) v2(223.8,17.59) v2(223.8,14.94) v2(224.18,21.25) v2(224.34,72.52) v2(224.34,71.51) v2(224.34,70.49) v2(224.34,69.48) v2(224.34,68.46) v2(224.34,67.44) v2(224.34,66.43) v2(224.34,65.41) v2(225.31,106.94) v2(225.31,106.03) v2(225.31,105.11) v2(225.31,104.2) v2(225.31,103.28) v2(225.31,102.37) v2(225.36,72.52) v2(225.36,71.51) v2(225.36,70.49) v2(225.58,28.73) v2(225.65,25.1) v2(225.57,20.99) v2(226.32,106.94) v2(226.32,106.03) v2(226.32,105.11) v2(226.32,104.2) v2(226.32,103.28) v2(226.32,102.37) v2(227.34,106.94) v2(227.34,106.03) v2(227.34,105.11) v2(227.34,104.2) v2(227.34,103.28) v2(227.34,102.37) v2(227.76,38.8) v2(227.76,31.07) v2(228.35,106.03) v2(228.35,105.11) v2(228.35,104.2) v2(228.35,103.28) v2(228.35,102.37) v2(229.12,25.18) v2(229.16,40.47) v2(229.83,84) v2(230.38,25.18) v2(230.69,28.89) v2(231.38,14.72) v2(232.92,26.09) v2(232.92,12.76) v2(233.76,24.6) v2(235.17,90.95) v2(235.17,89.81) v2(235.17,88.67) v2(235.17,87.52) v2(235.3,96.48) v2(235.3,95.34) v2(235.3,94.2) v2(236.09,73.18) v2(236.09,66.07) v2(236.09,58.96) v2(236.09,51.85) v2(236.09,44.74) v2(236.09,37.62) v2(236.09,30.51) v2(236.31,90.95) v2(236.31,89.81) v2(236.31,88.67) v2(236.31,87.52) v2(236.44,96.48) v2(236.44,95.34) v2(236.44,94.2) v2(237.46,90.95) v2(237.46,89.81) v2(237.46,88.67) v2(237.46,87.52) v2(237.59,96.48) v2(237.59,95.34) v2(237.59,94.2) v2(238.6,90.95) v2(238.6,89.81) v2(238.6,88.67) v2(238.6,87.52) v2(238.73,96.48) v2(238.73,95.34) v2(238.73,94.2) v2(239.74,90.95) v2(239.74,89.81) v2(239.74,88.67) v2(239.74,87.52) v2(239.87,96.48) v2(239.87,95.34) v2(239.87,94.2) v2(240.13,126.83) v2(240.13,123.02) v2(240.13,119.21) v2(241.41,82.44) v2(241.59,73.18) v2(241.59,66.07) v2(241.59,58.96) v2(241.59,51.85) v2(241.59,44.74) v2(241.59,37.62) v2(241.59,30.51) v3(19.04,184.35) v3(66.17,66.91) v3(67.99,184.71) v3(69.58,184.82) v3(69.58,180.82) v3(71.23,184.51) v3(71.18,180.11) v3(72.18,177.96) v3(72.58,184.51) v3(72.89,176.23) v3(74.08,184.51) v3(74.62,176.28) v3(75.58,184.51) v3(86.24,168.35) v3(88.2,168.35) v3(89.16,169.75) v3(91.12,169.75) v3(92.11,168.1) v3(94.07,168.1) v3(95.11,169.75) v3(97.07,169.75) v3(98.16,166.47) v3(98.24,115.79) v3(98.65,154.72) v3(99.45,99.7) v3(99.53,108.48) v3(99.47,105.77) v3(99.55,114.55) v3(100.12,166.47) v3(101.33,100.56) v3(101.3,94.49) v3(101.51,110.41) v3(101.48,104.34) v3(101.61,118.75) v3(101.58,112.67) v3(103.03,112.14) v3(102.98,100.28) v3(102.95,94.21) v3(103.06,118.21) v3(103.67,124.18) v3(107.48,86.31) v3(107.92,93.43) v3(107.92,92.63) v3(108.31,87.25) v3(108.72,94.23) v3(108.72,93.43) v3(108.72,91.03) v3(109.52,94.23) v3(109.52,91.83) v3(109.52,89.43) v3(110.14,87.43) v3(110.32,92.63) v3(110.32,90.23) v3(110.97,86.7) v3(111.02,84.9) v3(111.12,93.43) v3(111.12,91.03) v3(111.12,89.43) v3(111.67,115.42) v3(111.67,114.63) v3(111.67,104.98) v3(111.92,94.23) v3(111.92,91.83) v3(111.92,90.23) v3(111.92,89.43) v3(112.16,166.24) v3(112.43,104.98) v3(112.72,92.63) v3(113.22,104.98) v3(113.52,93.43) v3(113.52,91.03) v3(113.52,90.23) v3(114.04,166.24) v3(114.32,94.23) v3(114.32,91.83) v3(114.32,89.43) v3(115.08,167.64) v3(115.12,92.63) v3(115.12,90.23) v3(115.92,93.43) v3(115.92,91.03) v3(116.13,124.84) v3(116.72,94.23) v3(116.72,91.83) v3(116.8,60) v3(116.97,167.7) v3(117.52,92.63) v3(117.52,90.23) v3(118.02,165.17) v3(118.32,93.43) v3(118.32,91.03) v3(118.32,89.43) v3(119.12,94.23) v3(119.12,91.83) v3(119.9,165.17) v3(119.92,92.63) v3(119.92,90.23) v3(119.92,89.43) v3(120.72,93.43) v3(120.72,91.03) v3(121.03,165.99) v3(121.52,94.23) v3(121.52,91.83) v3(122.32,92.63) v3(122.32,90.23) v3(122.9,165.99) v3(123.12,93.43) v3(123.12,91.03) v3(123.92,94.23) v3(123.92,91.83) v3(124.07,163.49) v3(124.06,124.84) v3(124.72,92.63) v3(124.72,90.23) v3(125.52,93.43) v3(125.52,91.03) v3(125.95,163.49) v3(126.32,94.23) v3(126.32,91.83) v3(127.12,92.63) v3(127.12,89.43) v3(127.92,93.43) v3(127.92,91.03) v3(128.72,94.23) v3(128.72,91.83) v3(129.52,92.63) v3(129.52,91.03) v3(129.52,87.03) v3(129.53,76.63) v3(129.53,69.43) v3(130.22,124.76) v3(130.32,93.43) v3(130.32,86.23) v3(130.32,84.63) v3(130.33,75.83) v3(131.12,94.23) v3(131.12,91.83) v3(131.92,92.63) v3(131.93,71.83) v3(132.72,93.43) v3(132.73,80.63) v3(132.73,74.23) v3(133.52,94.23) v3(133.52,87.83) v3(133.54,75.06) v3(135.62,124.69) v3(145.3,124.68) v3(145.8,63.42) v3(146.34,93.92) v3(146.72,61.87) v3(147.61,94.92) v3(147.56,83.8) v3(147.56,73.58) v3(148.74,94.57) v3(148.73,84.83) v3(148.73,73.24) v3(148.73,63.49) v3(149.54,95.22) v3(149.53,86.78) v3(149.53,84.18) v3(149.53,73.89) v3(149.53,62.84) v3(151.94,95.22) v3(151.94,93.92) v3(151.93,92.63) v3(151.93,86.78) v3(151.93,85.48) v3(151.94,73.88) v3(151.94,72.58) v3(151.93,71.29) v3(151.93,64.14) v3(153.4,126.49) v3(154.33,94.57) v3(154.33,73.24) v3(155.13,92.63) v3(155.13,72.59) v3(155.13,71.29) v3(159.05,119.36) v3(159.5,131.98) v3(166.22,132.5) v3(168.04,123.91) v3(175.87,131.9) v3(179.17,124.6) v3(186.65,124.59) v3(187.55,131.86) v3(193.51,123.84) v3(197.53,92) v3(197.76,119.63) v3(197.9,129.96) v3(197.96,88.3) v3(198.81,81.58) v3(199.39,109.61) v3(199.45,101.97) v3(199.46,114.63) v3(203.96,123.77) v3(203.99,84.23) v3(205.08,78.03) v3(207.51,109.73) v3(207.57,118.23) v3(208.19,101.79) v3(209.05,90.7) v3(209.77,83.62) v3(211.45,75.46) v3(212.14,73.43) v3(216.47,77.35) v3(217.22,84.29) v4(69.6,90.14) v4(71,90.14) v4(73.72,114.08) v4(73.72,113.32) v4(73.72,102.9) v4(73.72,102.14) v4(73.83,89.36) v4(74.48,114.08) v4(74.48,113.32) v4(74.48,102.9) v4(74.48,102.14) v4(74.81,90.13) v4(74.81,89.41) v4(75.24,114.08) v4(75.24,113.32) v4(75.24,102.9) v4(75.24,102.14) v4(75.88,118.27) v4(75.88,117.51) v4(75.88,116.87) v4(75.88,116.11) v4(75.88,111.28) v4(75.88,110.52) v4(75.88,109.89) v4(75.88,109.13) v4(75.88,107.09) v4(75.88,106.33) v4(75.88,105.7) v4(75.88,104.93) v4(75.88,100.11) v4(75.88,99.35) v4(75.88,98.71) v4(75.88,97.95) v4(77.91,118.27) v4(77.91,117) v4(77.91,110.4) v4(77.91,109) v4(77.91,107.09) v4(77.91,105.7) v4(77.91,99.22) v4(77.91,97.82) v4(78.18,73.18) v4(78.55,118.27) v4(78.55,117) v4(78.55,110.4) v4(78.55,109) v4(78.55,107.09) v4(78.55,105.7) v4(78.55,99.22) v4(78.55,97.82) v4(78.7,80.22) v4(78.8,75.85) v4(78.8,74.58) v4(79.39,73.18) v4(79.39,65.01) v4(80.48,80.22) v4(81.49,80.22) v4(81.75,68.87) v4(82.57,67.22) v4(82.57,65.95) v4(82.91,68.87) v4(84.65,63.93) v4(84.78,82.76) v4(84.81,80.22) v4(85.82,80.22) v4(87.22,80.22) v4(87.56,75.85) v4(87.56,74.58) v4(88.83,68.61) v4(88.83,67.85) v4(89.24,75.85) v4(90.48,75.85) v4(90.89,91.34) v4(91.75,68.61) v4(91.75,67.85) v4(92.61,90.93) v4(93.62,90.93) v4(94.64,90.93) v4(96.83,112.43) v4(96.83,111.16) v4(96.83,109.13) v4(96.83,107.86) v4(96.83,105.82) v4(96.83,104.55) v4(96.83,102.52) v4(96.83,101.12) v4(96.83,99.22) v4(96.83,97.82) v4(96.83,94.52) v4(97.11,89.81) v4(97.47,111.16) v4(97.47,109.13) v4(97.47,107.86) v4(97.47,105.82) v4(97.47,104.55) v4(97.47,102.52) v4(97.47,101.12) v4(97.47,99.22) v4(97.47,97.82) v4(97.6,94.52) v4(99.12,97.06) v4(99.12,94.52) v4(99.12,91.98) v4(99.88,97.06) v4(99.88,94.52) v4(99.88,91.98) v4(106.51,105.4) v4(107.33,116.63) v4(108.64,115.95) v4(109.21,105.09) v4(109.25,115.95) v4(109.3,109.85) v4(114.13,109.85) v4(115.38,105.7) v4(115.38,105.06) v4(116.65,105.7) v4(116.65,105.06) v4(118.93,114.88) v4(118.93,109.85) v4(118.93,105.7) v4(118.93,105.06) v4(120.2,105.7) v4(120.2,105.06) v4(120.86,46.54) v4(120.86,45.27) v4(122.49,109.85) v4(122.49,105.06) v4(122.65,46.45) v4(122.64,45.27) v4(123.76,105.7) v4(123.76,105.06) v4(124.29,46.44) v4(124.29,45.14) v4(125.94,46.44) v4(125.94,45.27) v4(126.04,109.85) v4(126.04,105.7) v4(126.04,105.06) v4(127.31,105.7) v4(127.31,105.06) v4(127.72,46.54) v4(127.72,45.27) v4(129.6,109.85) v4(129.6,105.7) v4(129.6,105.06) v4(130.85,49) v4(130.85,47.81) v4(130.87,105.7) v4(130.87,105.06) v4(130.89,41.08) v4(132.01,117.76) v4(133.16,105.7) v4(133.16,105.06) v4(134.43,105.7) v4(134.43,105.06) v4(136.71,105.7) v4(136.71,105.06) v4(137.98,105.7) v4(137.98,105.06) v4(140.27,105.7) v4(140.27,105.06) v4(141.54,105.7) v4(141.54,105.06) v4(143.82,105.7) v4(143.82,105.06) v4(145.09,105.7) v4(145.09,105.06) v4(145.98,55.28) v4(145.98,54.52) v4(145.98,53.37) v4(145.98,52.61) v4(147.38,105.7) v4(147.38,105.06) v4(148.65,105.7) v4(148.65,105.06) v4(149.16,55.28) v4(149.16,54.52) v4(149.16,53.37) v4(149.16,52.61) v4(150.63,106.76) v4(150.74,101.25) v4(151.39,106.76) v4(152.14,56.93) v4(152.54,106.76) v4(153.3,106.76) v4(154.44,106.76) v4(155.2,106.76) v4(156.35,106.76) v4(157.11,106.76) v4(157.59,89.39) v4(157.99,53.63) v4(159.13,53.63) v4(159.06,51.98) v4(159.06,51.21) v4(159.6,68.87) v4(159.58,64.89) v4(159.9,94.89) v4(159.92,87.83) v4(164.96,117.19) v4(164.96,116.56) v4(165.26,162.7) v4(166.35,117.19) v4(166.35,116.56) v4(168.96,78.14) v4(168.96,76.49) v4(168.96,75.09) v4(168.96,73.57) v4(168.96,72.04) v4(168.96,70.52) v4(169.27,121.38) v4(169.27,120.62) v4(169.27,119.86) v4(170.04,121.38) v4(170.04,120.62) v4(170.04,119.86) v4(172.83,117.19) v4(172.83,116.56) v4(174.05,76.11) v4(174.05,75.09) v4(174.05,74.07) v4(174.05,73.06) v4(174.05,72.04) v4(174.23,117.19) v4(174.23,116.56) v4(174.3,85.38) v4(174.3,84.23) v4(174.3,83.09) v4(174.3,64.8) v4(174.3,63.66) v4(174.3,62.52) v4(174.89,81.15) v4(174.89,80.21) v4(174.86,67.94) v4(174.86,67) v4(175.07,76.11) v4(175.07,75.09) v4(175.07,74.07) v4(175.07,73.06) v4(175.07,72.04) v4(175.19,85.38) v4(175.19,84.23) v4(175.19,83.09) v4(175.19,64.8) v4(175.19,63.66) v4(175.19,62.52) v4(175.52,81.15) v4(175.52,80.21) v4(175.5,67.94) v4(175.5,67) v4(176.08,76.11) v4(176.08,75.09) v4(176.08,73.06) v4(176.08,72.04) v4(176.39,117.19) v4(176.39,116.56) v4(176.64,81.15) v4(176.64,80.21) v4(176.67,67.94) v4(176.67,67) v4(176.97,85.38) v4(176.97,84.23) v4(176.97,83.09) v4(176.97,64.88) v4(176.97,63.74) v4(176.97,62.59) v4(177.1,76.11) v4(177.1,75.09) v4(177.1,73.06) v4(177.1,72.04) v4(177.28,81.15) v4(177.28,80.21) v4(177.3,67.94) v4(177.3,67) v4(177.78,117.19) v4(177.78,116.56) v4(177.86,85.38) v4(177.86,84.23) v4(177.86,83.09) v4(177.86,64.88) v4(177.86,63.74) v4(177.86,62.59) v4(178.11,76.11) v4(178.11,75.09) v4(178.11,73.06) v4(178.11,72.04) v4(180.7,121.38) v4(180.7,120.62) v4(180.7,119.86) v4(181.47,121.38) v4(181.47,120.62) v4(181.47,119.86) v4(182.32,76.31) v4(182.32,75.67) v4(183.26,76.31) v4(183.26,75.67) v4(184.26,117.19) v4(184.26,116.56) v4(184.46,77.63) v4(184.46,76.74) v4(185.61,77.63) v4(185.61,76.74) v4(185.66,117.19) v4(185.66,116.56) v4(186.75,77.63) v4(186.75,76.74) v4(187.56,117.19) v4(187.56,116.56) v4(188.96,117.19) v4(188.96,116.56) v4(191.88,121.38) v4(191.88,120.62) v4(191.88,119.86) v4(192.64,121.38) v4(192.64,120.62) v4(192.64,119.86) v4(195.44,117.19) v4(195.44,116.56) v4(196.83,117.19) v4(196.83,116.56) v5(68.13,185.3) v5(69.58,185.3) v5(70.24,181.53) v5(71.1,185.25) v5(71.31,181.56) v5(71.46,178.54) v5(72.07,171.98) v5(72.58,185.23) v5(72.8,175.31) v5(73.16,178.94) v5(74.08,185.23) v5(74.55,178.87) v5(75.58,185.23) v5(76.02,178.87) v5(86.24,168) v5(88.2,168) v5(89.16,169.4) v5(91.12,169.4) v5(92.11,167.75) v5(94.07,167.75) v5(95.11,169.4) v5(97.07,169.4) v5(98.16,166.11) v5(99.47,102.54) v5(99.6,120.42) v5(99.55,111.33) v5(100.12,166.11) v5(101.33,97.33) v5(101.51,107.19) v5(101.61,115.52) v5(102.98,97.05) v5(103.06,114.99) v5(107.48,86.31) v5(108.31,87.25) v5(108.51,124.65) v5(109.13,86.44) v5(110.02,85.9) v5(110.14,87.43) v5(110.97,86.7) v5(111.02,84.9) v5(112.16,165.89) v5(112.23,115.42) v5(112.25,114.66) v5(114.04,165.89) v5(115.08,167.29) v5(116.97,167.34) v5(118.02,164.81) v5(119.9,164.81) v5(120.13,124.83) v5(121.03,165.64) v5(122.9,165.64) v5(124.07,163.13) v5(125.95,163.13) v5(127.16,124.8) v5(132.98,124.76) v5(140.8,124.78) v5(149.5,124.83) v5(156.32,129.39) v5(162.67,122.92) v5(172.25,132.49) v5(175.91,124.55) v5(179.76,131.82) v5(182.9,124.65) v5(183.8,131.83) v5(189.99,124.58) v5(193.61,131.85) v5(195.87,121.75) v5(197.71,90.19) v5(198.24,94.96) v5(198.84,84.36) v5(199.43,99.86) v5(199.47,112) v5(199.46,105.75) v5(201.07,76.86) v5(201.41,126.26) v5(204.3,81.33) v5(206.45,121.23) v5(207.52,111.87) v5(207.49,105.71) v5(207.85,81.31) v5(208.71,73.17) v5(208.96,96.11) v5(209.07,98.4) v5(209.19,86.44) v5(214.59,75.59) v5(214.72,83.54) v6(98.09,125.24) v6(98.23,117.9) v6(101.69,130.76) v6(106.38,88.04) v6(106.97,89.18) v6(107.17,90.48) v6(107.6,92.71) v6(107.6,90.02) v6(108.03,87.76) v6(108.44,93.5) v6(108.44,91.42) v6(108.59,87.99) v6(109.18,92.3) v6(109.15,89.61) v6(109.25,94.31) v6(109.99,93.09) v6(110.14,87.43) v6(110.22,90.2) v6(110.78,93.96) v6(111.33,133.29) v6(111.34,95.1) v6(112.89,115.77) v6(112.86,115.06) v6(120.78,133.42) v6(129,132.27) v6(130.69,76.25) v6(131.95,71.06) v6(133.04,132.95) v6(133.43,80.75) v6(143.11,132.99) v6(147.93,95.88) v6(147.93,93.28) v6(147.93,74.55) v6(147.93,71.95) v6(149.17,132.92) v6(149.54,93.29) v6(149.54,71.95) v6(154.86,141.1) v6(161.77,142.25) v6(168.03,140.76) v6(173.32,140.77) v6(179.86,140.49) v6(187.6,139.11) v6(191.12,42.45) v6(191.41,50.42) v6(192.64,91.27) v6(192.77,98) v6(192.92,84.44) v6(192.86,75.9) v6(194.03,101.32) v6(194.17,56.11) v6(194.58,23.03) v6(194.75,68.97) v6(195.17,81.34) v6(195.25,77.94) v6(195.62,139.13) v6(196.2,83.56) v6(196.7,102.3) v6(198.1,49.62) v6(198.73,132.53) v6(200.11,70.72) v6(200.25,38.24) v6(201.8,65.72) v6(203.1,52.11) v6(203.15,19.7) v6(203.36,124.96) v6(203.72,36.84) v6(204.21,73.91) v6(204.25,66.82) v6(208.28,138.13) v6(210.17,109.22) v6(210.76,46.29) v6(210.81,21.69) v6(212.35,30.39) v6(212.71,110.66) v6(212.94,127.54) v6(213.01,120.07) v6(213.07,101.92) v6(214.77,37.4) v6(216.39,43.78) v6(217.05,58.03) v6(218.68,95.53) v6(220.76,49.36) v6(223.04,90.94) v6(223.76,55.91) v6(223.86,63.08) v6(224.48,74.48) v7(67.62,184.25) v7(68.08,183.63) v7(69.58,183.55) v7(69.6,180.59) v7(70.29,185.8) v7(70.87,172.75) v7(71.08,183.63) v7(71.84,185.83) v7(71.79,181.1) v7(71.79,177.47) v7(72.91,171.68) v7(73.06,179.88) v7(73.13,174.9) v7(73.34,185.85) v7(74.61,175.01) v7(74.81,185.88) v7(106.59,91.42) v7(110.53,91.57) v7(111.18,89.64) v7(111.37,92.45) v7(112.28,93.07) v7(112.96,94.05) v7(115.58,92.2) v7(118.07,93.02) v7(121.65,92.18) v7(122.21,92.58) v7(123.71,95.73) v7(125.05,95.71) v7(128.68,96.09) v7(131.48,90.63) v7(131.84,85.46) v7(142.53,147.85) v7(143.67,148.29) v7(144.79,147.07) v7(146.77,90.15) v7(146.79,68.78) v7(149.31,146.51) v7(149.36,147.3) v7(149.64,90.15) v8(67.75,182) v8(71.31,148.01) v8(71.36,161.83) v8(71.41,151.77) v8(73.14,170.72) v8(73.14,168.41) v8(73.31,180.45) v8(73.34,151.75) v8(73.26,144.64) v8(73.36,184.54) v8(73.36,155.89) v8(73.52,148.04) v8(73.8,165.18) v8(74.38,161.17) v8(74.46,151.77) v8(74.46,148.06) v8(74.81,175.87) v8(74.94,170.01) v8(75.14,156.57) v8(75.19,175.04) v8(75.68,142.27) v8(76.31,181.49) v8(76.36,144.41) v8(76.74,162.14) v8(76.84,185.22) v8(76.79,151.65) v8(76.97,148.11) v8(77.63,178.21) v8(77.66,180.12) v8(77.88,139.73) v8(78.9,148.14) v8(78.98,145.24) v8(79.23,141.51) v8(80.02,164.47) v8(80.07,168.16) v8(80.07,157.92) v8(80.09,155.35) v8(80.07,151.75) v8(80.42,171.25) v8(80.55,134.32) v8(80.7,177.88) v8(81.03,184.72) v8(81.24,142.22) v8(81.54,179.46) v8(81.64,148.22) v8(81.57,145.12) v8(82.48,137.98) v8(82.89,171.61) v8(83.35,177.35) v8(83.45,146.92) v8(83.42,135.11) v8(83.55,168.13) v8(83.55,164.52) v8(83.47,160.51) v8(83.52,156.93) v8(83.5,153.91) v8(83.65,142.68) v8(83.9,150.86) v8(84.21,130.46) v8(84.41,170.75) v8(84.64,181.57) v8(85.43,140.67) v8(85.53,168.13) v8(85.61,164.35) v8(85.78,156.9) v8(85.91,153.91) v8(86.06,148.42) v8(86.11,132.47) v8(86.22,144.2) v8(86.34,151.11) v8(86.55,176.94) v8(86.5,164.98) v8(86.52,162.16) v8(86.62,171.81) v8(86.72,159.11) v8(86.9,124.52) v8(87.13,156.87) v8(87.85,164.95) v8(87.83,161.48) v8(87.79,136.23) v8(88.17,159.16) v8(88.3,126.5) v8(88.62,157.39) v8(88.8,155.03) v8(89.01,148.57) v8(88.98,145.45) v8(89.45,165.14) v8(89.42,162.21) v8(89.42,139.81) v8(89.52,159.49) v8(89.62,121.88) v8(89.71,156.59) v8(90.86,165.51) v8(90.89,162.75) v8(90.97,159.44) v8(91.63,156.9) v8(91.75,153.98) v8(91.83,145.57) v8(91.91,142.58) v8(91.88,137.19) v8(91.91,131.78) v8(91.96,151.88) v8(92.39,164.6) v8(92.36,158.66) v8(92.41,122.13) v8(93.05,133.84) v8(93.4,154.92) v8(93.91,164.5) v8(93.94,161.7) v8(93.91,158.68) v8(94.01,127.49) v8(94.09,151.61) v8(94.22,157.11) v8(94.18,149.67) v8(94.6,153.03) v8(94.8,123.65) v8(94.98,135.87) v8(95.06,155.53) v8(95.33,160.26) v8(95.36,163.38) v8(95.84,128.94) v8(95.87,115.65) v8(96.27,154.36) v8(96.5,118.37) v8(96.55,151.01) v8(96.66,152.81) v8(96.7,149) v8(96.73,147.11) v8(96.66,124.85) v8(96.81,160.28) v8(96.81,131.27) v8(96.88,163.41) v8(96.86,157.69) v8(97.44,155.38) v8(98.1,120.33) v8(98.41,162.87) v8(98.38,159.54) v8(98.54,126.19) v8(98.64,156.55) v8(98.61,150.91) v8(98.81,128.94) v8(98.94,112.66) v8(99.09,153.42) v8(99.22,144.51) v8(99.37,148.18) v8(99.35,146.28) v8(99.37,115.53) v8(99.73,121.8) v8(99.8,163.44) v8(99.77,161.18) v8(99.81,157.8) v8(100.26,149.38) v8(100.97,156.45) v8(100.97,154.08) v8(101.25,126.6) v8(101.74,116.82) v8(101.74,111.89) v8(101.76,141.89) v8(101.86,150.68) v8(101.9,148.04) v8(101.91,145.61) v8(101.96,143.75) v8(102.32,154.89) v8(102.88,122.11) v8(103.46,118.09) v8(103.72,140.1) v8(103.81,150.75) v8(103.77,112.38) v8(104.29,145.67) v8(104.42,143.12) v8(104.51,147.92) v8(104.47,141.2) v8(104.94,121.95) v8(105.11,119.87) v8(106.06,139.3) v8(106.77,140.77) v8(106.85,147.55) v8(106.95,143) v8(107.04,145.41) v8(107.15,119.82) v8(108.59,112.71) v8(108.87,90.86) v8(109.43,143.05) v8(109.42,140.18) v8(109.66,144.74) v8(110.42,114.28) v8(110.98,94.39) v8(111.12,140.32) v8(111.36,118.68) v8(111.84,142.52) v8(112.24,140.32) v8(112.48,95.25) v8(112.66,91.59) v8(112.94,124.61) v8(112.91,116.72) v8(112.96,129.25) v8(112.97,119.89) v8(113.24,91.14) v8(113.55,92.46) v8(113.64,164.17) v8(113.95,95.73) v8(114.54,133.59) v8(114.48,127.73) v8(114.52,123.58) v8(114.5,119.91) v8(114.89,92.2) v8(115.03,132.11) v8(115.07,93.65) v8(115.32,95.66) v8(115.27,92.66) v8(115.39,114.8) v8(115.4,109.54) v8(115.73,91.21) v8(116.3,122.78) v8(116.32,119.71) v8(116.36,130.37) v8(116.36,126.58) v8(116.39,93.68) v8(116.63,112.58) v8(116.8,165.42) v8(116.95,94.23) v8(117.43,91.44) v8(117.79,130.1) v8(117.79,125.93) v8(117.78,121.04) v8(117.77,117.15) v8(117.8,112.42) v8(118.1,167.92) v8(118.1,137.42) v8(118.27,93.52) v8(118.27,91.03) v8(118.53,135.45) v8(118.77,133.19) v8(119.04,130.63) v8(118.96,128.21) v8(118.98,125.24) v8(118.96,122.46) v8(118.96,118.99) v8(118.97,115.65) v8(119.44,94.54) v8(119.52,91.06) v8(120.04,166.46) v8(120.16,125.09) v8(120.18,120.82) v8(120.16,117.45) v8(120.23,91.8) v8(120.49,169.9) v8(120.72,139.91) v8(120.68,92.61) v8(120.81,141.86) v8(121.06,168.7) v8(121.12,91.47) v8(121.31,129.73) v8(121.34,126.79) v8(121.34,121.32) v8(121.34,118.98) v8(121.34,116) v8(121.34,113.41) v8(121.34,110.4) v8(121.34,107.86) v8(121.44,137.99) v8(121.35,133.06) v8(121.47,90.27) v8(121.62,136.06) v8(122.11,94.56) v8(122.53,170.12) v8(122.52,163.72) v8(122.49,135.05) v8(122.53,125.49) v8(122.54,121.67) v8(122.52,118.98) v8(122.52,116.04) v8(122.51,112.59) v8(122.54,90.48) v8(122.7,133.07) v8(122.79,93.27) v8(122.91,167.35) v8(122.92,95.66) v8(123.52,168.78) v8(123.6,91.44) v8(123.73,129.67) v8(123.73,127.47) v8(123.73,123.66) v8(123.73,119.35) v8(123.73,114.27) v8(123.73,109.89) v8(123.87,165.98) v8(123.92,136.39) v8(124.48,140.5) v8(124.55,139.05) v8(124.56,133.47) v8(124.83,135.58) v8(124.93,128.46) v8(124.89,120.8) v8(124.9,116.78) v8(124.9,114.22) v8(124.9,110.38) v8(124.9,108.9) v8(124.9,107.09) v8(125.03,125.87) v8(125.03,122.87) v8(125.07,163.59) v8(125.08,131.05) v8(125.2,170.14) v8(125.31,132.44) v8(125.38,167.21) v8(125.41,165.37) v8(125.59,92.86) v8(125.71,138.16) v8(125.74,94.39) v8(125.81,168.59) v8(125.85,152.71) v8(125.86,159.33) v8(125.86,156.12) v8(125.88,148.85) v8(125.87,143.06) v8(125.92,122.3) v8(126.02,128.13) v8(126.04,106.97) v8(126.05,119.84) v8(126.08,116.43) v8(126.07,113.54) v8(126.08,110.49) v8(126.29,126.23) v8(126.3,91.36) v8(126.47,137.21) v8(126.52,132.44) v8(126.73,161.86) v8(126.81,92.38) v8(126.87,130.84) v8(127.1,167.47) v8(127.14,140.09) v8(127.1,136.15) v8(127.06,134.37) v8(127.14,92.74) v8(127.24,169.06) v8(127.2,160.08) v8(127.2,156.63) v8(127.2,153.19) v8(127.2,149.74) v8(127.31,121.18) v8(127.29,119.87) v8(127.31,117.63) v8(127.31,115.09) v8(127.31,112.55) v8(127.31,110.01) v8(127.41,122.86) v8(127.41,95.28) v8(127.65,124.14) v8(127.77,164.95) v8(127.95,93.27) v8(128.03,138.81) v8(127.97,126.78) v8(128.05,121.13) v8(128.11,130.73) v8(128.14,128.26) v8(128.23,125.57) v8(128.15,94.41) v8(128.29,162.27) v8(128.37,116.27) v8(128.36,113.98) v8(128.43,91.59) v8(128.47,160.61) v8(128.48,158.86) v8(128.48,155.41) v8(128.48,151.96) v8(128.48,148.51) v8(128.48,140.6) v8(128.53,95.35) v8(128.75,165.81) v8(128.97,167.33) v8(128.96,136.32) v8(129.35,138.57) v8(129.37,128.16) v8(129.59,162.74) v8(129.64,118.38) v8(129.61,111.71) v8(129.68,159.33) v8(129.68,155.87) v8(129.68,152.44) v8(129.68,148.99) v8(129.68,141.13) v8(129.82,131.31) v8(129.78,129.78) v8(129.78,93.12) v8(130.03,91.85) v8(130.34,126.63) v8(130.28,93.55) v8(130.36,137.87) v8(130.59,94.11) v8(130.7,119.23) v8(130.67,95.38) v8(130.9,158.11) v8(130.9,154.62) v8(130.9,151.18) v8(130.9,147.74) v8(130.9,143.93) v8(130.9,139.87) v8(130.87,117.47) v8(130.87,115.19) v8(130.86,112.9) v8(130.85,110.61) v8(131.04,125.15) v8(131.17,165.06) v8(131.5,128.35) v8(131.66,92.23) v8(131.9,104.9) v8(132.11,163.22) v8(132.06,93.57) v8(132.24,134.42) v8(132.27,156.77) v8(132.26,153.3) v8(132.26,149.86) v8(132.26,146.42) v8(132.25,142.53) v8(132.25,138.48) v8(132.49,95.43) v8(132.65,129.9) v8(133.15,125.17) v8(133.2,119.83) v8(133.19,117.55) v8(133.18,115.26) v8(133.17,112.97) v8(133.22,107.09) v8(133.79,131.05) v8(133.91,112.12) v8(134.37,158.5) v8(135.21,156.83) v8(136.28,155.73) v8(136.52,112.42) v8(136.71,151.37) v8(136.71,148.14) v8(136.74,144.64) v8(136.76,141.76) v8(136.79,138.84) v8(136.79,135.62) v8(136.84,130.87) v8(136.77,114.95) v8(137.78,159.49) v8(137.93,155.3) v8(138.03,168.97) v8(138.03,162.31) v8(138.1,111.39) v8(138.87,164.57) v8(139.29,110.14) v8(139.39,115.31) v8(139.58,173.69) v8(139.62,117.78) v8(140.3,107.23) v8(140.39,157.77) v8(140.49,113.92) v8(140.88,109.63) v8(141.54,175.42) v8(141.51,146.34) v8(141.49,143.09) v8(141.51,139.91) v8(141.53,112.26) v8(141.59,171.61) v8(142.02,120.24) v8(142.16,118.07) v8(142.15,110.95) v8(142.58,135.9) v8(142.71,168.92) v8(142.71,107.02) v8(142.99,164.85) v8(142.99,140.06) v8(143.02,116.47) v8(143.06,143.34) v8(143.2,114.06) v8(143.25,111.92) v8(143.49,163) v8(143.47,160.71) v8(143.65,147.75) v8(143.62,136.74) v8(143.67,173.41) v8(143.92,110.27) v8(144.08,117.6) v8(144.18,122.38) v8(144.36,142.88) v8(144.36,140.11) v8(144.53,133.71) v8(144.66,147.81) v8(144.86,150.05) v8(145.17,121.1) v8(145.27,112.02) v8(145.37,116.15) v8(145.47,136.63) v8(145.52,117.7) v8(145.58,148.06) v8(145.55,142.93) v8(145.63,140.85) v8(145.86,172.19) v8(145.88,167.47) v8(146.06,165.56) v8(146.26,133.97) v8(146.48,124.63) v8(146.69,164.07) v8(146.72,147.78) v8(146.7,122.34) v8(146.69,113.44) v8(146.77,116.18) v8(146.85,111.95) v8(146.97,137.27) v8(147.1,131.22) v8(147.13,117.48) v8(147.23,143.64) v8(147.28,140.44) v8(147.25,106.84) v8(147.53,148.08) v8(147.53,120.73) v8(147.56,169.48) v8(147.71,134.4) v8(147.84,146.15) v8(147.89,126.17) v8(147.95,122.34) v8(148.27,115.35) v8(148.27,113.37) v8(148.27,109.94) v8(148.52,131.68) v8(148.6,149.72) v8(148.6,144.28) v8(148.6,142.25) v8(148.65,137.52) v8(148.75,146.1) v8(148.88,147.98) v8(148.88,129.01) v8(149.03,134.86) v8(149.13,168.74) v8(149.11,126.15) v8(149.06,123.98) v8(149.26,172.93) v8(149.44,114.87) v8(149.46,166.78) v8(149.64,118.8) v8(149.79,132.24) v8(149.77,111.54) v8(150.05,121.24) v8(150.07,171.25) v8(150.07,135.67) v8(150.2,146.97) v8(150.22,129.06) v8(150.25,126.14) v8(150.27,123.91) v8(151.03,132.89) v8(151.44,121.06) v8(151.39,113.27) v8(151.54,169.02) v8(151.49,129.06) v8(151.49,126.14) v8(151.47,123.91) v8(151.93,116.75) v8(152.31,133.54) v8(152.71,128.99) v8(152.71,126.12) v8(152.74,124.77) v8(152.66,120.61) v8(153.63,173.31) v8(153.78,119.72) v8(154.01,176.84) v8(153.98,128.81) v8(153.96,126.12) v8(153.96,124.01) v8(155.74,178.47) v8(155.99,176.36) v8(157.87,178.37) v9(35.03,150.03) v9(35.03,129.71) v9(35.31,139.84) v9(35.48,160.47) v9(35.75,127.45) v9(35.91,147.83) v9(35.99,141.51) v9(37.01,150.03) v9(36.97,140.51) v9(37.01,129.71) v9(37.18,162.57) v9(37.35,160.79) v9(37.39,143.03) v9(37.65,146.03) v9(38.16,147.46) v9(38.19,127.82) v9(38.19,126.6) v9(38.39,142.11) v9(38.86,164.05) v9(38.95,162.48) v9(39.03,150.03) v9(39.03,129.71) v9(39.57,146.08) v9(39.61,144.3) v9(40.16,142.95) v9(40.73,127.82) v9(40.73,126.6) v9(41.01,150.03) v9(41.01,129.71) v9(41.22,164.56) v9(41.26,163.31) v9(41.87,147.01) v9(41.87,145.76) v9(42.44,144.37) v9(43.03,150.03) v9(43.3,160.34) v9(43.32,141.02) v9(43.27,130.26) v9(43.27,129.04) v9(43.27,127.82) v9(43.27,126.6) v9(43.76,164.56) v9(43.8,163.31) v9(43.78,162.4) v9(44.41,147.01) v9(44.41,145.76) v9(44.78,139.98) v9(45.01,150.03) v9(44.98,144.37) v9(45.04,142.99) v9(45.51,162.09) v9(45.81,130.26) v9(45.81,129.04) v9(45.81,127.82) v9(45.81,126.6) v9(46.3,164.56) v9(46.34,163.31) v9(46.45,141.77) v9(47.03,150.03) v9(46.95,148.22) v9(46.95,147.01) v9(46.95,145.76) v9(47.24,139.94) v9(47.52,144.37) v9(47.58,142.99) v9(48.05,162.09) v9(48.35,130.26) v9(48.35,129.04) v9(48.35,127.82) v9(48.35,126.6) v9(48.84,164.56) v9(48.88,163.31) v9(48.91,140.36) v9(49.01,150.03) v9(48.99,141.77) v9(49.49,148.22) v9(49.49,147.01) v9(49.49,145.76) v9(49.68,160.85) v9(50.06,144.37) v9(50.12,142.99) v9(50.59,162.09) v9(50.89,130.26) v9(50.89,129.04) v9(50.89,127.82) v9(50.89,126.6) v9(51.3,149.97) v9(51.38,164.56) v9(51.42,163.31) v9(51.53,148.55) v9(51.53,141.77) v9(51.67,140.48) v9(52.02,131.53) v9(52.22,160.85) v9(52.54,147.64) v9(52.48,144.48) v9(52.66,151.34) v9(52.73,143.04) v9(53.13,162.09) v9(53.36,146.7) v9(53.43,130.26) v9(53.43,129.04) v9(53.43,127.82) v9(53.43,126.6) v9(53.47,150.31) v9(53.92,164.56) v9(53.96,163.31) v9(54.06,139.12) v9(54.21,152.89) v9(54.34,149.43) v9(54.42,142.2) v9(54.38,131.57) v9(54.79,140.96) v9(55.01,160.17) v9(55.14,146.69) v9(55.06,145.91) v9(55.24,153.87) v9(55.16,148.5) v9(55.26,152.11) v9(55.79,161.28) v9(55.95,145.04) v9(55.97,130.26) v9(55.97,129.04) v9(55.97,127.82) v9(55.97,126.6) v9(56.14,151.23) v9(56.07,139.88) v9(56.63,164.26) v9(56.59,138.89) v9(56.6,134.87) v9(56.58,132.52) v9(56.71,162.51) v9(56.68,144.03) v9(56.82,147.67) v9(56.96,150.29) v9(56.95,148.51) v9(57.06,153.9) v9(57.45,156.09) v9(57.38,143.01) v9(57.75,146.83) v9(57.93,153.03) v9(57.9,137.41) v9(57.9,134.87) v9(57.9,132.33) v9(58.12,141.84) v9(58.53,149.35) v9(58.47,145.83) v9(58.51,129.04) v9(58.51,127.82) v9(58.51,126.6) v9(58.64,150.2) v9(58.75,152.09) v9(58.94,140.57) v9(59.17,144.81) v9(59.54,148.63) v9(59.83,162.09) v9(59.83,160.87) v9(59.83,159.65) v9(59.83,158.43) v9(59.83,157.21) v9(59.83,155.99) v9(59.83,154.77) v9(59.92,143.64) v9(59.88,132.04) v9(60.27,147.63) v9(60.73,142.37) v9(60.72,131.08) v9(60.97,146.6) v9(61.05,127.82) v9(61.05,126.6) v9(61.71,145.43) v9(61.68,133.83) v9(62.25,130.63) v9(62.37,162.09) v9(62.37,160.87) v9(62.37,159.65) v9(62.37,158.43) v9(62.37,157.21) v9(62.37,155.99) v9(62.37,154.77) v9(62.37,153.55) v9(62.37,152.33) v9(62.53,144.16) v9(62.52,132.88) v9(63.09,129.68) v9(63.47,135.63) v9(64.04,132.43) v9(64.31,134.67) v9(64.91,162.09) v9(64.91,160.87) v9(64.91,159.65) v9(64.91,158.43) v9(64.91,157.21) v9(64.91,155.99) v9(64.91,154.77) v9(64.91,153.55) v9(64.91,152.33) v9(64.91,151.14) v9(64.91,149.92) v9(64.91,148.7) v9(64.91,147.48) v9(64.91,146.26) v9(64.87,144.99) v9(64.88,131.47) v9(65.84,134.22) v9(66.08,130.36) v9(66.7,133.25) v9(67.45,160.87) v9(67.45,159.65) v9(67.45,158.43) v9(67.45,157.21) v9(67.45,155.99) v9(67.45,154.77) v9(67.45,153.55) v9(67.45,152.33) v9(67.45,151.14) v9(67.45,149.92) v9(67.45,148.7) v9(67.45,147.48) v9(67.45,146.26) v9(67.45,145.04) v9(67.45,143.82) v9(69.89,134.29) v9(69.99,162.09) v9(69.99,160.87) v9(69.99,159.65) v9(69.99,158.43) v9(69.99,157.21) v9(69.99,155.99) v9(69.99,154.77) v9(69.99,153.55) v9(69.99,152.33) v9(69.99,151.14) v9(69.99,149.92) v9(69.99,148.7) v9(69.99,147.48) v9(69.99,146.26) v9(69.99,145.04) v9(69.99,143.82) v9(69.99,142.6) v9(70.18,130.88) v9(72.53,162.09) v9(72.53,160.87) v9(72.53,159.65) v9(72.53,158.43) v9(72.53,157.21) v9(72.53,155.99) v9(72.53,154.77) v9(72.53,153.55) v9(72.53,152.33) v9(72.53,151.14) v9(72.53,149.92) v9(72.53,148.7) v9(72.53,147.48) v9(72.53,146.26) v9(72.53,145.04) v9(72.53,143.82) v9(72.53,142.6) v9(72.53,141.38) v9(73.05,134.48) v9(75.07,162.09) v9(75.07,160.87) v9(75.07,159.65) v9(75.07,158.43) v9(75.07,157.21) v9(75.07,155.99) v9(75.07,154.77) v9(75.07,153.55) v9(75.07,152.33) v9(75.07,151.14) v9(75.07,149.92) v9(75.07,148.7) v9(75.07,147.48) v9(75.07,146.26) v9(75.07,145.04) v9(75.07,143.82) v9(75.07,142.6) v9(75.07,141.38) v9(76.86,136) v9(77.49,130.81) v9(77.61,162.09) v9(77.61,160.87) v9(77.61,159.65) v9(77.61,158.43) v9(77.61,157.21) v9(77.61,155.99) v9(77.61,154.77) v9(77.61,153.55) v9(77.61,152.33) v9(77.61,151.14) v9(77.61,149.92) v9(77.61,148.7) v9(77.61,147.48) v9(77.61,146.26) v9(77.61,145.04) v9(77.61,143.82) v9(77.61,142.6) v9(77.61,141.38) v9(79.93,134.48) v9(80.15,162.09) v9(80.15,160.87) v9(80.15,159.65) v9(80.15,158.43) v9(80.15,157.21) v9(80.15,155.99) v9(80.15,154.77) v9(80.15,153.55) v9(80.15,152.33) v9(80.15,151.14) v9(80.15,149.92) v9(80.15,148.7) v9(80.15,147.48) v9(80.15,146.26) v9(80.15,145.04) v9(80.15,143.82) v9(80.15,142.6) v9(80.15,141.38) v9(82.69,162.09) v9(82.69,160.87) v9(82.69,159.65) v9(82.69,158.43) v9(82.69,157.21) v9(82.69,155.99) v9(82.69,154.77) v9(82.69,153.55) v9(82.69,152.33) v9(82.69,151.14) v9(82.69,149.92) v9(82.69,148.7) v9(82.69,147.48) v9(82.69,146.26) v9(82.69,145.04) v9(82.69,143.82) v9(82.69,142.6) v9(82.69,141.38) v9(83.43,130.89) v9(83.74,135.9) v9(85.23,162.09) v9(85.23,160.87) v9(85.23,159.65) v9(85.23,158.43) v9(85.23,157.21) v9(85.23,155.99) v9(85.23,154.77) v9(85.23,153.55) v9(85.23,152.33) v9(85.23,151.14) v9(85.23,149.92) v9(85.23,148.7) v9(85.23,147.48) v9(85.23,146.26) v9(85.23,145.04) v9(85.23,143.82) v9(85.23,142.6) v9(85.23,141.38) v9(86.96,134.49) v9(87.77,162.09) v9(87.77,160.87) v9(87.77,159.65) v9(87.77,158.43) v9(87.77,157.21) v9(87.77,155.99) v9(87.77,154.77) v9(87.77,153.55) v9(87.77,152.33) v9(87.77,151.14) v9(87.77,149.92) v9(87.77,148.7) v9(87.77,147.48) v9(87.77,146.26) v9(87.77,145.04) v9(87.77,143.82) v9(87.77,142.6) v9(90.04,135.88) v9(90.31,162.09) v9(90.31,160.87) v9(90.31,159.65) v9(90.31,158.43) v9(90.31,157.21) v9(90.31,155.99) v9(90.31,154.77) v9(90.31,153.55) v9(90.31,152.33) v9(90.31,151.14) v9(90.31,149.92) v9(90.31,148.7) v9(90.31,147.48) v9(90.31,146.26) v9(90.31,145.04) v9(90.31,143.82) v9(90.31,142.6) v9(90.31,141.38) v9(91.67,130.87) v9(92.85,162.09) v9(92.85,160.87) v9(92.85,159.65) v9(92.85,158.43) v9(92.85,157.21) v9(92.85,155.99) v9(92.85,154.77) v9(92.85,153.55) v9(92.85,152.33) v9(92.85,151.14) v9(92.85,149.92) v9(92.85,148.7) v9(92.85,147.48) v9(92.85,146.26) v9(92.85,145.04) v9(92.85,143.82) v9(92.85,142.6) v9(92.85,141.38) v9(95.12,134.48) v9(95.39,162.09) v9(95.39,160.87) v9(95.39,159.65) v9(95.39,158.43) v9(95.39,157.21) v9(95.39,155.99) v9(95.39,154.77) v9(95.39,153.55) v9(95.39,152.33) v9(95.39,151.14) v9(95.39,149.92) v9(95.39,148.7) v9(95.39,147.48) v9(95.39,146.26) v9(95.39,145.04) v9(95.39,143.82) v9(95.39,142.6) v9(95.39,141.38) v9(95.8,135.87) v9(96.3,127.38) v9(97.26,129.03) v9(97.7,126.98) v9(97.93,162.09) v9(97.93,160.87) v9(97.93,159.65) v9(97.93,158.43) v9(97.93,157.21) v9(97.93,155.99) v9(97.93,154.77) v9(97.93,153.55) v9(97.93,152.33) v9(97.93,151.14) v9(97.93,149.92) v9(97.93,148.7) v9(97.93,147.48) v9(97.93,146.26) v9(97.93,145.04) v9(97.93,143.82) v9(97.93,142.6) v9(97.9,124.56) v9(98.66,130.73) v9(100.47,162.09) v9(100.47,160.87) v9(100.47,159.65) v9(100.47,158.43) v9(100.47,157.21) v9(100.47,155.99) v9(100.47,154.77) v9(100.47,153.55) v9(100.47,152.33) v9(100.47,151.14) v9(100.47,149.92) v9(100.47,148.7) v9(100.47,147.48) v9(100.47,146.26) v9(100.47,145.04) v9(100.47,143.82) v9(100.47,142.6) v9(100.47,141.38) v9(100.9,131.37) v9(100.89,128.36) v9(100.89,127.76) v9(101.1,130) v9(101.17,136.28) v9(102.73,130.15) v9(103.01,162.09) v9(103.01,160.87) v9(103.01,159.65) v9(103.01,158.43) v9(103.01,157.21) v9(103.01,155.99) v9(103.01,154.77) v9(103.01,153.55) v9(103.01,152.33) v9(103.01,151.14) v9(103.01,149.92) v9(103.01,148.7) v9(103.01,147.48) v9(103.01,146.26) v9(103.01,145.04) v9(103.01,143.82) v9(103.01,142.6) v9(103.01,141.38) v9(103.19,134.18) v9(103.5,136.4) v9(104.21,136.4) v9(105,136.4) v9(105.55,162.09) v9(105.55,160.87) v9(105.55,159.65) v9(105.55,158.43) v9(105.55,157.21) v9(105.55,155.99) v9(105.55,154.77) v9(105.55,153.55) v9(105.55,152.33) v9(105.55,151.14) v9(105.55,149.92) v9(105.55,148.7) v9(105.55,147.48) v9(105.55,146.26) v9(105.55,145.04) v9(105.55,143.82) v9(105.55,142.6) v9(105.55,141.38) v9(105.71,136.4) v9(106.84,136.4) v9(107.55,136.4) v9(108.09,162.09) v9(108.09,160.87) v9(108.09,159.65) v9(108.09,158.43) v9(108.09,157.21) v9(108.09,155.99) v9(108.09,154.77) v9(108.09,153.55) v9(108.09,152.33) v9(108.09,151.14) v9(108.09,149.92) v9(108.09,148.7) v9(108.09,147.48) v9(108.09,146.26) v9(108.09,145.04) v9(108.09,143.82) v9(108.09,142.6) v9(108.09,141.38) v9(108.5,136.4) v9(109.21,136.4) v9(110.34,136.4) v9(110.63,160.87) v9(110.63,159.65) v9(110.63,158.43) v9(110.63,157.21) v9(110.63,155.99) v9(110.63,154.77) v9(110.63,153.55) v9(110.63,152.33) v9(110.63,151.14) v9(110.63,149.92) v9(110.63,148.7) v9(110.63,147.48) v9(110.63,146.26) v9(110.63,145.04) v9(110.63,143.82) v9(110.63,142.6) v9(110.63,141.38) v9(110.86,139.42) v9(111.05,136.4) v9(111.99,133.42) v9(112.06,135.99) v9(112.18,138.92) v9(112.54,123.92) v9(112.91,91.8) v9(113.15,130.9) v9(113.17,162.09) v9(113.17,160.87) v9(113.17,159.65) v9(113.17,158.43) v9(113.17,157.21) v9(113.17,155.99) v9(113.17,154.77) v9(113.17,153.55) v9(113.17,152.33) v9(113.17,151.14) v9(113.17,149.92) v9(113.17,148.7) v9(113.17,147.48) v9(113.17,146.26) v9(113.17,145.04) v9(113.17,143.82) v9(113.17,142.6) v9(113.17,141.38) v9(113.31,118.74) v9(113.72,102.18) v9(113.8,92.66) v9(114.06,112.56) v9(114.05,102.74) v9(114.16,93.47) v9(115.12,93.98) v9(115.25,102.34) v9(115.53,103.09) v9(115.71,160.87) v9(115.71,159.65) v9(115.71,158.43) v9(115.71,157.21) v9(115.71,155.99) v9(115.71,154.77) v9(115.71,153.55) v9(115.71,152.33) v9(115.71,151.14) v9(115.71,149.92) v9(115.71,148.7) v9(115.71,147.48) v9(115.71,146.26) v9(115.71,145.04) v9(115.71,143.82) v9(115.71,142.6) v9(116.16,131.94) v9(117.57,134.84) v9(117.96,142.75) v9(118.25,162.09) v9(118.25,160.87) v9(118.25,159.65) v9(118.25,158.43) v9(118.25,157.21) v9(118.25,155.99) v9(118.25,154.77) v9(118.25,153.55) v9(118.25,152.33) v9(118.25,151.14) v9(118.25,149.92) v9(118.25,148.7) v9(118.25,147.48) v9(118.41,145.73) v9(118.36,144.07) v9(118.73,128.97) v9(119.05,110.99) v9(120.08,142.35) v9(120.14,134.38) v9(120.24,125.92) v9(120.29,119.01) v9(120.79,162.09) v9(120.79,160.87) v9(120.79,159.65) v9(120.79,158.43) v9(120.79,157.21) v9(120.79,155.99) v9(120.79,154.77) v9(120.79,153.55) v9(120.79,152.33) v9(120.79,151.14) v9(120.79,149.92) v9(120.79,148.7) v9(120.79,147.48) v9(121.14,145.83) v9(121.07,135.53) v9(121.64,142.66) v9(121.59,140.85) v9(121.58,127.41) v9(122.06,143.81) v9(122.37,139.01) v9(122.44,91.97) v9(122.51,130.18) v9(122.59,131.92) v9(123.25,92.84) v9(123.33,162.09) v9(123.33,160.87) v9(123.33,159.65) v9(123.33,158.43) v9(123.33,157.21) v9(123.34,155.97) v9(123.34,154.69) v9(123.31,151.84) v9(123.42,140.34) v9(123.53,147.28) v9(123.75,142.51) v9(123.78,145.25) v9(124.02,132.39) v9(124.17,152.75) v9(124.26,148.37) v9(124.34,92.66) v9(125.04,153.62) v9(125.11,150.1) v9(125.05,90.45) v9(125.15,93.42) v9(125.26,90.86) v9(125.72,157.97) v9(125.7,145.1) v9(125.84,91.72) v9(125.9,154.48) v9(125.86,134.82) v9(125.95,130.33) v9(125.95,128.84) v9(125.98,150.96) v9(126.47,127.68) v9(126.86,139.63) v9(127.2,158.25) v9(127.25,154.86) v9(127.21,151.36) v9(127.2,147.65) v9(127.2,143.6) v9(127.64,127.68) v9(127.66,133.33) v9(127.66,131.83) v9(128.14,130.33) v9(128.14,128.84) v9(128.44,157.11) v9(128.44,153.66) v9(128.44,150.22) v9(128.44,146.35) v9(128.44,142.37) v9(129.07,138.12) v9(129.19,124.36) v9(129.22,118.72) v9(129.32,130.31) v9(129.32,128.86) v9(129.52,136.75) v9(129.68,157.6) v9(129.68,154.15) v9(129.68,150.71) v9(129.68,147.26) v9(129.69,142.93) v9(129.68,139.35) v9(129.84,127.7) v9(129.85,133.33) v9(129.85,131.83) v9(130.32,119.92) v9(130.92,156.35) v9(130.92,152.91) v9(130.92,149.47) v9(130.92,146.03) v9(130.92,141.71) v9(130.93,138.1) v9(131.01,127.3) v9(131.01,125.84) v9(131.51,130.31) v9(131.51,128.86) v9(131.53,124.68) v9(132.26,155.02) v9(132.26,151.58) v9(132.26,148.14) v9(132.26,144.69) v9(132.25,140.37) v9(132.7,124.68) v9(132.86,156.21) v9(133.2,127.3) v9(133.2,125.84) v9(133.5,148.62) v9(133.86,140.95) v9(134.4,136.18) v9(134.4,133.64) v9(134.4,131.1) v9(134.4,128.56) v9(134.4,126.02) v9(134.4,123.48) v9(134.4,120.94) v9(134.4,118.4) v9(134.4,115.86) v9(134.4,113.32) v9(134.4,110.78) v9(134.84,152.44) v9(134.84,149) v9(134.84,143.84) v9(134.84,142.11) v9(135.65,136.19) v9(135.65,133.65) v9(135.65,131.11) v9(135.65,128.57) v9(135.65,126.03) v9(135.65,123.49) v9(135.65,120.95) v9(135.65,118.41) v9(135.65,113.33) v9(136.08,146.04) v9(136.19,138.49) v9(137.03,122.46) v9(137.47,148.09) v9(137.54,144.57) v9(137.61,141.05) v9(137.73,137.25) v9(138.25,150.82) v9(138.17,122.46) v9(138.33,148.95) v9(138.4,145.43) v9(138.48,141.91) v9(138.55,138.39) v9(139.03,125.48) v9(139.03,120.36) v9(139.03,117.82) v9(139.03,115.28) v9(139.03,112.74) v9(139.27,146.29) v9(139.34,142.77) v9(139.41,139.25) v9(140.05,149.02) v9(140.13,147.16) v9(140.13,136.2) v9(140.2,143.64) v9(140.28,130.52) v9(140.28,127.98) v9(140.28,125.44) v9(140.28,122.9) v9(140.28,120.36) v9(140.27,118.21) v9(140.27,115.72) v9(140.38,140) v9(140.98,137.26) v9(141.06,144.5) v9(141.13,140.98) v9(141.53,130.52) v9(141.53,127.98) v9(141.53,125.44) v9(141.53,122.9) v9(141.53,120.36) v9(141.54,117.35) v9(141.52,114.89) v9(141.53,112.74) v9(141.84,147.23) v9(141.92,145.36) v9(142,141.84) v9(142.12,137.91) v9(142.78,133.06) v9(142.78,130.52) v9(142.78,127.98) v9(142.78,125.44) v9(142.78,122.9) v9(142.78,120.8) v9(142.79,118.66) v9(142.79,113.71) v9(142.78,110.2) v9(142.78,107.66) v9(142.78,105.12) v9(142.86,142.7) v9(142.9,139.01) v9(143.64,145.43) v9(143.72,143.56) v9(143.74,139.97) v9(143.94,136.16) v9(144.03,133.06) v9(144.03,130.52) v9(144.03,127.98) v9(144.03,125.44) v9(144.03,122.9) v9(144.03,112.74) v9(144.06,120) v9(144.05,118.11) v9(144.65,140.91) v9(145.06,137.23) v9(145.17,107.48) v9(145.42,133.06) v9(145.42,130.52) v9(145.42,127.98) v9(145.42,125.44) v9(145.42,123.54) v9(145.42,112.74) v9(145.51,119.91) v9(145.52,118.11) v9(145.52,117.25) v9(145.63,143.7) v9(146.58,119.91) v9(146.59,117.27) v9(146.68,135.91) v9(146.67,133.06) v9(146.67,130.52) v9(146.67,127.98) v9(146.67,125.44) v9(146.67,112.74) v9(146.79,123.56) v9(147.41,141.27) v9(147.62,142.84) v9(147.92,138.14) v9(147.92,135.6) v9(147.92,133.06) v9(147.92,130.52) v9(147.87,123.56) v9(147.98,127.41) v9(148.97,140.9) v9(149.05,127.41) v9(149.17,135.6) v9(149.17,133.06) v9(149.17,130.52) v10(35.39,149.42) v10(35.39,129.1) v10(36.31,161.7) v10(36.65,149.42) v10(36.65,129.1) v10(36.92,126.6) v10(37,128.08) v10(37.92,163.34) v10(38.18,161.69) v10(39.39,149.42) v10(39.39,129.1) v10(39.46,127.82) v10(39.46,126.6) v10(39.98,164.47) v10(39.99,163.12) v10(40.65,149.42) v10(40.6,148.22) v10(40.6,145.76) v10(40.65,129.1) v10(41.17,144.37) v10(42,127.82) v10(42,126.6) v10(42.49,164.56) v10(42.53,163.31) v10(43.14,147.01) v10(43.14,145.76) v10(43.4,161.34) v10(43.39,149.42) v10(43.71,144.37) v10(43.77,142.99) v10(44.54,129.04) v10(44.54,127.82) v10(44.54,126.6) v10(44.65,149.42) v10(44.7,160.67) v10(44.71,130.48) v10(45.03,164.56) v10(45.07,163.31) v10(45.68,148.22) v10(45.68,147.01) v10(45.68,145.76) v10(46.25,144.37) v10(46.31,142.99) v10(46.78,162.09) v10(47.08,130.26) v10(47.08,129.04) v10(47.08,127.82) v10(47.08,126.6) v10(47.39,149.42) v10(47.57,164.56) v10(47.61,163.31) v10(47.72,141.77) v10(48.22,148.22) v10(48.22,147.01) v10(48.22,145.76) v10(48.65,149.42) v10(48.79,144.37) v10(48.85,142.99) v10(49.32,162.09) v10(49.62,130.26) v10(49.62,129.04) v10(49.62,127.82) v10(49.62,126.6) v10(50.11,164.56) v10(50.15,163.31) v10(50.26,141.77) v10(50.71,148.26) v10(50.76,147.01) v10(50.95,160.85) v10(50.92,145.77) v10(51.33,144.37) v10(51.39,142.99) v10(51.86,162.09) v10(52.16,130.26) v10(52.16,129.04) v10(52.16,127.82) v10(52.16,126.6) v10(52.65,164.56) v10(52.69,163.31) v10(52.8,141.78) v10(53.29,131.53) v10(53.44,148.54) v10(53.4,144.83) v10(53.49,160.85) v10(53.96,143.41) v10(54.19,145.03) v10(54.26,147.6) v10(54.29,145.84) v10(54.4,162.09) v10(54.37,151.21) v10(54.7,130.26) v10(54.7,129.04) v10(54.7,127.82) v10(54.7,126.6) v10(55.02,144.1) v10(55.19,164.56) v10(55.23,163.31) v10(55.24,150.33) v10(55.74,143.1) v10(55.65,131.57) v10(55.91,146.76) v10(56.01,147.57) v10(56.06,149.39) v10(56.16,153.01) v10(56.44,142.07) v10(56.54,158.88) v10(56.58,136.33) v10(56.58,133.79) v10(56.85,145.93) v10(57.03,152.13) v10(57.16,160.1) v10(57.19,140.9) v10(57.24,130.26) v10(57.24,129.04) v10(57.24,127.82) v10(57.24,126.6) v10(57.64,148.48) v10(57.58,144.93) v10(57.74,149.29) v10(57.82,161.49) v10(57.85,151.19) v10(57.9,138.68) v10(57.9,136.14) v10(57.9,133.6) v10(57.96,154.8) v10(58.16,162.98) v10(58.27,143.91) v10(58.65,147.73) v10(58.83,153.92) v10(59.02,142.74) v10(59.37,150.13) v10(59.37,146.73) v10(59.46,151.02) v10(59.65,152.99) v10(59.84,141.47) v10(59.78,126.6) v10(59.95,130.21) v10(60.07,145.7) v10(60.3,151.86) v10(60.46,150.77) v10(60.57,149.41) v10(60.82,144.54) v10(60.78,132.93) v10(61.1,162.09) v10(61.1,160.87) v10(61.1,159.65) v10(61.1,158.43) v10(61.1,157.21) v10(61.1,155.99) v10(61.1,154.77) v10(61.1,153.55) v10(61.1,152.33) v10(61.63,143.26) v10(61.62,131.98) v10(61.74,149.83) v10(61.95,151.12) v10(62.02,147.35) v10(62.19,148.64) v10(62.32,126.6) v10(62.56,146.18) v10(62.57,134.73) v10(63.15,131.53) v10(63.42,133.78) v10(63.64,162.09) v10(63.64,160.87) v10(63.64,159.65) v10(63.64,158.43) v10(63.64,157.21) v10(63.64,155.99) v10(63.64,154.77) v10(63.64,153.55) v10(63.64,152.33) v10(63.64,151.14) v10(63.64,149.92) v10(63.64,148.7) v10(63.64,147.48) v10(63.64,146.26) v10(63.59,144.75) v10(63.99,130.58) v10(64.94,133.32) v10(65.78,132.37) v10(66.18,160.87) v10(66.18,159.65) v10(66.18,158.43) v10(66.18,157.21) v10(66.18,155.99) v10(66.18,154.77) v10(66.18,153.55) v10(66.18,152.33) v10(66.18,151.14) v10(66.18,149.92) v10(66.18,148.7) v10(66.18,147.48) v10(66.18,146.26) v10(66.16,145) v10(67.6,134.15) v10(68.72,162.09) v10(68.72,160.87) v10(68.72,159.65) v10(68.72,158.43) v10(68.72,157.21) v10(68.72,155.99) v10(68.72,154.77) v10(68.72,153.55) v10(68.72,152.33) v10(68.72,151.14) v10(68.72,149.92) v10(68.72,148.7) v10(68.72,147.48) v10(68.72,146.26) v10(68.72,145.04) v10(68.72,143.82) v10(68.72,141.38) v10(70.05,136.28) v10(71.26,162.09) v10(71.26,160.87) v10(71.26,159.65) v10(71.26,158.43) v10(71.26,157.21) v10(71.26,155.99) v10(71.26,154.77) v10(71.26,153.55) v10(71.26,152.33) v10(71.26,151.14) v10(71.26,149.92) v10(71.26,148.7) v10(71.26,147.48) v10(71.26,146.26) v10(71.26,145.04) v10(71.26,143.82) v10(71.26,142.6) v10(71.26,141.38) v10(73.8,162.09) v10(73.8,160.87) v10(73.8,159.65) v10(73.8,158.43) v10(73.8,157.21) v10(73.8,155.99) v10(73.8,154.77) v10(73.8,153.55) v10(73.8,152.33) v10(73.8,151.14) v10(73.8,149.92) v10(73.8,148.7) v10(73.8,147.48) v10(73.8,146.26) v10(73.8,145.04) v10(73.8,143.82) v10(73.8,142.6) v10(73.8,141.38) v10(73.88,130.87) v10(76.34,162.09) v10(76.34,160.87) v10(76.34,159.65) v10(76.34,158.43) v10(76.34,157.21) v10(76.34,155.99) v10(76.34,154.77) v10(76.34,153.55) v10(76.34,152.33) v10(76.34,151.14) v10(76.34,149.92) v10(76.34,148.7) v10(76.34,147.48) v10(76.34,146.26) v10(76.34,145.04) v10(76.34,143.82) v10(76.34,141.38) v10(76.55,134.49) v10(78.88,162.09) v10(78.88,160.87) v10(78.88,159.65) v10(78.88,158.43) v10(78.88,157.21) v10(78.88,155.99) v10(78.88,154.77) v10(78.88,153.55) v10(78.88,152.33) v10(78.88,151.14) v10(78.88,149.92) v10(78.88,148.7) v10(78.88,147.48) v10(78.88,146.26) v10(78.88,145.04) v10(78.88,143.82) v10(78.88,142.6) v10(78.88,141.38) v10(81.04,130.88) v10(81.42,162.09) v10(81.42,160.87) v10(81.42,159.65) v10(81.42,158.43) v10(81.42,157.21) v10(81.42,155.99) v10(81.42,154.77) v10(81.42,153.55) v10(81.42,152.33) v10(81.42,151.14) v10(81.42,149.92) v10(81.42,148.7) v10(81.42,147.48) v10(81.42,146.26) v10(81.42,145.04) v10(81.42,143.82) v10(81.42,142.6) v10(81.42,141.38) v10(83.68,134.49) v10(83.96,162.09) v10(83.96,160.87) v10(83.96,159.65) v10(83.96,158.43) v10(83.96,157.21) v10(83.96,155.99) v10(83.96,154.77) v10(83.96,153.55) v10(83.96,152.33) v10(83.96,151.14) v10(83.96,149.92) v10(83.96,148.7) v10(83.96,147.48) v10(83.96,146.26) v10(83.96,145.04) v10(83.96,143.82) v10(83.96,142.6) v10(83.96,141.38) v10(86.5,162.09) v10(86.5,160.87) v10(86.5,159.65) v10(86.5,158.43) v10(86.5,157.21) v10(86.5,155.99) v10(86.5,154.77) v10(86.5,153.55) v10(86.5,152.33) v10(86.5,151.14) v10(86.5,149.92) v10(86.5,148.7) v10(86.5,147.48) v10(86.5,146.26) v10(86.5,145.04) v10(86.5,143.82) v10(86.5,142.6) v10(86.46,130.9) v10(86.76,141.39) v10(89.04,162.09) v10(89.04,160.87) v10(89.04,159.65) v10(89.04,158.43) v10(89.04,157.21) v10(89.04,155.99) v10(89.04,154.77) v10(89.04,153.55) v10(89.04,152.33) v10(89.04,151.14) v10(89.04,149.92) v10(89.04,148.7) v10(89.04,147.48) v10(89.04,146.26) v10(89.04,145.04) v10(89.04,143.82) v10(89.04,142.6) v10(91.4,134.48) v10(91.58,162.09) v10(91.58,160.87) v10(91.58,159.65) v10(91.58,158.43) v10(91.58,157.21) v10(91.58,155.99) v10(91.58,154.77) v10(91.58,153.55) v10(91.58,152.33) v10(91.58,151.14) v10(91.58,149.92) v10(91.58,148.7) v10(91.58,147.48) v10(91.58,146.26) v10(91.58,145.04) v10(91.58,142.6) v10(92.91,89.37) v10(94.12,162.09) v10(94.12,160.87) v10(94.12,159.65) v10(94.12,158.43) v10(94.12,157.21) v10(94.12,155.99) v10(94.12,154.77) v10(94.12,153.55) v10(94.12,152.33) v10(94.12,151.14) v10(94.12,149.92) v10(94.12,148.7) v10(94.12,147.48) v10(94.12,146.26) v10(94.12,145.04) v10(94.12,143.82) v10(94.12,142.6) v10(94.12,141.38) v10(96.35,125.81) v10(96.66,162.09) v10(96.66,160.87) v10(96.66,159.65) v10(96.66,158.43) v10(96.66,157.21) v10(96.66,155.99) v10(96.66,154.77) v10(96.66,153.55) v10(96.66,152.33) v10(96.66,151.14) v10(96.66,149.92) v10(96.66,148.7) v10(96.66,147.48) v10(96.66,146.26) v10(96.66,145.04) v10(96.66,143.82) v10(96.66,142.6) v10(97.21,127.48) v10(98.28,130.18) v10(99.2,162.09) v10(99.2,160.87) v10(99.2,159.65) v10(99.2,158.43) v10(99.2,157.21) v10(99.2,155.99) v10(99.2,154.77) v10(99.2,153.55) v10(99.2,152.33) v10(99.2,151.14) v10(99.2,149.92) v10(99.2,148.7) v10(99.2,147.48) v10(99.2,146.26) v10(99.2,145.04) v10(99.2,143.82) v10(99.2,142.6) v10(99.2,141.38) v10(99.2,134.5) v10(99.47,128.8) v10(99.78,131.12) v10(101.74,162.09) v10(101.74,160.87) v10(101.74,159.65) v10(101.74,158.43) v10(101.74,157.21) v10(101.74,155.99) v10(101.74,154.77) v10(101.74,153.55) v10(101.74,151.14) v10(101.74,149.92) v10(101.74,148.7) v10(101.74,147.48) v10(101.74,146.26) v10(101.74,145.04) v10(101.74,143.82) v10(101.74,142.6) v10(101.74,141.38) v10(103.22,137.56) v10(103.69,83.85) v10(104.28,162.09) v10(104.28,160.87) v10(104.28,159.65) v10(104.28,158.43) v10(104.28,157.21) v10(104.28,155.99) v10(104.28,154.77) v10(104.28,153.55) v10(104.28,152.33) v10(104.28,151.14) v10(104.28,149.92) v10(104.28,148.7) v10(104.28,147.48) v10(104.28,146.26) v10(104.28,145.04) v10(104.28,143.82) v10(104.28,142.6) v10(104.28,141.38) v10(104.49,137.56) v10(106.82,162.09) v10(106.82,160.87) v10(106.82,159.65) v10(106.82,158.43) v10(106.82,157.21) v10(106.82,155.99) v10(106.82,154.77) v10(106.82,153.55) v10(106.82,152.33) v10(106.82,151.14) v10(106.82,149.92) v10(106.82,148.7) v10(106.82,147.48) v10(106.82,146.26) v10(106.82,145.04) v10(106.82,143.82) v10(106.82,142.6) v10(106.82,141.38) v10(107.47,133.18) v10(109.36,162.09) v10(109.36,160.87) v10(109.36,159.65) v10(109.36,158.43) v10(109.36,157.21) v10(109.36,155.99) v10(109.36,154.77) v10(109.36,153.55) v10(109.36,151.14) v10(109.36,149.92) v10(109.36,148.7) v10(109.36,147.48) v10(109.36,146.26) v10(109.36,145.04) v10(109.36,143.82) v10(109.36,142.6) v10(109.36,141.38) v10(110.97,133.18) v10(111.71,127.56) v10(111.9,162.09) v10(111.9,160.87) v10(111.9,159.65) v10(111.9,158.43) v10(111.9,157.21) v10(111.9,155.99) v10(111.9,154.77) v10(111.9,153.55) v10(111.9,152.33) v10(111.9,151.14) v10(111.9,149.92) v10(111.9,148.7) v10(111.9,147.48) v10(111.9,146.26) v10(111.9,145.04) v10(111.9,143.82) v10(111.9,142.6) v10(111.9,141.38) v10(112.66,91.59) v10(113.3,121.09) v10(113.55,92.46) v10(114.07,110.64) v10(114.09,104.46) v10(114.31,133.78) v10(114.44,162.09) v10(114.44,160.87) v10(114.44,159.65) v10(114.44,158.43) v10(114.44,157.21) v10(114.44,155.99) v10(114.44,154.77) v10(114.44,153.55) v10(114.44,152.33) v10(114.44,151.14) v10(114.44,149.92) v10(114.44,148.7) v10(114.44,147.48) v10(114.44,146.26) v10(114.44,145.04) v10(114.44,143.82) v10(114.44,142.6) v10(114.89,92.2) v10(115.07,93.65) v10(115.27,92.66) v10(115.53,101.64) v10(115.71,162.09) v10(115.8,128.15) v10(116.12,123.98) v10(116.1,118.93) v10(116.89,143.63) v10(116.98,162.09) v10(116.98,160.87) v10(116.98,159.65) v10(116.98,158.43) v10(116.98,157.21) v10(116.98,155.99) v10(116.98,154.77) v10(116.98,153.55) v10(116.98,152.33) v10(116.98,151.14) v10(116.98,149.92) v10(116.98,148.7) v10(116.98,147.48) v10(116.98,146.26) v10(117,144.99) v10(117.19,125.96) v10(117.16,120.87) v10(117.5,136.27) v10(118.56,133.66) v10(118.92,129.83) v10(118.97,141.76) v10(118.97,135.67) v10(119.04,103.55) v10(119.06,113.85) v10(119.34,143.09) v10(119.52,162.09) v10(119.52,160.87) v10(119.52,159.65) v10(119.52,158.43) v10(119.52,157.21) v10(119.52,155.99) v10(119.52,154.77) v10(119.52,153.55) v10(119.52,152.33) v10(119.52,151.14) v10(119.52,149.92) v10(119.52,148.7) v10(119.52,147.48) v10(119.52,146.26) v10(119.5,144.67) v10(120,140.02) v10(120.22,117.03) v10(120.32,123.52) v10(120.56,143.72) v10(121.02,139.64) v10(121.32,133.23) v10(122.06,162.09) v10(122.06,160.87) v10(122.06,159.65) v10(122.06,158.43) v10(122.06,157.21) v10(122.06,155.99) v10(122.06,154.77) v10(122.06,153.55) v10(122.06,152.33) v10(122.06,151.14) v10(122.06,149.92) v10(122.41,137.79) v10(122.63,148.18) v10(122.64,127.41) v10(122.88,146.15) v10(122.91,133.4) v10(123.15,129.44) v10(123.22,153.37) v10(123.36,149.26) v10(123.74,130.74) v10(124.23,154.31) v10(124.22,151) v10(124.21,95.66) v10(124.26,142.98) v10(124.43,146.38) v10(124.6,162.09) v10(124.6,160.87) v10(124.6,159.65) v10(124.6,158.39) v10(124.61,157.06) v10(124.64,155.59) v10(124.67,144.35) v10(125.04,127.02) v10(125.08,151.86) v10(125.06,124.77) v10(125.15,147.47) v10(125.94,152.72) v10(125.9,133.89) v10(125.93,129.58) v10(125.89,122.91) v10(125.95,159.34) v10(125.95,156.13) v10(125.97,148.86) v10(126.39,130.85) v10(126.73,161.86) v10(126.88,124.65) v10(127.1,133.61) v10(127.08,122.02) v10(127.06,92.2) v10(127.2,160.08) v10(127.2,156.63) v10(127.2,153.19) v10(127.2,149.74) v10(127.2,145.43) v10(127.2,141.82) v10(127.26,123.44) v10(127.64,132.58) v10(127.68,130.85) v10(127.73,125.84) v10(128.1,133.82) v10(128.16,129.58) v10(128.44,158.85) v10(128.44,155.4) v10(128.44,151.95) v10(128.44,148.5) v10(128.44,144.2) v10(128.44,140.59) v10(128.47,160.61) v10(128.46,105.48) v10(128.74,121.9) v10(128.71,91.39) v10(128.91,119.25) v10(129.3,129.58) v10(129.41,133.85) v10(129.68,159.33) v10(129.68,155.87) v10(129.68,152.44) v10(129.68,148.99) v10(129.68,141.13) v10(129.76,130.83) v10(129.78,120.22) v10(129.87,132.58) v10(130.84,122.21) v10(130.84,114.59) v10(130.84,112.05) v10(130.84,109.51) v10(130.92,158.12) v10(130.92,154.63) v10(130.92,151.19) v10(130.92,147.75) v10(130.92,143.93) v10(130.92,139.88) v10(130.99,126.57) v10(131.05,130.83) v10(131.45,127.82) v10(131.53,129.58) v10(132.01,119.68) v10(132.01,117.14) v10(132.01,114.6) v10(132.01,112.06) v10(132.01,105.48) v10(132.27,156.77) v10(132.26,153.3) v10(132.26,149.86) v10(132.26,146.42) v10(132.25,142.53) v10(132.25,138.48) v10(132.74,127.82) v10(132.89,137.34) v10(133.18,134.9) v10(133.17,132.31) v10(133.19,129.81) v10(133.22,126.57) v10(133.17,114.57) v10(133.17,112.03) v10(133.17,109.58) v10(133.5,153.78) v10(133.5,152.06) v10(133.5,150.34) v10(133.5,146.9) v10(133.5,145.18) v10(133.5,143.46) v10(134.4,134.91) v10(134.4,132.37) v10(134.4,129.83) v10(134.4,127.29) v10(134.4,124.75) v10(134.4,122.21) v10(134.4,119.67) v10(134.4,117.13) v10(134.4,114.59) v10(134.4,112.05) v10(134.4,109.51) v10(134.4,106.97) v10(134.74,147.38) v10(134.74,145.66) v10(134.84,150.73) v10(135.06,139.73) v10(135.57,105.48) v10(135.57,104.6) v10(135.59,102.62) v10(135.65,134.92) v10(135.65,132.38) v10(135.65,129.84) v10(135.65,127.3) v10(135.65,124.76) v10(135.65,122.22) v10(135.65,119.68) v10(135.66,116.58) v10(135.65,114.6) v10(135.65,112.06) v10(136.08,151.2) v10(136.08,149.49) v10(136.08,147.77) v10(136.08,140.88) v10(136.34,144.04) v10(136.38,142.28) v10(136.9,121.35) v10(137.35,151.72) v10(137.43,149.85) v10(137.51,146.33) v10(137.58,142.81) v10(137.65,139.29) v10(138.3,121.35) v10(138.37,147.19) v10(138.44,143.67) v10(138.51,140.15) v10(138.76,136.15) v10(139.03,129.25) v10(139.03,126.71) v10(139.03,121.63) v10(139.03,119.09) v10(139.03,116.55) v10(139.03,114.01) v10(139.03,111.47) v10(139.03,108.93) v10(139.03,106.39) v10(139.15,149.92) v10(139.23,148.05) v10(139.3,144.53) v10(139.48,137.43) v10(140.16,145.4) v10(140.24,141.88) v10(140.28,131.79) v10(140.28,129.25) v10(140.28,126.71) v10(140.28,124.17) v10(140.28,121.63) v10(140.28,119.09) v10(140.28,116.55) v10(140.29,113.59) v10(140.28,111.47) v10(140.94,148.13) v10(141.03,146.26) v10(141.1,142.74) v10(141.26,139.02) v10(141.45,135.8) v10(141.53,134.33) v10(141.53,129.25) v10(141.53,126.71) v10(141.53,124.17) v10(141.53,121.63) v10(141.53,119.09) v10(141.53,116.55) v10(141.53,111.47) v10(141.96,143.6) v10(142.03,140.05) v10(142.74,146.33) v10(142.67,136.25) v10(142.82,144.46) v10(142.78,134.33) v10(142.78,131.79) v10(142.78,129.25) v10(142.78,124.17) v10(142.78,121.63) v10(142.78,116.55) v10(142.78,108.93) v10(142.78,106.39) v10(142.89,140.94) v10(143.55,137.76) v10(143.76,141.8) v10(144.03,134.33) v10(144.03,131.79) v10(144.03,129.25) v10(144.03,124.17) v10(144.03,121.63) v10(144.03,119.09) v10(144.03,116.55) v10(144.54,144.53) v10(144.58,138.56) v10(145.16,106.35) v10(145.38,135.93) v10(145.42,134.33) v10(145.42,131.79) v10(145.42,129.25) v10(145.42,126.71) v10(145.42,124.17) v10(145.42,121.63) v10(145.37,119.13) v10(146.65,137.36) v10(146.67,134.33) v10(146.67,131.79) v10(146.67,129.25) v10(146.67,126.71) v10(146.67,124.17) v10(146.72,117.87) v10(146.77,143.48) v10(146.79,122.44) v10(147.92,139.41) v10(147.92,136.87) v10(147.92,134.33) v10(147.92,131.79) v10(147.92,129.25) v10(147.92,124.17) v10(147.87,122.44) v10(147.98,126.29) v10(148.53,141.84) v10(149.05,126.29) v10(149.17,134.33) v10(149.17,131.79) v10(149.17,129.25) v10(149.17,124.17) v10(150.49,104.59) v10(151.13,104.59) v10(153.95,104.59) v10(154.58,104.59) v10(157.4,104.59) v10(158.03,104.59) v11(32.84,15.95) v11(33.64,125.48) v11(35.39,149.42) v11(35.39,129.1) v11(36.65,149.42) v11(36.65,129.1) v11(39.39,149.42) v11(39.39,129.1) v11(40.65,149.42) v11(40.65,129.1) v11(43.39,149.42) v11(43.67,38.29) v11(44.65,149.42) v11(47.39,149.42) v11(48.65,149.42) v11(57.46,177.58) v11(87.44,85.15) v11(88.96,114.14) v11(88.96,113.64) v11(88.96,113) v11(88.96,112.5) v11(88.96,111.85) v11(88.96,111.35) v11(88.96,110.71) v11(88.96,110.21) v11(88.96,109.57) v11(88.96,109.07) v11(89.29,91.35) v11(89.29,90.59) v11(90.05,91.35) v11(90.05,90.59) v11(90.81,90.59) v11(91.06,89.53) v11(91.25,113) v11(91.25,112.5) v11(91.25,111.85) v11(91.25,111.35) v11(91.25,110.71) v11(91.25,110.21) v11(91.25,109.57) v11(91.25,109.07) v11(92.25,89.37) v11(92.17,88.41) v11(92.17,87.26) v11(92.34,90.4) v11(92.39,91.47) v11(92.67,120.36) v11(92.91,89.37) v11(93.1,90.4) v11(93.15,91.47) v11(93.91,91.47) v11(93.86,90.4) v11(95.27,72.04) v11(95.92,89.56) v11(95.92,88.8) v11(96.35,125.81) v11(96.47,65.18) v11(96.6,89.38) v11(96.66,131.48) v11(96.68,88.8) v11(97.21,127.48) v11(97.44,88.8) v11(97.67,131.48) v11(97.8,89.46) v11(98.07,81.19) v11(98.28,130.18) v11(98.45,66.2) v11(98.53,70.39) v11(98.71,69.5) v11(98.99,72.3) v11(98.99,71.79) v11(99.23,131.99) v11(99.47,128.8) v11(99.49,77.11) v11(99.78,131.12) v11(100.95,81.69) v11(100.95,80.68) v11(100.95,77.12) v11(100.95,76.05) v11(100.95,73.82) v11(100.95,72.68) v11(100.95,71.53) v11(101.41,79.79) v11(101.41,79.28) v11(101.45,85.3) v11(103.1,71.53) v11(103.22,137.56) v11(103.76,79.61) v11(104.49,137.56) v11(105.44,120.7) v11(105.71,28.91) v11(108.71,120.6) v11(109.25,62.1) v11(112.12,62.07) v11(112.4,135.39) v11(114.13,115.87) v11(114.18,119.98) v11(114.8,134.24) v11(115.6,113.65) v11(116.07,129.78) v11(116.25,128.63) v11(116.25,127.49) v11(116.25,126.35) v11(116.25,125.2) v11(116.38,63.04) v11(117.09,124.06) v11(117.51,113.65) v11(118.92,129.83) v11(118.95,135.22) v11(120.08,132.68) v11(120.2,113.62) v11(121.93,90.51) v11(122.64,127.41) v11(122.72,90.51) v11(123.15,129.44) v11(123.53,91.15) v11(123.53,90.47) v11(124.32,90.71) v11(125.13,90.51) v11(125.93,129.58) v11(125.89,122.91) v11(125.92,90.51) v11(126.39,130.85) v11(126.7,90.71) v11(127.08,122.02) v11(127.26,123.44) v11(127.64,132.58) v11(127.68,130.85) v11(128.1,133.82) v11(128.16,129.58) v11(128.39,90.84) v11(128.46,105.48) v11(128.49,100.1) v11(128.58,165.94) v11(128.74,121.9) v11(128.93,90.44) v11(128.99,100.1) v11(129.3,129.58) v11(129.41,133.85) v11(129.76,130.83) v11(129.87,132.58) v11(130.39,100.1) v11(130.89,100.1) v11(130.99,126.57) v11(131.05,130.83) v11(131.15,56.8) v11(131.45,127.82) v11(131.53,129.58) v11(132.01,105.48) v11(132.3,100.1) v11(132.74,127.82) v11(132.8,100.1) v11(133.22,126.57) v11(133.24,87.25) v11(134.45,100.1) v11(134.95,100.1) v11(134.97,87.25) v11(135.57,105.48) v11(135.57,104.6) v11(135.59,102.62) v11(136.44,131.22) v11(136.9,121.35) v11(136.94,89.34) v11(136.94,88.3) v11(136.94,87.26) v11(136.94,86.24) v11(137.19,155.99) v11(137.45,147.5) v11(138.3,121.35) v11(138.59,155.7) v11(138.59,147.5) v11(139.14,131.22) v11(139.73,147.5) v11(140.54,150.88) v11(140.88,147.5) v11(142.02,147.5) v11(143.16,147.5) v11(144.31,147.5) v11(145.22,92.38) v11(145.22,84.75) v11(145.22,71.16) v11(145.22,63.42) v11(145.45,147.5) v11(146.72,148.14) v11(147.86,148.14) v11(149.35,176.78) v11(149.53,162.41) v11(150.49,104.59) v11(151.13,104.59) v11(153.95,104.59) v11(154.58,104.59) v11(157.4,104.59) v11(158.03,104.59) v11(161.01,172.19) v11(161.29,104.12) v11(162.97,104.12) v11(164.62,104.12) v11(166.23,104.12) v11(172.47,77.51) v11(181.77,177.41) v11(182.72,177.41) v11(186.17,33.15) v11(190.64,177.86) v11(191.8,39.03) v11(192.95,39.03) v11(194.24,62.29) v11(194.55,49.19) v11(196,21.38) v11(200.55,61.15) v11(205.04,144.09) v11(212.4,145.53) v12(229.97,168.08) v12(229.97,166.3) v12(229.97,164.52) v12(229.97,162.75) v12(231.09,174.61) v12(231.09,172.83) v12(231.09,171.05) v12(231.75,168.08) v12(231.75,166.3) v12(231.75,164.52) v12(231.75,162.75) v12(232.87,174.61) v12(232.87,172.83) v12(232.87,171.05) v12(233.53,168.08) v12(233.53,166.3) v12(233.53,164.52) v12(233.53,162.75) v12(234.65,176.39) v12(234.65,174.61) v12(234.65,172.83) v12(234.65,171.05) v12(235.36,164.52) v12(235.36,162.75) v12(235.36,160.97) v12(235.36,156.6) v12(235.36,154.82) v12(235.36,153.04) v12(235.36,143.57) v12(235.36,141.79) v12(235.36,140.01) v12(235.36,135.64) v12(235.36,133.87) v12(235.36,132.09) v12(237.14,164.52) v12(237.14,162.75) v12(237.14,160.97) v12(237.14,156.6) v12(237.14,154.82) v12(237.14,153.04) v12(237.14,143.57) v12(237.14,141.79) v12(237.14,140.01) v12(237.14,135.64) v12(237.14,133.87) v12(237.14,132.09) v12(238.92,164.52) v12(238.92,162.75) v12(238.92,160.97) v12(238.92,156.6) v12(238.92,154.82) v12(238.92,153.04) v12(238.92,143.57) v12(238.92,141.79) v12(238.92,140.01) v12(238.92,135.64) v12(238.92,133.87) v12(238.92,132.09) v12(238.92,114.82) v12(238.92,113.04) v12(238.92,111.26) v12(240.7,164.52) v12(240.7,162.75) v12(240.7,160.97) v12(240.7,156.6) v12(240.7,154.82) v12(240.7,153.04) v12(240.7,143.57) v12(240.7,141.79) v12(240.7,140.01) v12(240.7,135.64) v12(240.7,133.87) v12(240.7,132.09) v12(240.7,114.82) v12(240.7,113.04) v12(240.7,111.26) v12(240.7,109.48) v12(240.7,107.7) v12(240.7,105.93) v12(240.7,104.15) v12(240.7,102.37) v12(240.7,100.59) v12(240.7,98.81) v12(242.48,164.52) v12(242.48,162.75) v12(242.48,160.97) v12(242.48,156.6) v12(242.48,154.82) v12(242.48,153.04) v12(242.48,143.57) v12(242.48,141.79) v12(242.48,140.01) v12(242.48,135.64) v12(242.48,133.87) v12(242.48,132.09) v12(242.48,114.82) v12(242.48,113.04) v12(242.48,111.26) v12(242.48,109.48) v12(242.48,107.7) v12(242.48,105.93) v12(242.48,104.15) v12(242.48,102.37) v12(242.48,100.59) v12(242.48,98.81)
