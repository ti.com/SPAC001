# Allegro board PROC184E1_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSYS_MCUIO_1V8_IN+: length 4.8
  TOP w0.127: U121.D3 178.21,34.98 U120.10 178.21,37.02 178,37.23 C391.2 178,38.18 177.89,38.3 R574.1
VSYS_MCUIO_1V8_IN-: length 6.3
  TOP w0.127: 179.41,34.58 179.41,34.79 179.21,34.99 U120.8 179.21,36.86 178.92,37.15 ; 179.41,34.58 U121.D1 ; 179.41,34.58 U121.D2 ; 178.92,37.15 178.71,36.94 U120.9 ; 178.92,37.15 C391.1 178.92,38.22 179.04,38.34 R575.1
VSYS_MCUIO_1V8_N: length 43.3
  TOP w0.127: R575.2 179.04,40.27 179.17,40.41 v2(179.17,41.03)
  L7-SIGNAL3 w0.109: v2(179.17,41.03) 178.74,41.03 178.63,40.93 178.63,40.47 178.37,40.21 176.65,40.21 173.74,43.11 170.93,43.11 163,51.04 163,53.15 163,64.09 166.76,67.85 166.76,69.52 v2(166.33,69.94)
VSYS_MCUIO_1V8_P: length 42.4
  TOP w0.127: R574.2 177.89,40.27 177.76,40.4 v2(177.76,41.03)
  L7-SIGNAL3 w0.109: v2(167.09,69.94) 167.01,69.87 167.01,67.77 163.23,63.99 163.23,53.17 163.23,51.14 170.98,43.39 173.86,43.39 176.8,40.45 178.18,40.45 178.39,40.67 178.39,40.87 178.23,41.03 v2(177.76,41.03)
VSYS_MCUIO_3V3: length 686.2
  TOP w0.254: U111.5 v2(92.94,36.51) ; U82.4 197.53,99.1 197.96,98.67 C329.1 ; R422.2 62.73,70.85 v2(62.73,72.12) R419.2 ; C249.1 97.83,87.77 96.92,86.86 R353.1 95.38,86.65 93.28,84.55 v2(93.28,82.86) ; C249.1 98.52,87.93 98.52,87.93 U55.4 ; C249.1 97.83,88.25 R336.1 ; v2(64.97,45.22) U102.5 ; R478.1 27.49,58.61 27.77,58.88 27.77,59.16 27.93,59.32 v2(28.57,59.32) U78.8 ; R472.1 v2(191.19,100.05) ; U150.5 138.35,9.16 138.35,8.35 137.73,7.73 v2(137.65,7.73) ; U241.17 120.29,47.86 120,48.15 C1080.1 v2(120,49.48) ; v2(199.46,97.79) 199.03,97.79 198.78,98.05 C329.1 ; v2(80.25,38.31) 80.51,38.57 U104.6 ; C437.1 103.7,26.09 v2(103.89,25.9) ; v2(84.69,41.78) U101.5 ; C329.1 198.78,99.29 198.83,99.34 R499.1 ; v2(123.79,42.44) 124.29,42.94 U241.30 ; U241.1 128.94,47.61 v4(129.15,47.81) C1086.2 ; U149.5 128.54,9.16 128.54,8.35 127.93,7.73 v2(127.85,7.73) ; U47.16 v2(29.61,106.13) ; R673.2 v2(239.68,18.42) ; R470.1 94.22,25.56 v2(94.37,25.71) ; v2(98.98,29.55) 98.79,29.36 C424.1 ; R445.1 v2(28.57,66.38) ; R232.1 v2(18.89,112.43) ; U127.5 v2(130.01,28.5)
  L3-SIGNAL1 w0.305: v2(21.83,76.87) 21.37,76.87 20.05,75.55 20.05,73.21 20.48,72.78 20.48,67.72 21.4,66.81 21.4,61.11 v2(22.25,60.26) ; v2(199.46,97.79) 194.13,97.79 R472.1 v2(191.19,100.05)
  L7-SIGNAL3 w0.254: v2(28.57,59.32) v2(28.57,66.38) ; v2(28.57,59.32) 26.77,61.12 23.11,61.12 v2(22.25,60.26) ; v2(28.57,59.32) 26.75,57.5 26.75,47.87 v2(26.06,47.18)
  L7-SIGNAL3 w0.381: v2(84.69,41.78) 85.62,41.78 86.46,40.94 v2(90.48,40.94) 92.94,38.49 v2(92.94,36.51) ; v2(18.89,112.43) 23.77,107.55 24.38,107.55 v2(24.5,107.44) 25.8,106.13 v2(29.61,106.13)
  L8-PWR1 w0.381: 56.82,74.88 56.82,78.66 59.84,81.68 73.63,81.68 77.22,85.27 83.96,85.27 85.23,84 86.9,84 88.04,82.86 v2(93.28,82.86) ; v2(239.68,18.42) 231.7,18.42 228.51,15.24 227.21,15.24 225.6,13.63 212.87,13.63 210.2,16.3 199.15,16.3 ; 60.65,30.17 48.52,30.17 46.01,27.66 23.26,27.66 21.43,29.48 21.43,48.82 19.03,51.22 19.03,57.57 19.77,58.31 19.77,71.3 17.51,73.56 17.51,74.59 v2(16.33,75.78) 20.36,75.78 21.46,76.87 v2(21.83,76.87) 21.83,77.9 v2(20.29,79.44) 20.66,79.81 v2(20.66,80.78) 20.79,80.78 v2(21.93,81.92) 21.93,84.08 v2(20.66,85.35) 16.19,89.83 16.19,108.76 18.89,111.47 v2(18.89,112.43)
  L10-SIGNAL4 w0.305: v2(239.68,18.42) 239.68,23.91 240.85,25.08 240.85,97.14 239.81,98.17 239.81,117.17 241.29,118.65 v2(241.29,121.24)
  L14-SIGNAL6 w0.254: 170.49,81.52 171.33,81.52 173.57,83.75 173.57,85.71 174.58,86.72 174.58,88.78 179.76,93.96 179.76,101 180.37,101.61 180.37,106.84 175.17,112.05 175.17,114.33 174.07,115.43 164.51,115.43 162.33,117.61 162.33,129.26 164.73,131.66 164.73,157.23 162.62,159.34 157.97,159.34 156.65,158.02 154.43,158.02 v2(154.16,157.75)
  L14-SIGNAL6 w0.305: v2(166.26,33.65) 166.27,33.65 167.49,32.42 v2(182.78,32.42) ; v2(191.19,100.05) 191.19,96.01 187.51,92.33 187.51,73.51 183.98,69.98 183.98,56.03 188.63,51.38 190.96,51.38 v2(192.26,50.08)
  L14-SIGNAL6 w0.381: 170.49,81.52 167.78,78.8 167.78,72.12 v2(167.25,71.59)
  BOTTOM w0.203: U244.16 62.8,50.12 63.31,49.61 v2(63.73,49.61)
  BOTTOM w0.254: v2(103.89,25.9) 103.76,25.77 U261.41 ; v2(182.78,32.42) 182.92,32.28 U259.1 ; U270.1 189.17,16.83 189.03,16.69 v2(188.42,16.69) ; U233.24 55.76,67.34 56.49,68.08 C1056.1 ; U250.8 193.41,48.43 193.63,48.65 C1122.1 193.63,50.02 v2(193.73,50.12) ; C1056.1 56.24,68.79 54.92,68.79 54.74,68.61 U233.23 ; C1056.1 56.96,68.76 v2(57.2,69.01) ; R1158.2 73.08,48.32 v4(73.06,48.34) ; v2(98.98,29.55) 99.11,29.42 U261.30 ; v2(195.88,40.66) 195.71,40.66 R1178.1 ; R1150.1 R1149.1 191.75,50.07 191.77,50.08 v2(192.26,50.08) ; U259.3 184.22,29.46 v2(183.9,29.14) ; U261.19 95.27,25.27 94.83,25.71 v2(94.37,25.71) ; v2(21.83,76.87) 21.28,76.87 21.07,76.66 U228.5 ; v2(57.94,28.88) 57.94,28.88 C1177.2 58.12,30.18 U257.5 ; U270.3 v2(191.64,18.13) ; R1179.1 v2(189.82,40.57) ; v2(26.06,47.18) U249.5 ; v2(16.33,75.78) R1038.2 R1034.2 ; v2(123.79,42.44) 124.29,42.94 C313.2
  BOTTOM w0.305: R1129.1 22.4,60.1 v2(22.25,60.26) ; R1136.2 v4(71.99,55.23)
  BOTTOM w0.381: R1246.2 v2(105.71,23.13)
  vias: v2(56.86,71.04) v2(79.37,39.45) v2(86.1,34.72) v2(90.67,5.34) v2(90.67,3.31) v2(91.28,27.41) v2(92.2,27.41) v2(100.61,31.19) v2(102.73,31.19) v2(105.71,30.06) v2(105.71,26.63) v2(105.71,19.82) v2(110.29,5.34) v2(119.95,24.59) v2(124.63,50.39) v2(134.87,10.7) v2(142.31,19.03) v2(144.68,10.7) v2(166.62,71.59) v4(79.05,61.37) v4(79.05,59.84) v4(80.58,61.37) v4(80.58,59.84) v4(82.1,61.37) v4(82.1,59.84) v4(129.93,49)
VSYS_MCUIO_3V3_IN+: length 4.8
  TOP w0.127: U116.D3 169.58,34.98 U117.10 169.58,37.02 169.37,37.23 C387.2 169.37,38.18 169.26,38.3 R570.1
VSYS_MCUIO_3V3_IN-: length 6.3
  TOP w0.127: R571.1 170.4,38.34 170.29,38.22 C387.1 170.29,37.15 ; 170.29,37.15 170.08,36.94 U117.9 ; 170.29,37.15 170.58,36.86 U117.8 170.58,34.99 170.78,34.79 170.78,34.58 ; 170.78,34.58 U116.D2 ; 170.78,34.58 U116.D1
VSYS_MCUIO_3V3_N: length 39.9
  TOP w0.127: R571.2 170.4,40.34 170.53,40.48 v2(170.53,41.03)
  L7-SIGNAL3 w0.109: v2(170.53,41.03) 170.12,41.03 169.91,40.82 169.91,40.39 169.66,40.14 168.61,40.14 168,40.75 168,45.27 162.52,50.75 162.52,53.14 162.52,64.37 163.6,65.45 163.6,70.38 164.63,71.41 165.63,71.41 v2(165.83,71.61)
VSYS_MCUIO_3V3_P: length 38.7
  TOP w0.127: v2(169.12,41.03) 169.12,40.43 169.26,40.29 R570.2
  L7-SIGNAL3 w0.109: v2(169.12,41.03) 169.54,41.03 169.65,40.93 169.65,40.5 169.54,40.4 168.72,40.4 168.23,40.88 168.23,45.37 162.76,50.84 162.76,53.14 162.76,64.25 163.84,65.33 163.84,70.27 164.7,71.13 165.56,71.13 v2(165.83,70.85)
VSYS_SENSE: length 106.6
  TOP w0.127: v2(175.13,79.46) 175.13,78.91 175.33,78.71 U68.51 ; R78.2 v2(162.76,162.7)
  L12-SIGNAL5 w0.102: v2(175.13,79.46) 172.11,79.46 170.67,80.9 170.67,85.57 171.01,85.9 171.01,89.91 170.35,90.57 170.35,101.79 165.16,106.98 158.57,106.98 157.23,108.32 157.23,123.4 156.32,124.31 156.32,138.87 153.37,141.82 153.37,156.14 155.38,158.15 156.94,158.15 160.47,161.68 161.74,161.68 v2(162.76,162.7)
VSYS_VDDSHV0_MCU: length 1.2
  BOTTOM w0.305: R1128.2 v2(22.4,58.71)
VSYS_VDDSHV2: length 149.6
  TOP w0.305: U153.5 167.93,8.21 167.45,7.73 v2(167.06,7.73)
  L7-SIGNAL3 w0.508: v2(171.54,20.24) 152.72,20.24 140.62,32.33 131.64,32.33 130.13,33.84 117.04,33.84 115.5,35.38 99.05,35.38 92.74,41.69 87.64,41.69 86.66,42.67 83.42,42.67 82.76,43.34 82.76,43.97 82.09,44.64 v2(77.44,44.64)
  L14-SIGNAL6 w0.381: v2(76.59,64.93) 76.59,45.48 v2(77.44,44.64) ; v2(167.06,7.73) 168.41,9.08 170.19,9.08 173.08,11.97 173.08,18.7 v2(171.54,20.24)
  BOTTOM w0.381: v2(76.59,64.93) 76.59,66.26 76.97,66.64 77.37,66.64 77.39,66.66 78.67,66.66 78.94,66.39 R1104.2 R1103.2
  vias: v2(17.97,123.68) v2(41.77,124.11)
VSYSMON_RESET#: length 5.5
  TOP w0.127: U113.7 227.26,34.58 227.14,34.7 225.84,34.7 225.59,34.45 224.89,34.45 R589.1 224.85,33.71 224.66,33.52 U123.1
VUSB_FT2232: length 13.1
  TOP w0.381: v2(194.22,9.06) 195.44,7.84 LD11.2 194.48,5.03 193.33,6.18 v2(190.84,6.18)
  TOP w0.508: LD11.2 195.44,2.59 TP251.1
  BOTTOM w0.254: U276.3 v2(194.22,9.06)
  vias: v2(190.84,7.02)
VUSB_FT4232: length 6.8
  TOP w0.381: LD12.2 216.95,4.81 216.07,5.7 v2(213.44,5.7)
  BOTTOM w0.254: U277.3 v2(216.8,8.58)
  vias: v2(213.44,6.54)
WKUP_GPIO0_0: length 91.4
  L3-SIGNAL1 w0.089: v5(109.18,54.08) 108.57,54.69 105.58,54.69 103.77,56.49 75.78,56.49 62.93,69.33 57.7,69.33 56.14,70.89 56.14,71.2 v2(55.3,72.04) ; v3(122.32,71.83) v5(122.59,71.6)
  L4-GND2 w0.102: v5(122.59,71.6) v6(122.29,71.3) ; v5(109.18,54.08) v6(109.51,54.08)
  L5-SIGNAL2 w0.102: v6(109.51,54.08) 110.4,54.08 111.09,53.38 115.44,53.38 121.57,59.51 121.57,70.28 122.29,71 v6(122.29,71.3)
  BOTTOM w0.127: R1065.1 54.41,71.8 54.65,72.04 v2(55.3,72.04)
  vias: v1(122.32,71.83)
WKUP_GPIO0_54: length 84
  TOP w0.127: v2(68.94,70.97) 68.92,70.97 67.6,72.29 R416.1
  L3-SIGNAL1 w0.089: v2(68.94,70.97) 68.94,67.57 69.5,67.01 69.5,64.15 76.22,57.43 105.19,57.43 105.95,56.67 110.36,56.67 111.49,55.54 111.49,53.95 v5(111.26,53.72) ; v3(122.32,72.63) v5(122.59,72.4)
  L4-GND2 w0.102: v5(122.59,72.4) v6(122.9,72.1) ; v5(111.26,53.72) v6(111.59,53.72)
  L5-SIGNAL2 w0.102: v6(122.9,72.1) 122.42,72.1 121.88,71.55 121.88,71.1 121.32,70.54 121.32,59.58 115.46,53.72 v6(111.59,53.72)
  vias: v1(122.32,72.63)
WKUP_GPIO0_57: length 183.6
  L3-SIGNAL1 w0.089: v2(107.91,39.99) 99.14,39.99 93.78,45.34 78.46,45.34 74.51,49.3 70.47,49.3 67.19,52.58 v2(66.06,52.58) 66.06,51.75 64.39,50.08 57.05,50.08 50.89,43.92 46.26,43.92 44.21,45.98 44.21,46.87 42.23,48.84 33.06,48.84 32.6,49.31 25.44,49.31 24.77,48.64 21.12,48.64 20.56,49.2 19.94,49.82 12.7,49.82 11.28,51.24 11.28,73.08 17.21,79.01 21.14,79.01 v2(21.56,79.44) ; v2(108.11,51.05) 108.24,50.93 111.44,50.93 118.01,57.5 118.01,69.12 v3(118.32,69.43)
  L7-SIGNAL3 w0.109: v2(107.91,39.99) 106.84,41.06 106.84,48.84 107.78,49.78 107.78,50.72 v2(108.11,51.05)
  BOTTOM w0.127: v2(66.06,52.58) 66.06,52.19 65.62,51.75 R1142.1
  vias: v1(118.32,69.43)
WKUP_I2C0_SCL: length 58.4
  TOP w0.127: v2(28.81,70.77) 28.81,68.92 27.34,67.44 v2(26.1,67.44) ; U78.2 28.07,62.64 27.8,62.36 26.2,62.36 R456.1 24.54,62.67 v2(23.34,63.87) 23.08,64.14 U73.6
  L5-SIGNAL2 w0.102: v2(26.1,67.44) 23.34,64.69 v2(23.34,63.87)
  L12-SIGNAL5 w0.102: v2(28.81,70.77) 30,71.96 30,78.16 31.73,79.89 31.73,95.22 30.08,96.88 30.08,100.07 31.65,101.63 v2(31.65,106.01)
  BOTTOM w0.127: J54.65 32.15,106.51 v2(31.65,106.01)
WKUP_I2C0_SDA: length 60.2
  TOP w0.127: U78.6 27.57,61.47 27.34,61.7 R463.1 24.33,61.7 v2(22.16,63.87) 22.43,64.14 U73.5 ; v2(26.1,66.17) 26.98,66.17 29.4,68.59 v2(29.4,70.01)
  L5-SIGNAL2 w0.102: v2(22.16,63.87) 22.59,63.44 23.52,63.44 23.95,63.86 23.95,64.15 25.97,66.17 v2(26.1,66.17)
  L12-SIGNAL5 w0.102: v2(29.4,70.01) 30.22,70.84 30.22,78.07 32.03,79.88 32.03,95.33 30.3,97.06 30.3,99.94 32.66,102.3 v2(32.66,106.01)
  BOTTOM w0.127: J54.63 v2(32.66,106.01)
WKUP_LFOSC_XI: length 147.7
  L3-SIGNAL1 w0.089: v2(108.54,49.05) 108.85,48.74 111.16,48.74 119.92,57.5 v3(119.92,68.63)
  L5-SIGNAL2 w0.102: v2(109.51,32.56) 129.38,32.56 v2(131.55,30.4)
  L7-SIGNAL3 w0.109: v2(64.56,53.63) 65.16,53.03 65.16,51.97 66.63,50.5 66.63,45.19 69.57,42.24 76.01,42.24 76.48,41.77 83,41.77 89.87,34.9 109.18,34.9 109.74,34.34 115.69,34.34 116.75,33.28 128.67,33.28 v2(131.55,30.4)
  L14-SIGNAL6 w0.089: v2(109.51,32.56) 108.47,33.6 108.47,34 106.99,35.47 106.99,45.87 108.57,47.45 108.57,49.02 v2(108.54,49.05)
  vias: v1(119.92,68.63)
WKUP_LFOSC_XI_OE: length 2.8
  TOP w0.127: U127.1 134.91,28.5 135.15,28.25 R619.1 R626.1
WKUP_LFOSC_XI_R: length 1.5
  TOP w0.127: R613.1 135.09,29.52 135.01,29.45 U127.2
WKUP_OSC0_XI: length 10.5
  TOP w0.127: Y6.3 C279.1 114.13,61.27 115.12,62.25 U59.A24
WKUP_OSC0_XO: length 9.4
  TOP w0.127: Y6.1 C270.1 112.3,64.01 112.3,67.34 112.96,68 113.62,68 113.92,68.29 113.92,69.04 U59.B25
WKUP_UART0_RXD: length 130.8
  L3-SIGNAL1 w0.089: v3(118.32,70.23) 117.82,69.73 117.82,68.51 117.74,68.43 117.74,57.53 111.64,51.44 v2(109.46,51.44)
  L5-SIGNAL2 w0.102: v2(189.16,18.78) 179.9,18.78 179.64,18.52 170.16,18.52 169.07,19.61 150.97,19.61 137.3,33.27 111.85,33.27 111.12,34.01 v2(109.33,34.01)
  L14-SIGNAL6 w0.089: v2(109.33,34.01) 110.24,34.01 110.6,34.37 110.6,35.03 109.48,36.14 109.48,39.07 110.09,39.68 110.09,50.8 v2(109.46,51.44)
  BOTTOM w0.127: U270.4 v2(189.16,18.78)
  vias: v1(118.32,70.23)
WKUP_UART0_TXD: length 130.4
  L3-SIGNAL1 w0.089: v3(119.12,70.23) 118.62,69.74 118.62,57.48 111.51,50.37 108.72,50.37 v2(108.52,50.17)
  L5-SIGNAL2 w0.102: v2(110.07,34.77) 110.8,34.77 112.07,33.5 137.4,33.5 151.07,19.83 171.71,19.83 171.96,20.08 v2(188.42,20.08)
  L14-SIGNAL6 w0.089: v2(110.07,34.77) 109.25,35.59 108.49,35.59 107.81,36.27 107.81,38.56 109.25,40.01 109.25,46.79 108.97,47.07 108.97,49.71 v2(108.52,50.17)
  BOTTOM w0.127: U270.6 v2(188.42,20.08)
  vias: v1(119.12,70.23)
XDS110_BUF_SELN: length 195.5
  TOP w0.127: 9.03,141.85 8.77,141.59 U29.10 ; 9.03,141.85 10.52,141.85 10.72,141.64 U29.13 ; 9.03,141.85 8.77,142.1 8.77,144.46 9.62,145.31 ; 9.62,145.31 11.18,145.31 11.37,145.5 U29.1 ; 9.62,145.31 9.42,145.52 U29.4 9.42,147.74 v3(9.08,148.08) ; U10.22 13.84,174.36 13.63,174.15 v2(12.68,174.15) ; SW2.8 v2(145.27,170.25)
  L3-SIGNAL1 w0.089: v3(9.08,148.08) 9.08,153.8 9.94,154.66 9.94,168.55 12.2,170.81 12.2,173.67 v2(12.68,174.15) 13.61,175.08 16.33,175.08 18.52,177.27 19.78,177.27 21.83,175.22 27.16,175.22 31.89,170.48 38.54,170.48 41.37,173.32 48.12,173.32 53.76,178.96 59.91,178.96 61.27,180.32 v2(61.27,181.87)
  L7-SIGNAL3 w0.109: v2(61.27,181.87) 61.34,181.8 62.46,181.8 65.4,184.73 78.27,184.73 86.19,176.82 125.12,176.82 130.84,171.1 139.03,171.1 140.41,169.72 144.74,169.72 v2(145.27,170.25)
XDS110_EMU0: length 83.3
  TOP w0.127: U47.10 26.24,102.23 v2(25.59,101.58)
  L12-SIGNAL5 w0.102: v2(25.59,101.58) 25.16,102 23.03,102 22.81,102.22 17.79,102.22 15.92,104.09 15.92,120.65 7.27,129.3 7.27,148.44 6.77,148.94 6.77,157.47 5.93,158.32 5.93,165.75 v2(7.46,167.29)
  BOTTOM w0.127: v2(7.46,167.29) 7.83,167.66 U170.42
XDS110_EMU1: length 84.7
  TOP w0.127: U47.13 v2(26.6,104.18)
  L12-SIGNAL5 w0.102: v2(26.6,104.18) 24.65,102.22 23.21,102.22 22.99,102.45 17.88,102.45 16.14,104.19 16.14,120.82 7.5,129.47 7.5,148.53 6.99,149.03 6.99,157.61 6.21,158.39 6.21,165.42 7.9,167.11 7.9,168 v2(7.46,168.43)
  BOTTOM w0.127: v2(7.46,168.43) 7.84,168.06 U170.43
XDS110_PROG_STAZ1: length 30.4
  L12-SIGNAL5 w0.102: v2(21.01,171.15) 21.01,171.24 20.32,171.93 20.32,179.45 26.1,185.23 30.08,185.23 v2(30.29,185.02)
  BOTTOM w0.127: U170.4 22.06,165.12 22.07,165.13 22.07,165.47 22.06,165.48 22.06,165.62 22.5,166.06 22.5,169.67 v2(21.01,171.15)
XDS110_PROG_STAZ2: length 32.9
  L12-SIGNAL5 w0.102: v2(30.29,187.68) 28.2,187.68 20.05,179.53 20.05,171.51 20.84,170.72 21.55,170.72 v2(21.85,171.03)
  BOTTOM w0.127: v2(21.85,171.03) 22.74,170.14 22.74,165.84 22.37,165.47 22.37,163.7 22.46,163.61 U170.3
XDS110_TCK: length 72.7
  TOP w0.127: U47.3 23.93,104.83 v2(24.58,104.18)
  L12-SIGNAL5 w0.102: v2(8.05,164.64) 7.15,163.74 7.15,158.77 8.13,157.79 8.13,150.18 8.44,149.86 8.44,130.02 17.13,121.33 17.13,111.34 22.58,105.89 22.58,104.97 23.38,104.18 v2(24.58,104.18)
  BOTTOM w0.127: v2(8.05,164.64) 8.27,164.86 U170.35
XDS110_TDI: length 71.2
  L12-SIGNAL5 w0.102: v2(7.1,165.66) 6.45,165.02 6.45,158.51 7.22,157.75 7.22,149.13 7.72,148.62 7.72,129.56 16.41,120.87 16.41,109 v2(19.93,105.48)
  BOTTOM w0.127: U206.6 20.58,104.83 v2(19.93,105.48) ; v2(7.1,165.66) 7.59,166.15 8.29,166.15 8.38,166.06 U170.38
XDS110_TDO: length 72.2
  L12-SIGNAL5 w0.102: v2(21,102.88) 21,104.31 20.37,104.94 20.37,107.37 16.69,111.05 16.69,121.09 7.94,129.83 7.94,148.72 7.44,149.22 7.44,157.84 6.68,158.61 6.68,164.84 7.06,165.23 7.63,165.23 v2(8.06,165.66)
  BOTTOM w0.127: U206.3 v2(21,102.88) ; U170.37 v2(8.06,165.66)
XDS110_TMS: length 82.5
  L12-SIGNAL5 w0.102: v2(7.1,164.65) 6.9,164.46 6.9,158.7 7.66,157.94 7.66,149.31 8.17,148.81 8.17,129.92 16.91,121.18 16.91,111.21 22.11,106.01 22.11,103.73 23.39,102.45 24.41,102.45 25.97,104 25.97,104.15 27.07,105.26 29.8,105.26 v2(30.23,104.83)
  BOTTOM w0.127: v2(7.1,164.65) 7.6,165.16 8.24,165.16 8.34,165.26 U170.36 ; U206.10 29.58,105.48 v2(30.23,104.83)
XDS110_TRST#: length 75.3
  TOP w0.127: U47.6 v2(23.57,102.88)
  L12-SIGNAL5 w0.102: v2(10.55,166.86) 8.66,164.96 8.66,163.25 8.09,162.68 8.09,158.14 8.35,157.88 8.35,150.63 8.75,150.24 8.75,130.18 17.36,121.56 17.36,112.4 24.15,105.61 24.15,105.3 24.99,104.46 24.99,103.9 23.97,102.88 v2(23.57,102.88)
  BOTTOM w0.127: v2(10.55,166.86) U170.40
XDS110_VBUS_DET: length 3.2
  TOP w0.127: R69.2 v2(22.79,164.46)
  BOTTOM w0.127: U170.1 23.26,163.99 v2(22.79,164.46)
XDS_PM1_SCL: length 52.2
  TOP w0.127: U29.8 v3(7.47,139.15)
  L3-SIGNAL1 w0.089: v2(17.92,179.38) 17.92,180.08 17.48,180.52 16.14,180.52 14.28,178.66 13.57,178.66 6.18,171.27 6.18,159.94 7.25,158.88 7.25,146.66 7.47,146.44 v3(7.47,139.15)
  BOTTOM w0.127: v2(17.92,179.38) 17.66,179.13 U170.82
XDS_PM1_SDA: length 50.9
  TOP w0.127: U29.11 v3(9.42,139.15)
  L3-SIGNAL1 w0.089: v2(17.26,179.84) 17.26,179.84 15.78,179.84 14.36,178.41 13.8,178.41 7.04,171.65 7.04,167.89 6.64,167.49 6.64,159.92 7.55,159 7.55,146.81 9.42,144.94 v3(9.42,139.15)
  BOTTOM w0.127: U170.81 v2(17.26,179.84)
XDS_PM2_SCL: length 29.9
  TOP w0.127: U29.3 v3(10.07,148.08)
  L3-SIGNAL1 w0.089: v2(7.46,170.21) 7.46,169.38 9.28,167.56 9.28,160.69 7.78,159.19 7.78,147.88 8.03,147.62 9.62,147.62 v3(10.07,148.08)
  BOTTOM w0.127: v2(7.46,170.21) 8.06,170.21 8.3,170.46 8.9,170.46 U170.49
XDS_PM2_SDA: length 28.4
  TOP w0.127: U29.6 v3(8.12,148.08)
  L3-SIGNAL1 w0.089: v2(7.46,171.36) 9.52,169.3 9.52,160.51 8.12,159.11 v3(8.12,148.08)
  BOTTOM w0.127: U170.50 7.96,170.86 v2(7.46,171.36)
XDS_RBIAS: length 2.1
  TOP w0.127: R22.1 8.17,174.26 v2(8.17,174.26)
  BOTTOM w0.127: v2(8.17,174.26) 8.37,174.46 U170.59
XDS_RESET#: length 6.8
  BOTTOM w0.127: U170.70 12.86,177.96 12.86,179.22 13.81,180.17 R741.1 13.81,182.91 R736.2 R735.1
XDS_SHIELD:
  vias: v2(16.3,186.75) v2(23.92,186.75)
XDS_TA_BM_IOEXP_RSTN: length 10
  TOP w0.127: U10.15 18.39,176.46 17.72,177.13 17.72,178.73 16.58,179.86 15.25,179.86 14.73,179.35 v2(13.64,179.35)
  BOTTOM w0.127: v2(13.64,179.35) 13.26,178.98 13.26,177.96 U170.71
XDS_TA_BOOTMODE_CNTL#: length 11.7
  TOP w0.127: v2(13.14,173.31) 13.71,172.74 16.83,172.74 17.74,173.65 U10.16
  BOTTOM w0.127: v2(13.14,173.31) 13.66,173.83 13.66,177.96 U170.72
XDS_TA_PORZN: length 5.6
  TOP w0.127: v2(15.66,174.04) 15.26,174.04 15.14,174.17 U10.20
  BOTTOM w0.127: U170.77 v2(15.66,174.04)
XDS_TA_POWERDOWNZ: length 5.9
  TOP w0.127: v2(15.84,179.25) 15.84,178.19 14.49,176.84 U10.21
  BOTTOM w0.127: v2(15.84,179.25) 16.06,179.02 U170.78
XDS_TA_RESETZ: length 3.4
  TOP w0.127: v2(15.05,176.69) 15.63,176.69 15.79,176.53 U10.19
  BOTTOM w0.127: U170.76 15.26,176.91 v2(15.05,176.69)
XDS_TA_SOC_INT1Z: length 7.5
  TOP w0.127: v2(14.65,174.04) 15.22,173.48 15.91,173.48 16.44,174.01 U10.18
  BOTTOM w0.127: v2(14.65,174.04) 14.46,174.23 14.46,177.96 U170.74
XDS_TA_SOC_INT2Z: length 9.7
  TOP w0.127: v2(14.06,173.32) 14.28,173.11 16.67,173.11 17.09,173.53 U10.17
  BOTTOM w0.127: U170.73 14.06,177.96 v2(14.06,173.32)
XDS_USB_D_N: length 14.3
  TOP w0.114: J1.2 19.46,185.62 19.65,185.43 19.65,185.25 v3(19.41,185.01) 19.65,184.76 19.65,184.46 U2.2
  L3-SIGNAL1 w0.091: v2(21.91,176.19) 22.16,176.44 22.16,177.65 19.67,180.13 19.67,184.75 v3(19.41,185.01)
  BOTTOM w0.114: v2(21.91,176.19) 22.13,176.42 22.13,177.05 22.06,177.11 U170.93
XDS_USB_D_P: length 14.3
  TOP w0.114: U2.1 19.92,184.46 19.92,184.76 v3(20.17,185.01) 19.92,185.25 19.92,185.43 20.11,185.62 J1.3
  L3-SIGNAL1 w0.091: v3(20.17,185.01) 19.89,184.72 19.89,180.22 22.37,177.74 22.37,176.44 v2(22.62,176.19)
  BOTTOM w0.114: U170.94 22.46,177.12 22.4,177.06 22.4,176.42 v2(22.62,176.19)
XDS_USB_ID: length 11.4
  TOP w0.127: J1.4 20.76,186.39 20.76,184.71 20.81,184.67 v3(20.81,184.13)
  L3-SIGNAL1 w0.089: v3(19.04,183.75) 18.7,184.08 18.7,184.88 19.34,185.52 20.23,185.52 20.81,184.94 v3(20.81,184.13) 23.16,181.78 v2(23.16,180.63)
XDS_VREF: length 6
  TOP w0.254: v2(20.06,164.6) C50.1 R52.2 20.81,166.89 20.91,166.78 U13.3
  BOTTOM w0.254: v2(20.06,164.6) U170.9
N16818967: length 6.6
  BOTTOM w0.127: R831.2 208.59,146.57 208.07,147.09 D41.1 208.07,148.8 207.78,149.08 207.78,150.65 208.12,151 208.12,151.61 U179.1
N19376907: length 2.7
  TOP w0.127: R395.2 116.17,59.87 C262.1 116.18,58.8 Y5.3
N19376959: length 2.5
  TOP w0.127: R402.2 C268.1 119.39,61.48 Y5.1
N22857883: length 2
  TOP w0.127: R454.2 SW7.13
N22857884: length 2
  TOP w0.127: R460.2 SW7.14
N22857885: length 2
  TOP w0.127: R467.2 SW7.15
N22857886: length 2.1
  TOP w0.127: R474.2 46.78,59.34 48.72,59.34 SW7.16
N22857888: length 2
  TOP w0.127: R435.2 SW7.10
N22857889: length 2
  TOP w0.127: R441.2 SW7.11
N22857890: length 2
  TOP w0.127: SW7.12 R450.2
N23037276: length 2
  TOP w0.127: R529.2 SW11.13
N23037278: length 2
  TOP w0.127: R536.2 SW11.14
N23037280: length 2
  TOP w0.127: R548.2 SW11.15
N23037282: length 2
  TOP w0.127: R553.2 SW11.16
N23037308: length 2
  TOP w0.127: R483.2 SW11.9
N23037310: length 2
  TOP w0.127: R496.2 SW11.10
N23037312: length 2
  TOP w0.127: R502.2 SW11.11
N23037314: length 2
  TOP w0.127: R514.2 SW11.12
N23191902: length 1.9
  TOP w0.127: R725.1 LD11.1
N23195767: length 1.9
  TOP w0.127: R727.1 LD12.1
N23200398: length 3.7
  BOTTOM w0.127: R749.1 24.34,179.79 C552.1 24.3,179.45 24.06,179.2 23.48,179.2 23.26,178.99 U170.96
N23200403: length 2
  BOTTOM w0.127: U170.95 22.86,179.03 23.16,179.32 R750.1
N23200423: length 3.5
  BOTTOM w0.127: R770.2 R768.1 8.04,174.86 U170.60
N23200491: length 1.4
  TOP w0.127: LD1.2 R5.2
N23200507: length 4.5
  BOTTOM w0.127: R756.2 R761.1 7.76,177.58 7.98,177.35 7.98,176.18 8.11,176.06 U170.63
N23200509: length 2.9
  TOP w0.127: R15.2 v2(11.25,175.26)
  BOTTOM w0.127: U170.61 v2(11.25,175.26)
N23200516: length 3.3
  BOTTOM w0.127: U170.62 7.97,175.66 7.6,175.29 R767.1 R762.2
N23200616: length 1.4
  TOP w0.127: LD6.2 R7.1
N23320850: length 5
  TOP w0.127: R99.1 86.33,157.94 v3(86.33,156.75)
  L3-SIGNAL1 w0.089: v3(86.33,156.75) 86.34,156.74 v3(90.12,156.74)
N23722671: length 2.5
  BOTTOM w0.127: R813.1 R811.1 R812.1
N23768120: length 39.7
  L14-SIGNAL6 w0.089: v2(17.97,137.87) 18.81,137.03 18.81,132.92 22.87,128.86 33.66,128.86 v2(34.59,127.93)
  BOTTOM w0.127: v2(34.59,127.93) 34.63,127.97 R882.1 39.82,127.97 40.3,128.45 R879.1
N23955014: length 1.5
  TOP w0.127: LD4.2 R3.2
N24011787: length 14.6
  L3-SIGNAL1 w0.127: v3(226.61,93.94) 227.02,93.94 227.27,94.2 227.27,95.05 226.49,95.83 216.51,95.83 216.07,96.27 216.07,97 215.99,97.09 v3(215.58,97.09)
N24011809: length 4.4
  TOP w0.127: U46.5 215.81,100.67 215.73,100.59 C234.2 215.73,99.05 R289.1
N24011946: length 18.1
  L3-SIGNAL1 w0.254: v3(218.84,124.59) 218.55,124.59 218.3,124.34 218.3,123.81 219.67,122.44 219.67,113.65 217.15,111.13 215.23,111.13 v3(214.76,111.6)
N24012043: length 3.2
  TOP w0.127: U46.26 215.81,108.87 215.68,109 C202.1 215.68,110.41 R245.1
N24016673: length 2.8
  TOP w0.127: C439.1 114.06,23.83 114.32,23.57 U138.7
N24017280: length 2.8
  BOTTOM w0.127: C1220.1 61.84,19.35 61.73,19.46 60.77,19.46 60.5,19.73 U266.7
N24020919: length 11.4
  TOP w0.127: v2(95.03,21.63) 95.06,21.6 v2(103.69,21.6)
  BOTTOM w0.127: v2(95.03,21.63) 95.03,22.1 95.19,22.27 95.86,22.27 U261.13 ; U261.48 102.86,22.27 103.5,22.27 103.69,22.08 v2(103.69,21.6)
N24026991: length 1.7
  TOP w0.127: U9.1 42.04,171.24 42.04,170.12 R46.1
N24026992: length 1.7
  BOTTOM w0.127: R740.1 57.23,182.56 56.97,182.3 56.97,182.3 U160.1
N24132464: length 2
  TOP w0.127: R279.2 211.38,99.11 C238.1
N24135121: length 2.5
  TOP w0.254: C194.1 210.97,110.89 211.9,109.96 211.96,109.96 R253.1
N24222943: length 37.7
  L14-SIGNAL6 w0.089: v2(206.33,154.16) 193.33,167.16 v2(193.33,185.5)
  BOTTOM w0.127: v2(206.33,154.16) 206.58,153.91 U179.3
N24223544: length 1.5
  TOP w0.127: LD5.2 R4.2
N24353848: length 1.5
  BOTTOM w0.127: U253.4 R1180.2
N24397394: length 2.7
  BOTTOM w0.127: C588.1 129.18,165.71 129.47,166 129.47,166.83 129.68,167.05 U174.7
N24401396: length 2.7
  BOTTOM w0.127: U169.7 106.37,172.8 106.16,173.01 105.32,173.01 105.03,173.29 C572.1
N24575373: length 13.8
  L14-SIGNAL6 w0.091: v11(138.55,178.73) 138.28,179 136.97,179 136.15,179.83 136.15,187.54 136.06,187.63 J2.2
  BOTTOM w0.114: L39.1 137.04,178.78 137.33,179.07 137.96,179.07 138.3,178.73 v11(138.55,178.73)
N24575375: length 13.7
  L14-SIGNAL6 w0.091: v11(138.55,179.68) 138.55,179.31 138.46,179.22 137.06,179.22 136.37,179.92 136.37,187.51 136.49,187.63 J2.3
  BOTTOM w0.114: v11(138.55,179.68) 138.3,179.68 137.96,179.34 137.31,179.34 137.02,179.63 L39.4
N24594316: length 2.2
  TOP w0.127: U241.8 124.79,48.98 124.63,49.14 R1118.2
N25567208: length 1.7
  TOP w0.127: R639.2 118.6,24.59 118.08,24.07 U138.5
N25567428: length 2
  BOTTOM w0.127: U266.5 61,23.59 61.17,23.76 61.65,23.76 61.78,23.88 R1242.2
N26384207: length 4.3
  BOTTOM w0.127: U252.6 U251.4
N26384397: length 1.6
  TOP w0.127: U101.1 R563.2
N26384556: length 4.4
  TOP w0.127: U122.3 C405.1 157.92,30.43 158.47,29.88 R615.1 R620.2
N26385797: length 1.3
  TOP w0.127: R606.2 226.26,32.1 U113.5
N26472696:
  vias: v2(30.88,41.13)
N26836401: length 3.2
  TOP w0.127: U130.1 226.64,28.62 226.37,28.89 R612.1 R606.1
N26873381: length 2
  TOP w0.127: R430.2 SW7.9
N26961694: length 2
  TOP w0.127: SW2.20 R109.2
N26961704: length 2
  TOP w0.127: SW2.19 R108.2
N26961722: length 2
  TOP w0.127: SW2.18 R107.2
N26961724: length 2
  TOP w0.127: SW2.17 R106.2
N26961726: length 2
  TOP w0.127: SW2.16 R105.2
N26961744: length 2
  TOP w0.127: SW2.15 R104.2
N26964770: length 2
  TOP w0.127: SW2.14 R103.2
N26964936: length 2
  TOP w0.127: SW2.13 R102.2
N26964939: length 2
  TOP w0.127: SW2.12 R101.2
N26964942: length 2
  TOP w0.127: SW2.11 R100.2
N27350045: length 1.5
  TOP w0.127: LD3.2 R2.2
N27350452: length 1.5
  TOP w0.127: R1.2 LD2.2
N27366714: length 3.8
  BOTTOM w0.127: U252.3 13.71,44.44 13.57,44.58 13.57,46.19 13.73,46.36 U247.4
N27374629: length 1.8
  TOP w0.127: LD7.2 R184.2
N28043247: length 3.9
  BOTTOM w0.127: R763.1 158.16,176.12 158.4,175.88 159.88,175.88 160.13,176.13 U161.2
N28381888: length 107.9
  L3-SIGNAL1 w0.089: v2(141.25,179.68) 140.85,179.28 140.85,172.99 139.79,171.92 139.79,171.91 138.94,171.07 130.23,171.07 127.09,174.2 124.99,174.2 123.8,175.39 101.75,175.39 101.38,175.76 87.73,175.76 73.49,161.52 61.94,161.52 57.85,165.61 v2(57.85,172.17)
  BOTTOM w0.127: v2(57.85,172.17) 57.88,172.14 58.99,172.14 R772.1
N28389101: length 1.4
  TOP w0.127: R21.2 154.82,174.82 U7.2
N30006402: length 2.4
  TOP w0.127: R618.2 v2(159.86,29.47)
  BOTTOM w0.127: U255.6 159.94,30.04 159.86,29.97 v2(159.86,29.47)
N30969363: length 4
  TOP w0.127: v2(165.85,32.4) 165.55,32.1 U124.1
  BOTTOM w0.127: v2(165.85,32.4) 164.99,31.54 U258.4
N32640257: length 11.4
  TOP w0.127: v2(78.04,21.6) 69.4,21.6 v2(69.37,21.63)
  BOTTOM w0.127: v2(69.37,21.63) 69.37,22.1 69.54,22.27 70.21,22.27 U262.13 ; v2(78.04,21.6) 78.04,22.08 77.85,22.27 77.21,22.27 U262.48
N32706667: length 2.7
  BOTTOM w0.127: R858.1 C681.1 119.16,133.31 118.95,133.51 U183.3
N32707436: length 4
  BOTTOM w0.127: U187.2 110.52,121.34 110.65,121.22 C713.1 110.65,120.84 R914.1 R913.2
N33033037: length 1.9
  BOTTOM w0.127: R949.1 29.16,103.95 28.93,104.18 U206.12
N33102148: length 6.3
  TOP w0.127: U78.3 v2(27.57,62.85) ; v2(29.9,61.33) 28.24,61.33 28.07,61.17 U78.7
  BOTTOM w0.127: v2(29.9,61.33) 29.08,61.33 v2(27.57,62.85)
N33104471: length 2.2
  BOTTOM w0.127: U268.15 229.55,23.91 R1243.1
N33174192: length 2.7
  TOP w0.127: U86.1 72,53.27 v2(72,53.27)
  BOTTOM w0.127: R1136.1 71.99,53.28 v2(72,53.27) 71.97,53.24 R1139.2
N33174210: length 3.7
  TOP w0.127: v2(70.87,50.58) 71.05,50.76 U86.2
  BOTTOM w0.127: R1141.1 70.84,51.72 R1140.2 70.93,50.63 v2(70.87,50.58)
N33175937: length 24.4
  L3-SIGNAL1 w0.089: v3(127.12,68.63) 127.12,63.32 126.47,62.68 126.47,57.86 133.59,50.75 v2(134.93,50.75)
  BOTTOM w0.127: R446.1 135.52,51.79 134.93,51.21 v2(134.93,50.75)
  vias: v1(127.12,68.63)
N33181549: length 1.3
  BOTTOM w0.127: U254.4 R1187.1
N33187905: length 3.2
  BOTTOM w0.127: R1042.1 26.34,76.27 26.67,75.93 U227.15
N33189610: length 1.9
  TOP w0.127: R345.2 43.5,87.55 43.69,87.73 U58.35
N33190088: length 1.3
  TOP w0.127: U50.16 51.06,102.08 v2(50.81,101.83)
N33442693: length 9.1
  TOP w0.127: v2(22.01,37.62) 20.08,35.69 16.67,35.69 16.03,35.05 SW13.1
N33442839: length 6.4
  TOP w0.127: v2(22.01,35.08) 18.02,35.08 17.3,34.37 SW13.2
N34186667: length 1.5
  TOP w0.127: U122.1 158.56,32.91 158.53,32.94 R600.2
N34514277: length 1.4
  TOP w0.127: R473.2 201.46,59.42 201.28,59.24 C305.1
N34514391: length 17.8
  TOP w0.127: v2(211.17,55.2) R488.2
  L12-SIGNAL5 w0.102: v2(211.17,55.2) 211.17,61.74 211.92,62.5 218.83,62.5 v2(219.9,63.56)
  BOTTOM w0.127: U240.4 v2(219.9,63.56)
N34888044: length 25.3
  L3-SIGNAL1 w0.254: v3(205.18,157.66) 204.83,158 204.83,158.99 198.62,165.2 185.72,165.2 185.01,165.91 185.01,166.42 v3(185.44,166.86)
N34888058: length 3.6
  TOP w0.127: R110.1 204.03,155.62 C94.2 204.15,154.56 203.97,154.38 U25.5
N34888105: length 25.4
  L3-SIGNAL1 w0.254: v3(205.06,143.52) 204.72,143.18 204.72,142.2 203.17,140.65 190.86,140.65 185.01,134.79 185.01,134.28 v3(185.44,133.84)
N34888129: length 3.1
  TOP w0.127: R150.1 203.92,144.98 204.03,145.09 C121.1 204.03,146.38 203.97,146.44 U25.26
N34899945: length 1.2
  TOP w0.127: R444.2 91.83,65.81 R440.1
N34899947: length 1.5
  TOP w0.127: D36.1 90.99,64.29 R440.2
N34900604: length 1.8
  TOP w0.127: U87.14 179.71,53.54 R486.2
N34900686: length 1.7
  TOP w0.127: R524.2 167,50.14 U89.14
N34917262: length 3.4
  TOP w0.381: R266.2 62.37,102.19 C224.1 C231.1 C233.1
N34917338: length 3.4
  TOP w0.127: C68.1 C69.1 C70.1 162.33,160.58 R93.2
N34917376: length 3.4
  TOP w0.381: R544.2 163.9,47.73 C349.1 C350.1 C351.1
N34917412: length 3.4
  TOP w0.381: C385.1 C384.1 C383.1 158.74,37.76 R580.2
N34917448: length 3.4
  TOP w0.254: R556.2 C362.1 C363.1 C364.1
N34917484: length 3.4
  TOP w0.254: C241.1 C242.1 C244.1 R323.2
N35193628: length 2
  BOTTOM w0.127: R1208.2 87.08,29.95 86.88,29.75 86.52,29.75 86.3,29.53 U260.5
N35193714: length 2.7
  BOTTOM w0.127: U260.7 85.8,25.77 86.01,25.56 86.85,25.56 87.14,25.27 C1196.1
N35201087: length 2.8
  TOP w0.127: C399.1 114.06,31.27 114.32,31.01 U125.7
N35210314: length 1.7
  TOP w0.127: U25.37 207.39,151.1 207.78,151.49 R133.1
N35214365: length 1.6
  TOP w0.127: v2(203.64,154.87) 203.47,154.7 U25.6
N35215938: length 1
  TOP w0.127: R117.1 C88.1
N35218154: length 3.2
  TOP w0.127: C103.1 209.43,152.73 208.82,152.13 207.91,152.13 207.38,151.6 U25.38
N35327993: length 3.2
  BOTTOM w0.127: U249.6 26.71,46.65 R1157.2 27.95,47.27 28.25,46.97 R1161.1
N35328046: length 2.8
  TOP w0.127: U124.6 R593.1 R588.2
N35592192: length 1.6
  TOP w0.127: U30.4 R154.1
N35592194: length 1.1
  TOP w0.127: R78.1 159.53,162.7 R80.2
N35592423: length 42.5
  TOP w0.127: U68.52 174.83,78.63 v2(174.56,78.9)
  L3-SIGNAL1 w0.089: v3(192.25,95.76) 191.95,95.46 187.89,95.46 186.65,94.22 177.1,94.22 170.95,88.07 169.69,88.07 166.73,85.11 166.73,83.01 169.1,80.65 171.99,80.65 173.74,78.9 v2(174.56,78.9)
N35593340: length 2
  TOP w0.127: LD10.1 187.68,65.79 R433.1
N35595852: length 32.5
  TOP w0.127: U36.1 180.09,122.97 179.1,123.96 v2(179.08,123.96) ; U37.1 191.26,122.97 191.12,123.12 191.12,123.73 190.94,123.91 v2(190.46,123.91) ; C158.2 167.23,123.79 167.36,123.92 C155.2 168.66,123.14 U35.1
  L12-SIGNAL5 w0.102: v2(190.46,123.91) 185.39,123.91 184.47,124.83 182.22,124.83 181.34,123.96 v2(179.08,123.96) 166.92,123.96 v2(166.76,123.8)
N35595856: length 34.6
  TOP w0.127: U36.10 183.21,120.62 183.59,121 183.59,121.69 v2(183.94,122.04) ; v2(172.73,121.12) 172.39,121.12 171.89,120.62 U35.10 ; U37.10 194.38,120.62 194.77,121 194.77,121.69 v2(195.12,122.04)
  L12-SIGNAL5 w0.102: v2(172.73,121.12) 174.09,122.49 181.03,122.49 182.82,120.69 183.28,120.69 183.94,121.35 v2(183.94,122.04) 184.36,122.47 192.81,122.47 193.64,121.64 194.71,121.64 v2(195.12,122.04)
  BOTTOM w0.127: R907.1 173.9,121.44 173.58,121.12 v2(172.73,121.12)
N35596954: length 1.2
  TOP w0.127: R186.2 167.26,124.93 167.35,124.84 C155.1
N35600802: length 14.8
  TOP w0.127: U48.1 72.08,101.52 71.94,101.38 v2(71.26,101.38) ; v2(71.23,111.49) 71.23,112 71.18,112.05 C189.2 71.33,112.7 U42.1
  L12-SIGNAL5 w0.102: v2(71.23,111.49) 71.23,101.41 v2(71.26,101.38)
N35600892: length 21.1
  TOP w0.127: v2(73.16,105.39) 73.74,105.39 74.48,104.66 U48.10 ; U42.10 74.48,115.83 74.07,116.24 73.76,116.24 R220.2 v2(73.38,117.76)
  L14-SIGNAL6 w0.089: v2(73.16,105.39) 70.8,107.75 70.8,116.09 72.48,117.76 v2(73.38,117.76)
N35601446: length 1.2
  TOP w0.127: R247.2 70.09,111.9 70.26,112.07 C189.1
N35603723: length 7.3
  TOP w0.127: 72.58,71.89 R417.2 72.58,72.88 72.71,73.01 73.82,73.01 74.48,72.35 74.48,71.35 74.86,70.98 U69.3 ; 72.58,71.89 72.58,71.75 72.8,71.52 U70.5 ; 72.58,71.89 72.15,71.46 U70.6
N35603798: length 3.8
  TOP w0.254: R406.1 82.35,75.36 C274.2 82.23,75.41 R410.2 80.96,75.22 U66.2
N35603915: length 3.8
  TOP w0.254: R237.2 110.37,112.39 C192.2 109.52,113.49 R235.1 109.48,114.01 109.2,114.29 U41.2
N35604551: length 2.2
  TOP w0.127: U75.6 84.2,66.33 84.65,65.88 84.65,64.9
N35604832: length 1.5
  TOP w0.127: U62.6 81.23,82.67 C255.1
N35605554: length 3.7
  TOP w0.254: R521.2 155.51,50.41 C334.2 155.55,51.43 R505.1 157.01,51.43 157.18,51.59 U85.2
N36263992: length 1.8
  BOTTOM w0.127: U186.5 85.28,130.19 R863.2
N36264078: length 2.9
  BOTTOM w0.127: U186.7 89.43,129.69 89.65,129.91 C686.1
N36834242: length 3
  BOTTOM w0.127: U216.1 174.95,91.23 174.51,90.79 R982.2 174.03,90.03 173.9,90.16 U217.3
N36841285: length 5
  BOTTOM w0.127: U234.1 R1122.2 R1123.2 R1111.2
N37510034: length 2.7
  TOP w0.127: R487.2 R547.1 180.21,52.76 U87.13
N37510108: length 1.7
  TOP w0.127: R512.2 167.03,50.64 U89.13
N37512355: length 1.5
  TOP w0.127: R653.1 235.87,22.21 SW16.8
N37512529: length 1.5
  TOP w0.127: R661.1 SW16.7
N37513072: length 1.5
  TOP w0.127: R664.1 SW16.6
N37514843: length 1.5
  TOP w0.127: R673.1 SW16.5
N37858028: length 1.5
  TOP w0.127: R49.1 13.19,168.1 U10.2
N37858624: length 4.2
  TOP w0.305: U29.14 C115.2 11.38,138.98 R1303.1
  TOP w0.381: R1304.1 R1303.1
N37948258: length 2.8
  BOTTOM w0.127: v2(14.58,180.66) 14.86,180.38 U170.75
N39003104: length 2.3
  TOP w0.127: SW4.4 R249.1
N39003106: length 2.3
  TOP w0.127: R222.1 SW4.3
N39039668: length 3.5
  TOP w0.254: R1295.1 83.4,82.5 R1297.2 83.88,81.63 84.22,81.97 85.14,81.97 85.31,81.8 U63.2
N40063454: length 2.6
  BOTTOM w0.127: U278.2 R1301.1 R1302.2
N40559760: length 1.6
  TOP w0.127: U279.3 77.86,68.79 78,68.92 R1309.2
N41254916: length 9.1
  TOP w0.127: 157.18,49.78 157.04,49.64 Q3.6 ; 157.18,49.78 157.54,49.78 157.69,49.63 Q3.5 ; 157.18,49.78 156.04,49.78 155.76,49.5 R1310.2 154.94,49.04 154.57,48.67 154.57,44.9 Q4.6
N262945201: length 1.8
  TOP w0.127: LD8.2 R207.2
N262947361: length 1.8
  TOP w0.127: LD9.2 R215.2

## Copper pours and planes (outline as drawn)
DGND on L3-SIGNAL1 (solid shape): 52.2,41.87 52.22,41.87 52.23,41.86 52.53,41.56 52.54,41.53 52.54,41.5 52.53,41.49 52.51,41.47 48.19,41.47 48.17,41.48 48.15,41.49 47.85,41.78 47.84,41.81 47.84,41.84 47.85,41.85 47.88,41.87
DGND on L3-SIGNAL1 (solid shape): 70.06,80.31 70.09,80.3 70.11,80.28 70.12,80.26 70.11,80.23 69.52,79.64 69.51,79.63 69.49,79.63 67.16,79.63 67.13,79.64 67.11,79.66 67.1,79.67 67.11,79.71 67.7,80.29 67.71,80.3 67.73,80.31
DGND on L3-SIGNAL1 (solid shape): 82.09,67.93 82.11,67.92 82.13,67.91 83.23,66.81 83.25,66.78 83.24,66.75 83.24,66.74 83.21,66.72 82.84,66.72 82.82,66.72 82.8,66.73 81.7,67.84 81.68,67.87 81.69,67.89 81.69,67.91 81.72,67.93
DGND on L3-SIGNAL1 (solid shape): 105.28,72.57 105.31,72.57 105.33,72.54 105.33,72.53 105.33,72.5 102.55,69.73 102.54,69.71 102.52,69.71 102.04,69.71 102.01,69.72 102,69.74 101.99,69.76 102,69.79 104.77,72.56 104.79,72.57 104.81,72.57
DGND on L3-SIGNAL1 (solid shape): 25.72,78.43 25.74,78.42 25.76,78.41 26.41,77.76 26.42,77.74 26.42,77.71 26.41,77.69 26.39,77.67 17.93,77.67 17.91,77.68 17.89,77.69 17.52,78.06 17.51,78.09 17.49,78.18 17.44,78.27 17.43,78.28 17.43,78.31 17.48,78.4 17.5,78.42 17.52,78.43
DGND on L3-SIGNAL1 (solid shape): 39.58,60.12 39.6,60.14 39.63,60.13 39.65,60.13 39.66,60.1 39.66,59.58 39.66,59.56 39.65,59.55 36.53,56.42 36.51,56.41 36.49,56.41 36.06,56.41 36.05,56.4 36.03,56.39 33.31,53.67 33.28,53.66 33.25,53.66 33.24,53.66 33.22,53.69 33.22,53.74 33.22,53.76 33.23,53.78
DGND on L3-SIGNAL1 (solid shape): 76.86,76.84 78.65,75.05 78.67,75.04 78.69,75.03 79.26,75.03 79.28,75.03 79.3,75.02 79.84,74.48 79.85,74.45 79.85,74.42 79.84,74.41 79.82,74.39 78.76,74.39 78.74,74.39 78.72,74.41 76.8,76.33 76.79,76.35 76.79,76.36 76.79,76.79 76.79,76.82 76.82,76.84 76.83,76.84
DGND on L3-SIGNAL1 (solid shape): 82.09,81.11 82.11,81.11 82.12,81.09 83.08,80.13 83.09,80.12 83.1,80.1 83.1,79.86 83.1,79.84 83.11,79.83 83.41,79.53 83.42,79.51 83.42,79.48 83.41,79.46 83.39,79.45 81.15,79.45 81.13,79.45 81.11,79.46 79.55,81.02 79.54,81.05 79.54,81.08 79.55,81.09 79.57,81.11
DGND on L3-SIGNAL1 (solid shape): 89.78,40.67 89.8,40.67 89.81,40.66 89.84,40.63 89.86,40.6 89.85,40.57 89.85,40.56 89.82,40.54 86.2,40.54 86.18,40.54 86.17,40.53 85.97,40.33 85.95,40.32 85.94,40.32 82.2,40.32 82.17,40.33 82.15,40.35 82.15,40.36 82.15,40.39 82.42,40.66 82.43,40.67 82.45,40.67
DGND on L3-SIGNAL1 (solid shape): 94.37,91.5 94.39,91.49 94.41,91.48 94.94,90.95 94.96,90.93 94.96,90.91 94.96,90.03 94.95,90 94.93,89.99 94.91,89.98 94.88,89.99 94.4,90.47 94.39,90.48 94.39,90.5 94.39,91.09 94.38,91.11 94.37,91.13 94.09,91.41 94.08,91.44 94.08,91.47 94.09,91.48 94.11,91.5
DGND on L3-SIGNAL1 (solid shape): 164.54,29.7 164.56,29.7 164.58,29.69 165.69,28.57 165.71,28.54 165.7,28.51 165.7,28.5 165.67,28.48 165.05,28.48 165.03,28.48 165.01,28.5 164.28,29.23 164.26,29.24 164.24,29.24 163.24,29.24 163.22,29.25 163.2,29.26 162.85,29.61 162.83,29.64 162.83,29.67 162.84,29.68 162.87,29.7
DGND on L3-SIGNAL1 (solid shape): 57.75,66.55 57.77,66.55 57.78,66.54 58.24,66.08 58.25,66.06 58.26,66.04 58.25,65.95 58.24,65.93 58.23,65.92 58.16,65.86 58.11,65.78 58.11,65.77 58.09,65.76 57.99,65.74 57.97,65.74 57.95,65.75 57.38,66.32 57.36,66.34 57.34,66.34 56.49,66.34 56.48,66.34 56.46,66.35 56.34,66.47 56.33,66.49 56.33,66.52 56.34,66.54 56.36,66.55
DGND on L3-SIGNAL1 (solid shape): 94.66,74.18 96.27,72.57 96.29,72.54 96.28,72.51 96.28,72.5 96.25,72.48 95.07,72.48 95.05,72.48 94.86,72.51 94.7,72.41 94.66,72.39 94.63,72.41 94.6,72.44 94.59,72.45 94.58,72.47 94.58,74.13 94.59,74.16 94.61,74.18 94.63,74.19
DGND on L3-SIGNAL1 (solid shape): 130.58,29.57 130.6,29.56 130.62,29.54 130.63,29.52 130.62,29.49 130.29,29.16 130.27,29.15 130.25,29.14 129.76,29.14 129.74,29.14 129.69,29.11 129.68,29.1 122.46,29.1 122.44,29.11 122.42,29.12 122.36,29.2 122.36,29.22 122.36,29.23 122.37,29.33 122.35,29.43 122.35,29.45 122.35,29.47 122.41,29.55 122.43,29.56 122.45,29.57
DGND on L3-SIGNAL1 (solid shape): 78.99,65.84 79,65.83 79.02,65.82 79.63,65.22 79.64,65.2 79.64,65.18 79.64,64.75 79.64,64.73 79.66,64.71 81.11,63.26 81.12,63.23 81.12,63.2 81.11,63.19 81.09,63.17 80.59,63.17 80.57,63.17 80.56,63.19 79.01,64.73 79,64.75 79,64.77 79,65.41 78.99,65.43 78.98,65.45 78.68,65.75 78.66,65.78 78.67,65.81 78.67,65.82 78.7,65.84
DGND on L3-SIGNAL1 (solid shape): 90.97,91.73 90.99,91.72 91.01,91.71 91.51,91.21 91.53,91.2 91.55,91.19 93.59,91.19 93.61,91.19 93.63,91.18 93.88,90.93 93.89,90.91 93.89,90.89 93.89,90.76 93.88,90.74 93.86,90.72 93.85,90.71 93.82,90.72 93.8,90.74 93.78,90.75 93.76,90.75 91.19,90.75 91.17,90.76 91.15,90.77 90.28,91.64 90.26,91.67 90.27,91.69 90.27,91.71 90.3,91.73
DGND on L3-SIGNAL1 (solid shape): 112.37,58.99 112.4,58.98 112.42,58.95 112.42,58.94 112.42,58.91 112.01,58.51 111.99,58.49 111.97,58.49 109.87,58.49 109.85,58.49 109.83,58.5 109.42,58.53 109.28,58.14 109.29,58.13 109.28,58.1 109.23,58.03 109.21,58.01 109.19,58.01 108.82,58.01 108.79,58.01 108.77,58.03 108.72,58.12 108.72,58.15 108.73,58.16 108.77,58.24 108.79,58.34 109.42,58.97 109.43,58.98 109.45,58.99
DGND on L3-SIGNAL1 (solid shape): 138.23,28.89 138.26,28.88 138.27,28.87 138.33,28.8 138.34,28.77 138.33,28.76 138.67,28.34 139,28.76 139,28.77 139,28.8 139.06,28.87 139.08,28.88 139.1,28.89 155.4,28.89 155.43,28.88 155.45,28.86 155.45,28.84 155.45,28.81 154.67,28.04 154.65,28.02 154.63,28.02 142.69,28.02 137.3,28.02 135.99,28.02 135.97,28.03 135.95,28.05 135.94,28.07 135.95,28.1 136.72,28.87 136.74,28.88 136.76,28.89
DGND on L3-SIGNAL1 (solid shape): 187,44.48 187.02,44.48 187.04,44.46 187.09,44.38 187.09,44.36 187.09,44.35 187.41,43.88 187.73,44.35 187.72,44.36 187.73,44.38 187.78,44.46 187.8,44.48 187.82,44.48 192.74,44.48 192.76,44.48 192.78,44.47 193.46,43.79 193.48,43.77 193.5,43.77 195.58,43.77 195.61,43.76 195.63,43.74 195.63,43.72 195.63,43.69 195.36,43.43 195.34,43.42 195.33,43.42 185.97,43.42 185.95,43.42 185.94,43.43 184.97,44.4 184.95,44.42 184.96,44.45 184.96,44.47 184.99,44.48
DGND on L3-SIGNAL1 (solid shape): 80.68,75.99 80.7,75.99 80.71,75.98 81.66,75.03 81.67,75.01 81.67,74.99 81.66,74.9 81.65,74.88 81.64,74.87 81.58,74.34 82.11,74.4 82.12,74.41 82.14,74.42 82.23,74.43 82.25,74.43 82.27,74.42 82.83,73.86 82.84,73.84 82.84,73.82 82.84,73.69 82.83,73.65 82.79,73.64 81.4,73.64 81.38,73.64 81.36,73.65 79.5,75.51 79.49,75.52 79.47,75.53 78.89,75.53 78.87,75.53 78.86,75.54 78.5,75.9 78.48,75.93 78.48,75.96 78.49,75.97 78.52,75.99
DGND on L3-SIGNAL1 (solid shape): 81.77,64.86 81.79,64.86 81.81,64.85 82.43,64.23 82.45,64.22 82.47,64.21 87.9,64.21 87.92,64.21 87.93,64.2 88.45,63.68 88.46,63.66 88.46,63.63 88.45,63.61 88.43,63.6 87.35,63.6 87.32,63.6 87.31,63.61 87.25,63.68 87.24,63.71 86.9,64.09 86.56,63.71 86.56,63.68 86.5,63.61 86.48,63.6 86.46,63.6 82.51,63.6 82.49,63.6 82.47,63.61 81.53,64.55 81.52,64.57 81.52,64.59 81.52,64.68 81.54,64.7 81.6,64.76 81.65,64.83 81.66,64.84 81.68,64.85
DGND on L3-SIGNAL1 (solid shape): 54.97,109.38 54.99,109.38 55.01,109.36 55.06,109.28 55.07,109.26 55.06,109.25 55.26,108.8 55.7,109 55.71,109.02 55.73,109.03 55.82,109.05 55.85,109.05 55.87,109.04 55.97,108.94 55.99,108.93 56.01,108.92 56.99,108.92 57.01,108.92 57.03,108.91 57.45,108.49 57.46,108.46 57.46,108.43 57.45,108.42 57.43,108.4 54.87,108.4 54.85,108.41 54.83,108.42 54.59,108.66 54.58,108.68 54.58,108.7 54.6,108.79 54.61,108.81 54.62,108.82 54.79,109 54.79,109.25 54.79,109.26 54.79,109.28 54.84,109.36 54.86,109.38 54.89,109.38
DGND on L3-SIGNAL1 (solid shape): 114.39,65.53 114.46,65.48 114.47,65.46 114.48,65.44 114.48,63.36 114.47,63.33 114.46,63.32 114.4,63.26 114.37,63.25 113.99,62.96 114.28,62.57 114.29,62.57 114.31,62.55 114.35,62.45 114.35,62.43 114.33,62.4 113.85,61.92 113.84,61.9 113.83,61.88 113.83,61.19 113.83,61.17 113.82,61.15 113.75,61.1 113.72,61.09 113.64,61.09 113.56,61.06 111.23,61.06 111.2,61.06 111.18,61.09 111.17,61.1 111.18,61.13 114.11,64.06 114.12,64.08 114.12,64.1 114.12,65.43 114.13,65.45 114.14,65.47 114.21,65.53 114.3,65.53 114.37,65.54
DGND on L3-SIGNAL1 (solid shape): 71.73,80.13 71.82,80.06 71.83,80.01 71.84,79.96 71.85,79.92 71.88,79.88 71.91,79.84 71.95,79.81 71.99,79.79 72.03,79.77 72.08,79.76 72.12,79.76 72.17,79.77 72.22,79.78 72.25,79.8 72.78,79.8 72.81,79.78 74.03,78.56 74.05,78.53 74.04,78.49 74.01,78.47 55.33,78.47 55.3,78.48 55.28,78.52 55.29,78.55 55.58,78.85 55.62,78.86 69.78,78.86 69.81,78.88 70.07,79.14 71.02,79.14 71.02,79.09 71.04,79.04 71.06,78.99 71.08,78.94 71.12,78.9 71.15,78.87 71.2,78.84 71.25,78.82 71.3,78.8 71.35,78.8 71.4,78.8 71.45,78.81 71.5,78.83 71.55,78.85 71.59,78.88 71.63,78.92 71.66,78.96 71.68,79.01 71.7,79.06 71.71,79.11 71.71,79.17 71.7,79.22 71.68,79.27 71.66,79.31 71.63,79.36 71.59,79.4 71.55,79.43 71.5,79.45 71.45,79.47 71.4,79.48 71.35,79.48 71.3,79.48 71.25,79.46 71.2,79.44 71.15,79.41 71.12,79.38 71.08,79.34 71.06,79.29 71.04,79.24 71.02,79.19 71.02,79.14 70.07,79.14 71.05,80.12 71.09,80.13
DGND on L3-SIGNAL1 (solid shape): 89.2,68.89 89.22,68.89 89.24,68.88 89.43,68.69 89.44,68.67 89.44,68.65 89.44,68.56 89.43,68.54 89.42,68.53 89.37,67.97 89.93,68.02 89.94,68.03 89.96,68.04 90.05,68.04 90.07,68.04 90.09,68.03 91.79,66.32 91.81,66.3 91.8,66.27 91.8,66.25 91.77,66.24 89.8,66.24 89.78,66.24 89.76,66.25 88.23,67.78 88.22,67.8 88.22,67.82 88.23,67.91 88.24,67.93 88.25,67.93 88.29,68.49 87.73,68.45 87.73,68.44 87.71,68.43 87.62,68.42 87.6,68.42 87.58,68.43 87.21,68.8 87.19,68.83 87.2,68.86 87.2,68.87 87.23,68.89
DGND on L3-SIGNAL1 (solid shape): 81.13,67.71 82.6,66.24 82.61,66.23 82.63,66.22 87.26,66.22 87.28,66.22 87.29,66.21 88.01,65.49 88.02,65.47 88.02,65.44 88.01,65.42 87.99,65.41 87.33,65.41 87.3,65.41 87.29,65.42 87.23,65.49 87.22,65.52 86.88,65.9 86.54,65.52 86.54,65.49 86.48,65.42 86.46,65.41 86.44,65.41 86.32,65.41 86.3,65.41 86.28,65.42 86.22,65.49 86.22,65.52 85.88,65.91 85.54,65.52 85.53,65.49 85.48,65.42 85.46,65.41 85.44,65.41 82.88,65.41 82.86,65.41 82.84,65.42 81.07,67.2 81.06,67.21 81.05,67.23 81.05,67.66 81.06,67.69 81.08,67.71 81.1,67.71
DGND on L3-SIGNAL1 (solid shape): 70.13,70.3 70.59,69.84 70.6,69.83 70.6,69.81 70.6,67.06 70.61,67.04 70.62,67.03 79.6,58.04 79.61,58.02 79.61,57.99 79.6,57.97 79.58,57.96 77.48,57.96 77.46,57.96 77.44,57.97 71.57,63.84 71.56,63.86 71.55,63.88 71.56,63.97 71.58,64 71.61,64.51 71.09,64.48 71.07,64.46 70.98,64.45 70.96,64.46 70.94,64.47 70.07,65.34 70.06,65.36 70.06,65.38 70.06,65.51 70.06,65.53 70.07,65.55 70.14,65.61 70.16,65.61 70.18,65.61 70.58,65.95 70.18,66.28 70.16,66.28 70.14,66.29 70.07,66.34 70.06,66.36 70.06,66.38 70.06,70.25 70.06,70.28 70.09,70.3 70.1,70.31
DGND on L3-SIGNAL1 (solid shape): outline of 84 points within 22.37,44.43 31.34,48.37
DGND on L3-SIGNAL1 (solid shape): outline of 88 points within 81.89,67.94 86.4,69.88
DGND on L3-SIGNAL1 (solid shape): 31.61,59.47 31.63,59.47 31.64,59.46 31.82,59.28 31.83,59.26 31.83,59.23 31.82,59.21 31.8,59.2 30.59,59.2 30.57,59.19 30.55,59.18 29.61,58.24 29.59,58.23 29.57,58.22 15.33,58.22 15.3,58.23 15.29,58.24 15.23,58.32 15.22,58.34 15.24,58.43 15.66,58.85 15.68,58.86 15.7,58.86 21.96,58.86 21.98,58.86 22,58.84 22.06,58.78 22.06,58.75 22.4,58.37 22.74,58.75 22.75,58.78 22.8,58.84 22.82,58.86 22.84,58.86 24.62,58.86 24.64,58.86 24.66,58.85 24.87,58.63 24.89,58.62 24.91,58.62 27.33,58.62 27.35,58.62 27.37,58.63 28.06,59.32 28.08,59.34 28.11,59.34 28.21,59.3 28.23,59.28 28.23,59.27 28.62,58.98 28.91,59.36 28.92,59.39 28.98,59.45 28.99,59.47 29.01,59.47
DGND on L3-SIGNAL1 (solid shape): 74.63,77.25 75.26,76.62 75.27,76.6 75.27,76.58 75.27,75.02 75.27,74.99 75.26,74.98 75.19,74.92 75.16,74.91 75.15,74.92 74.74,74.54 75.24,74.28 75.25,74.29 75.29,74.28 75.85,73.72 75.86,73.7 75.86,73.67 75.82,73.57 75.8,73.55 75.79,73.55 75.48,73.06 76.02,72.87 76.04,72.88 76.07,72.88 76.28,72.67 76.3,72.64 76.29,72.61 76.29,72.6 76.26,72.58 75.31,72.58 75.29,72.58 75.28,72.6 75.14,72.73 75.13,72.75 75.13,72.77 75.13,72.86 75.14,72.88 75.15,72.89 75.23,73.4 74.71,73.48 74.7,73.47 74.67,73.47 74.58,73.51 74.56,73.53 74.55,73.56 74.55,77.21 74.56,77.24 74.58,77.25 74.6,77.26
DGND on L3-SIGNAL1 (solid shape): 90.05,69.45 90.07,69.45 90.08,69.43 90.14,69.36 90.15,69.34 90.15,69.33 90.48,68.93 90.82,69.33 90.82,69.34 90.83,69.36 90.88,69.43 90.9,69.45 90.92,69.45 91.42,69.45 91.44,69.45 91.46,69.44 92.28,68.62 92.29,68.6 92.29,68.58 92.29,68.5 92.28,68.48 92.27,68 92.74,67.92 92.76,67.92 92.79,67.92 93.86,66.85 93.88,66.84 93.9,66.83 96.45,66.83 96.47,66.83 96.49,66.82 96.55,66.74 96.55,66.72 96.54,66.65 96.54,66.56 96.48,66.5 96.46,66.48 96.44,66.48 92.36,66.48 92.34,66.48 92.32,66.49 91.08,67.73 91.07,67.76 91.07,67.78 91.08,67.87 91.1,67.89 91.11,67.9 91.21,68.49 90.62,68.39 90.61,68.38 90.59,68.36 90.5,68.35 90.48,68.35 90.46,68.36 89.45,69.36 89.44,69.39 89.44,69.42 89.45,69.43 89.47,69.45
DGND on L3-SIGNAL1 (solid shape): 191.07,65.21 191.09,65.21 191.11,65.2 192.47,63.83 192.49,63.82 192.49,63.8 192.49,63.41 192.5,63.33 192.53,63.25 192.53,63.23 192.52,63.2 192.51,63.18 192.49,63.16 192.47,63.15 192.43,63.15 192.41,63.16 192.4,63.17 192.15,63.41 192.15,63.43 191.56,63.65 191.78,63.07 191.8,63.06 192.19,62.67 192.21,62.66 192.23,62.66 197.24,62.66 197.26,62.65 197.27,62.64 197.88,62.03 197.89,62.01 197.89,61.98 197.89,61.96 197.86,61.95 197.35,61.95 197.33,61.95 197.31,61.96 197.25,62.03 197.25,62.06 196.91,62.45 196.57,62.06 196.56,62.03 196.51,61.96 196.49,61.95 196.47,61.95 194.8,61.95 194.78,61.95 194.77,61.96 194.51,62.22 194.5,62.23 194.48,62.23 191.78,62.23 191.76,62.23 191.74,62.25 190.82,63.16 190.81,63.18 190.81,63.2 190.81,64.78 190.81,64.79 190.82,64.81 190.89,64.94 190.9,65.09 190.9,65.1 190.9,65.13 190.96,65.19 190.98,65.21 191,65.21
DGND on L3-SIGNAL1 (solid shape): outline of 132 points within 108.2,29.1 119.88,34.93
DGND on L3-SIGNAL1 (solid shape): 76.1,75.73 78.42,73.4 78.44,73.39 78.46,73.39 79.56,73.39 79.58,73.38 79.6,73.37 81.77,71.2 81.79,71.19 81.81,71.19 83.5,71.19 83.52,71.18 83.54,71.17 84.24,70.46 84.26,70.44 84.26,70.41 84.25,70.39 84.22,70.38 83.46,70.38 83.44,70.38 83.42,70.4 83.37,70.48 83.37,70.51 83.37,70.52 83.06,71.01 82.75,70.52 82.76,70.51 82.76,70.48 82.7,70.4 82.69,70.38 82.66,70.38 82.62,70.38 82.6,70.38 82.58,70.4 82.53,70.48 82.53,70.51 82.53,70.52 82.22,71.01 81.91,70.52 81.92,70.51 81.92,70.48 81.86,70.4 81.85,70.38 81.82,70.38 81.64,70.38 81.62,70.38 81.6,70.39 80.42,71.58 80.4,71.6 80.4,71.62 80.41,71.71 80.42,71.73 80.43,71.73 80.46,72.25 79.95,72.21 79.94,72.21 79.92,72.2 79.83,72.19 79.81,72.19 79.79,72.2 79,72.99 78.99,73 78.97,73.01 78.13,73.01 78.11,73.01 78.09,73.02 76.04,75.07 76.03,75.09 76.02,75.11 76.02,75.68 76.03,75.71 76.06,75.73 76.07,75.73
DGND on L3-SIGNAL1 (solid shape): outline of 144 points within 31.1,43.33 45.82,48.58
DGND on L3-SIGNAL1 (solid shape): outline of 146 points within 39.21,66.52 48.95,74.4
